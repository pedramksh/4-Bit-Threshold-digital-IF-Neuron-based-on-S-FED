`include "constants.vams"
`include "disciplines.vams"

module SFED(d, gs, gd, s, b);
    inout d, gs, gd, s, b; // Drain, Gates, Source , Bulk
    electrical d, gs, gd, s, b;


// --------------------------------------------------    IDS_START	    --------------------------------------------------
    localparam integer vds_width_int = 201;
    parameter real vds_points[0:vds_width_int-1] =  // Vds range in volts
	{
	-4.000000000e-001
	,-3.900000000e-001
	,-3.800000000e-001
	,-3.700000000e-001
	,-3.600000000e-001
	,-3.500000000e-001
	,-3.400000000e-001
	,-3.300000000e-001
	,-3.200000000e-001
	,-3.100000000e-001
	,-3.000000000e-001
	,-2.900000000e-001
	,-2.800000000e-001
	,-2.700000000e-001
	,-2.600000000e-001
	,-2.500000000e-001
	,-2.400000000e-001
	,-2.300000000e-001
	,-2.200000000e-001
	,-2.100000000e-001
	,-2.000000000e-001
	,-1.900000000e-001
	,-1.800000000e-001
	,-1.700000000e-001
	,-1.600000000e-001
	,-1.500000000e-001
	,-1.400000000e-001
	,-1.300000000e-001
	,-1.200000000e-001
	,-1.100000000e-001
	,-1.000000000e-001
	,-9.000000000e-002
	,-8.000000000e-002
	,-7.000000000e-002
	,-6.000000000e-002
	,-5.000000000e-002
	,-4.000000000e-002
	,-3.000000000e-002
	,-2.000000000e-002
	,-1.000000000e-002
	,0
	,1.000000000e-002
	,2.000000000e-002
	,3.000000000e-002
	,4.000000000e-002
	,5.000000000e-002
	,6.000000000e-002
	,7.000000000e-002
	,8.000000000e-002
	,9.000000000e-002
	,1.000000000e-001
	,1.100000000e-001
	,1.200000000e-001
	,1.300000000e-001
	,1.400000000e-001
	,1.500000000e-001
	,1.600000000e-001
	,1.700000000e-001
	,1.800000000e-001
	,1.900000000e-001
	,2.000000000e-001
	,2.100000000e-001
	,2.200000000e-001
	,2.300000000e-001
	,2.400000000e-001
	,2.500000000e-001
	,2.600000000e-001
	,2.700000000e-001
	,2.800000000e-001
	,2.900000000e-001
	,3.000000000e-001
	,3.100000000e-001
	,3.200000000e-001
	,3.300000000e-001
	,3.400000000e-001
	,3.500000000e-001
	,3.600000000e-001
	,3.700000000e-001
	,3.800000000e-001
	,3.900000000e-001
	,4.000000000e-001
	,4.100000000e-001
	,4.200000000e-001
	,4.300000000e-001
	,4.400000000e-001
	,4.500000000e-001
	,4.600000000e-001
	,4.700000000e-001
	,4.800000000e-001
	,4.900000000e-001
	,5.000000000e-001
	,5.100000000e-001
	,5.200000000e-001
	,5.300000000e-001
	,5.400000000e-001
	,5.500000000e-001
	,5.600000000e-001
	,5.700000000e-001
	,5.800000000e-001
	,5.900000000e-001
	,6.000000000e-001
	,6.100000000e-001
	,6.200000000e-001
	,6.300000000e-001
	,6.400000000e-001
	,6.500000000e-001
	,6.600000000e-001
	,6.700000000e-001
	,6.800000000e-001
	,6.900000000e-001
	,7.000000000e-001
	,7.100000000e-001
	,7.200000000e-001
	,7.300000000e-001
	,7.400000000e-001
	,7.500000000e-001
	,7.600000000e-001
	,7.700000000e-001
	,7.800000000e-001
	,7.900000000e-001
	,8.000000000e-001
	,8.100000000e-001
	,8.200000000e-001
	,8.300000000e-001
	,8.400000000e-001
	,8.500000000e-001
	,8.600000000e-001
	,8.700000000e-001
	,8.800000000e-001
	,8.900000000e-001
	,9.000000000e-001
	,9.100000000e-001
	,9.200000000e-001
	,9.300000000e-001
	,9.400000000e-001
	,9.500000000e-001
	,9.600000000e-001
	,9.700000000e-001
	,9.800000000e-001
	,9.900000000e-001
	,1.000000000e+000
	,1.010000000e+000
	,1.020000000e+000
	,1.030000000e+000
	,1.040000000e+000
	,1.050000000e+000
	,1.060000000e+000
	,1.070000000e+000
	,1.080000000e+000
	,1.090000000e+000
	,1.100000000e+000
	,1.110000000e+000
	,1.120000000e+000
	,1.130000000e+000
	,1.140000000e+000
	,1.150000000e+000
	,1.160000000e+000
	,1.170000000e+000
	,1.180000000e+000
	,1.190000000e+000
	,1.200000000e+000
	,1.210000000e+000
	,1.220000000e+000
	,1.230000000e+000
	,1.240000000e+000
	,1.250000000e+000
	,1.260000000e+000
	,1.270000000e+000
	,1.280000000e+000
	,1.290000000e+000
	,1.300000000e+000
	,1.310000000e+000
	,1.320000000e+000
	,1.330000000e+000
	,1.340000000e+000
	,1.350000000e+000
	,1.360000000e+000
	,1.370000000e+000
	,1.380000000e+000
	,1.390000000e+000
	,1.400000000e+000
	,1.410000000e+000
	,1.420000000e+000
	,1.430000000e+000
	,1.440000000e+000
	,1.450000000e+000
	,1.460000000e+000
	,1.470000000e+000
	,1.480000000e+000
	,1.490000000e+000
	,1.500000000e+000
	,1.510000000e+000
	,1.520000000e+000
	,1.530000000e+000
	,1.540000000e+000
	,1.550000000e+000
	,1.560000000e+000
	,1.570000000e+000
	,1.580000000e+000
	,1.590000000e+000
	,1.600000000e+000
	};

	localparam integer vgs_width_int = 21;
    parameter real vgs_points[0:vgs_width_int-1] =	// Vgs range in volts
	{
		-0.4,
		-0.3,
		-0.2,
		-0.1,
		0.0,
		0.1,
		0.2,
		0.3,
		0.4,
		0.5,
		0.6,
		0.7,
		0.8,
		0.9,
		1.0,
		1.1,
		1.2,
		1.3,
		1.4,
		1.5,
		1.6
	};
	localparam integer vgd_width_int = 21;
    parameter real vgd_points[0:vgd_width_int-1] = // Vgd range in volts
	{
		-0.4,
		-0.3,
		-0.2,
		-0.1,
		0.0,
		0.1,
		0.2,
		0.3,
		0.4,
		0.5,
		0.6,
		0.7,
		0.8,
		0.9,
		1.0,
		1.1,
		1.2,
		1.3,
		1.4,
		1.5,
		1.6
	};
    // Sample Ids data: Each row corresponds to a fixed Vgs, columns vary Vds
    parameter real table_ids[0 : vds_width_int*vgs_width_int*vgd_width_int-1] = 
	{
	-4.621722094e-008
	,-4.267057168e-008
	,-3.928692795e-008
	,-3.606283346e-008
	,-3.314413134e-008
	,-3.049730178e-008
	,-2.809272975e-008
	,-2.590496377e-008
	,-2.373706366e-008
	,-2.175879487e-008
	,-1.995647225e-008
	,-1.831336136e-008
	,-1.681443320e-008
	,-1.544603897e-008
	,-1.413483253e-008
	,-1.294521426e-008
	,-1.186760176e-008
	,-1.088954846e-008
	,-1.000025600e-008
	,-9.190346079e-009
	,-8.451613215e-009
	,-7.776827084e-009
	,-7.159520115e-009
	,-6.594015783e-009
	,-6.075132534e-009
	,-5.598126407e-009
	,-5.158619661e-009
	,-4.752519618e-009
	,-4.375850277e-009
	,-4.024662488e-009
	,-3.694891162e-009
	,-3.382178891e-009
	,-3.081649410e-009
	,-2.787615021e-009
	,-2.493178368e-009
	,-2.173294363e-009
	,-1.837052238e-009
	,-1.473744435e-009
	,-1.064361493e-009
	,-5.840842098e-010
	,3.393894272e-018
	,7.319769383e-010
	,1.671283229e-009
	,2.898376332e-009
	,4.501695949e-009
	,6.530403714e-009
	,9.189614428e-009
	,1.269424080e-008
	,1.732986876e-008
	,2.347578187e-008
	,3.163520524e-008
	,4.247486570e-008
	,5.687646861e-008
	,7.600324677e-008
	,1.013853001e-007
	,1.350278812e-007
	,1.795472970e-007
	,2.383385847e-007
	,3.156729026e-007
	,4.171255815e-007
	,5.498057312e-007
	,7.225468201e-007
	,9.462622629e-007
	,1.234228837e-006
	,1.602313298e-006
	,2.069094714e-006
	,2.655830583e-006
	,3.386219869e-006
	,4.285934355e-006
	,5.381921601e-006
	,6.701523531e-006
	,8.271494367e-006
	,1.011702858e-005
	,1.226090827e-005
	,1.472282067e-005
	,1.751908851e-005
	,2.066123385e-005
	,2.415837000e-005
	,2.801698337e-005
	,3.224011180e-005
	,3.682824711e-005
	,4.178060133e-005
	,4.709465596e-005
	,5.276682608e-005
	,5.879275250e-005
	,6.516755622e-005
	,7.188603195e-005
	,7.894279251e-005
	,8.633237189e-005
	,9.404928391e-005
	,1.020880679e-004
	,1.104433553e-004
	,1.191098207e-004
	,1.280820948e-004
	,1.373439710e-004
	,1.468795245e-004
	,1.566997739e-004
	,1.667992100e-004
	,1.771723214e-004
	,1.878004035e-004
	,1.982912832e-004
	,2.090252564e-004
	,2.199850387e-004
	,2.311619191e-004
	,2.425596316e-004
	,2.541722275e-004
	,2.659941092e-004
	,2.780200097e-004
	,2.902449782e-004
	,3.026643691e-004
	,3.152736835e-004
	,3.280068998e-004
	,3.408361520e-004
	,3.538242162e-004
	,3.669662944e-004
	,3.802582630e-004
	,3.936965330e-004
	,4.072770421e-004
	,4.209961843e-004
	,4.348341760e-004
	,4.488011569e-004
	,4.628970780e-004
	,4.771194177e-004
	,4.914658492e-004
	,5.059342256e-004
	,5.197888489e-004
	,5.336001659e-004
	,5.475274887e-004
	,5.615698346e-004
	,5.757263954e-004
	,5.899823739e-004
	,6.042884120e-004
	,6.187034455e-004
	,6.332268074e-004
	,6.478579674e-004
	,6.625965252e-004
	,6.774422009e-004
	,6.923948282e-004
	,7.074543475e-004
	,7.226030514e-004
	,7.377816934e-004
	,7.530441961e-004
	,7.683632350e-004
	,7.837810754e-004
	,7.992980339e-004
	,8.149144865e-004
	,8.306308586e-004
	,8.464476107e-004
	,8.623652258e-004
	,8.783841952e-004
	,8.945050061e-004
	,9.107281268e-004
	,9.270540038e-004
	,9.434830445e-004
	,9.600156095e-004
	,9.766520065e-004
	,9.933924844e-004
	,1.010237229e-003
	,1.027186361e-003
	,1.044239934e-003
	,1.061397933e-003
	,1.078660277e-003
	,1.096026822e-003
	,1.113495432e-003
	,1.131067125e-003
	,1.148742109e-003
	,1.166520009e-003
	,1.184400403e-003
	,1.202382826e-003
	,1.220466776e-003
	,1.238651717e-003
	,1.256937082e-003
	,1.275322278e-003
	,1.293806689e-003
	,1.312389681e-003
	,1.331070604e-003
	,1.349848898e-003
	,1.368723797e-003
	,1.387694605e-003
	,1.405784398e-003
	,1.423803275e-003
	,1.442048667e-003
	,1.460467267e-003
	,1.479031998e-003
	,1.497726918e-003
	,1.516528000e-003
	,1.535429820e-003
	,1.554438381e-003
	,1.573549725e-003
	,1.592760731e-003
	,1.612068856e-003
	,1.631471997e-003
	,1.650968349e-003
	,1.670556481e-003
	,1.690235253e-003
	,1.710003404e-003
	,1.729859679e-003
	,1.749803097e-003
	,1.769832664e-003
	,1.789947427e-003
	,1.810146473e-003
	,-3.660624976e-009
	,-3.339121899e-009
	,-3.051643036e-009
	,-2.793628578e-009
	,-2.558166590e-009
	,-2.327374177e-009
	,-2.121031090e-009
	,-1.936096914e-009
	,-1.769972345e-009
	,-1.620425764e-009
	,-1.478180109e-009
	,-1.347111851e-009
	,-1.228573856e-009
	,-1.121264359e-009
	,-1.024030022e-009
	,-9.358478392e-010
	,-8.558081162e-010
	,-7.831004629e-010
	,-7.170014783e-010
	,-6.568639395e-010
	,-5.981460094e-010
	,-5.453533494e-010
	,-4.978249037e-010
	,-4.549097468e-010
	,-4.160500159e-010
	,-3.807609708e-010
	,-3.486148420e-010
	,-3.192272207e-010
	,-2.922445908e-010
	,-2.673326099e-010
	,-2.441635447e-010
	,-2.224029741e-010
	,-2.016934350e-010
	,-1.816343374e-010
	,-1.617565058e-010
	,-1.414886952e-010
	,-1.201125704e-010
	,-9.670304666e-011
	,-7.004688062e-011
	,-3.853254080e-011
	,-2.260985773e-017
	,4.811618261e-011
	,1.088702737e-010
	,1.872685618e-010
	,2.900675774e-010
	,4.264210433e-010
	,6.087601932e-010
	,8.539935647e-010
	,1.185142205e-009
	,1.633567855e-009
	,2.242008000e-009
	,3.013065949e-009
	,4.032968272e-009
	,5.390554012e-009
	,7.198300894e-009
	,9.605923711e-009
	,1.281258763e-008
	,1.708304256e-008
	,2.276888825e-008
	,3.033650703e-008
	,4.040361787e-008
	,5.378688342e-008
	,7.156354357e-008
	,9.515062427e-008
	,1.264058146e-007
	,1.677545167e-007
	,2.222541284e-007
	,2.939433328e-007
	,3.880561638e-007
	,5.111681612e-007
	,6.715384218e-007
	,8.794129243e-007
	,1.147255982e-006
	,1.490055945e-006
	,1.925627768e-006
	,2.474452403e-006
	,3.159595294e-006
	,4.006334242e-006
	,5.041565002e-006
	,6.292993323e-006
	,7.788196843e-006
	,9.553649269e-006
	,1.161381816e-005
	,1.399043663e-005
	,1.670201580e-005
	,1.976362028e-005
	,2.318688859e-005
	,2.698024965e-005
	,3.114927076e-005
	,3.569709693e-005
	,4.062488472e-005
	,4.593222317e-005
	,5.161753153e-005
	,5.767837670e-005
	,6.411173881e-005
	,7.091422088e-005
	,7.808220061e-005
	,8.561195219e-005
	,9.349970025e-005
	,1.017416574e-004
	,1.103341038e-004
	,1.192733188e-004
	,1.285555347e-004
	,1.381769970e-004
	,1.481339707e-004
	,1.584225864e-004
	,1.690043184e-004
	,1.794665032e-004
	,1.902245716e-004
	,2.012708915e-004
	,2.125982398e-004
	,2.241997392e-004
	,2.360688115e-004
	,2.481991521e-004
	,2.605847149e-004
	,2.732197068e-004
	,2.860985861e-004
	,2.992160660e-004
	,3.125670018e-004
	,3.261465750e-004
	,3.399504311e-004
	,3.539743557e-004
	,3.682139364e-004
	,3.826589053e-004
	,3.973116680e-004
	,4.121645952e-004
	,4.270861177e-004
	,4.421970127e-004
	,4.574549180e-004
	,4.716559454e-004
	,4.857009836e-004
	,4.998833004e-004
	,5.142014938e-004
	,5.286543949e-004
	,5.432409980e-004
	,5.579300365e-004
	,5.727330967e-004
	,5.876650052e-004
	,6.027252086e-004
	,6.179133226e-004
	,6.332291276e-004
	,6.486725648e-004
	,6.642437332e-004
	,6.799428873e-004
	,6.957704343e-004
	,7.116784186e-004
	,7.276654404e-004
	,7.436995758e-004
	,7.596509141e-004
	,7.757029740e-004
	,7.918557136e-004
	,8.081092032e-004
	,8.244635683e-004
	,8.409189857e-004
	,8.574756664e-004
	,8.741338425e-004
	,8.908937673e-004
	,9.077556941e-004
	,9.247198544e-004
	,9.417864565e-004
	,9.589556760e-004
	,9.762276490e-004
	,9.936024659e-004
	,1.011080168e-003
	,1.028660741e-003
	,1.046344129e-003
	,1.064130209e-003
	,1.082018800e-003
	,1.100009648e-003
	,1.118099818e-003
	,1.136291532e-003
	,1.154584409e-003
	,1.172978027e-003
	,1.191471923e-003
	,1.210065598e-003
	,1.228758523e-003
	,1.247550138e-003
	,1.266439859e-003
	,1.285427078e-003
	,1.304511171e-003
	,1.323691494e-003
	,1.342967393e-003
	,1.362338199e-003
	,1.381236109e-003
	,1.399733196e-003
	,1.418457827e-003
	,1.437350740e-003
	,1.456383862e-003
	,1.475541321e-003
	,1.494813108e-003
	,1.514192423e-003
	,1.533674378e-003
	,1.553255298e-003
	,1.572907210e-003
	,1.592649456e-003
	,1.612482644e-003
	,1.632405517e-003
	,1.652416767e-003
	,1.672515143e-003
	,1.692699509e-003
	,1.712968812e-003
	,-3.434127347e-010
	,-3.063767695e-010
	,-2.744073690e-010
	,-2.466035650e-010
	,-2.221013121e-010
	,-1.999542559e-010
	,-1.806361648e-010
	,-1.623549090e-010
	,-1.459607922e-010
	,-1.315654817e-010
	,-1.188720930e-010
	,-1.076378371e-010
	,-9.739083822e-011
	,-8.795190990e-011
	,-7.951966400e-011
	,-7.197344305e-011
	,-6.520933732e-011
	,-5.913719309e-011
	,-5.367845989e-011
	,-4.876441213e-011
	,-4.433585009e-011
	,-4.033988532e-011
	,-3.672964042e-011
	,-3.346364457e-011
	,-3.050479490e-011
	,-2.781832802e-011
	,-2.513996924e-011
	,-2.274712784e-011
	,-2.059609768e-011
	,-1.864900096e-011
	,-1.687162556e-011
	,-1.523215807e-011
	,-1.369927548e-011
	,-1.224068519e-011
	,-1.082091041e-011
	,-9.399248108e-012
	,-7.926577308e-012
	,-6.341709247e-012
	,-4.566169405e-012
	,-2.497517203e-012
	,3.341677898e-018
	,3.107854660e-012
	,7.070155850e-012
	,1.221657313e-011
	,1.899390418e-011
	,2.800873887e-011
	,4.008604776e-011
	,5.601988737e-011
	,7.689001578e-011
	,1.049205435e-010
	,1.426833885e-010
	,1.936750852e-010
	,2.626529792e-010
	,3.560932435e-010
	,4.828156030e-010
	,6.548353113e-010
	,8.885250993e-010
	,1.192573306e-009
	,1.587034379e-009
	,2.112123203e-009
	,2.811204594e-009
	,3.742030242e-009
	,4.981494154e-009
	,6.631945298e-009
	,8.829557421e-009
	,1.175541004e-008
	,1.565013132e-008
	,2.083320409e-008
	,2.772834858e-008
	,3.689677730e-008
	,4.908057713e-008
	,6.525900120e-008
	,8.672103821e-008
	,1.151582213e-007
	,1.527032559e-007
	,2.022006023e-007
	,2.673952014e-007
	,3.530292784e-007
	,4.651406251e-007
	,6.113409086e-007
	,8.011146876e-007
	,1.046120087e-006
	,1.360461842e-006
	,1.760896974e-006
	,2.266925264e-006
	,2.900714846e-006
	,3.686821428e-006
	,4.651680847e-006
	,5.822887898e-006
	,7.228313559e-006
	,8.895148370e-006
	,1.084897971e-005
	,1.311300661e-005
	,1.570747192e-005
	,1.864935042e-005
	,2.195228855e-005
	,2.562675783e-005
	,2.968036375e-005
	,3.411826001e-005
	,3.894358871e-005
	,4.415791943e-005
	,4.976166168e-005
	,5.575443167e-005
	,6.213534569e-005
	,6.890327105e-005
	,7.605702209e-005
	,8.359551125e-005
	,9.151786278e-005
	,9.982345704e-005
	,1.085120997e-004
	,1.175823328e-004
	,1.269871380e-004
	,1.367243494e-004
	,1.468192839e-004
	,1.570241844e-004
	,1.673265126e-004
	,1.779487915e-004
	,1.888832872e-004
	,2.001225747e-004
	,2.116594624e-004
	,2.234869459e-004
	,2.355981813e-004
	,2.479864733e-004
	,2.606452723e-004
	,2.735681780e-004
	,2.867489482e-004
	,3.001799526e-004
	,3.138539948e-004
	,3.277676916e-004
	,3.419156573e-004
	,3.562926161e-004
	,3.708928647e-004
	,3.857117473e-004
	,4.007450654e-004
	,4.159881437e-004
	,4.312703908e-004
	,4.454367016e-004
	,4.597706147e-004
	,4.742710972e-004
	,4.889362341e-004
	,5.037503500e-004
	,5.187179357e-004
	,5.338446914e-004
	,5.491295226e-004
	,5.645714991e-004
	,5.801698522e-004
	,5.959239717e-004
	,6.118334038e-004
	,6.278978478e-004
	,6.441171544e-004
	,6.604913224e-004
	,6.769974167e-004
	,6.935807587e-004
	,7.101871920e-004
	,7.269381508e-004
	,7.438342301e-004
	,7.608761735e-004
	,7.780648552e-004
	,7.954012780e-004
	,8.128865687e-004
	,8.305219745e-004
	,8.483088600e-004
	,8.662487053e-004
	,8.843431061e-004
	,9.025937756e-004
	,9.205358927e-004
	,9.384811041e-004
	,9.565479196e-004
	,9.747370713e-004
	,9.930491027e-004
	,1.011484560e-003
	,1.030044010e-003
	,1.048728045e-003
	,1.067537286e-003
	,1.086472383e-003
	,1.105533127e-003
	,1.124718942e-003
	,1.144032713e-003
	,1.163475338e-003
	,1.182800159e-003
	,1.202110715e-003
	,1.221520295e-003
	,1.241028222e-003
	,1.260633786e-003
	,1.280336264e-003
	,1.300134919e-003
	,1.320029001e-003
	,1.340017755e-003
	,1.359643179e-003
	,1.378930111e-003
	,1.398417115e-003
	,1.418053967e-003
	,1.437817219e-003
	,1.457693721e-003
	,1.477675208e-003
	,1.497756065e-003
	,1.517932246e-003
	,1.538200697e-003
	,1.558558817e-003
	,1.579004926e-003
	,1.599536787e-003
	,-4.013582897e-011
	,-3.486960253e-011
	,-3.051329636e-011
	,-2.687314087e-011
	,-2.380399927e-011
	,-2.081292517e-011
	,-1.830299911e-011
	,-1.617597564e-011
	,-1.436010392e-011
	,-1.275204480e-011
	,-1.127997736e-011
	,-1.001484396e-011
	,-8.898875401e-012
	,-7.920329410e-012
	,-7.071952563e-012
	,-6.302511097e-012
	,-5.625781570e-012
	,-5.031577300e-012
	,-4.508259362e-012
	,-4.046039016e-012
	,-3.636482323e-012
	,-3.272703514e-012
	,-2.948854823e-012
	,-2.659930737e-012
	,-2.401048974e-012
	,-2.168952799e-012
	,-1.960439990e-012
	,-1.772472391e-012
	,-1.602537350e-012
	,-1.448052923e-012
	,-1.306781744e-012
	,-1.176063442e-012
	,-1.041153679e-012
	,-9.169638844e-013
	,-7.999332675e-013
	,-6.863521161e-013
	,-5.722402898e-013
	,-4.530231647e-013
	,-3.229722916e-013
	,-1.750369465e-013
	,6.161361847e-018
	,2.140841906e-013
	,4.832636481e-013
	,8.288611358e-013
	,1.279682910e-012
	,1.874367623e-012
	,2.665340614e-012
	,3.723645281e-012
	,5.145489921e-012
	,7.061529601e-012
	,9.649306610e-012
	,1.315012689e-011
	,1.789233658e-011
	,2.423661779e-011
	,3.243490789e-011
	,4.346382863e-011
	,5.832367934e-011
	,7.837295718e-011
	,1.054573743e-010
	,1.420862759e-010
	,1.916729715e-010
	,2.588622251e-010
	,3.499768167e-010
	,4.715109318e-010
	,6.259336865e-010
	,8.311888649e-010
	,1.104072490e-009
	,1.466941166e-009
	,1.949552858e-009
	,2.591514298e-009
	,3.445534754e-009
	,4.581747021e-009
	,6.093442421e-009
	,8.104673146e-009
	,1.078031724e-008
	,1.433938184e-008
	,1.907255008e-008
	,2.536526859e-008
	,3.372802933e-008
	,4.483593905e-008
	,5.958018460e-008
	,7.913459789e-008
	,1.049745328e-007
	,1.390828385e-007
	,1.841116424e-007
	,2.434331373e-007
	,3.213862455e-007
	,4.235106433e-007
	,5.568139821e-007
	,7.300644082e-007
	,9.540927196e-007
	,1.242078818e-006
	,1.609786601e-006
	,2.075702274e-006
	,2.661026617e-006
	,3.389475926e-006
	,4.286862612e-006
	,5.380455250e-006
	,6.698155250e-006
	,8.267564790e-006
	,1.011504762e-005
	,1.226488790e-005
	,1.473863729e-005
	,1.755470456e-005
	,2.072819795e-005
	,2.427099553e-005
	,2.819199174e-005
	,3.249746481e-005
	,3.719150356e-005
	,4.227643766e-005
	,4.775324434e-005
	,5.362193839e-005
	,5.988186843e-005
	,6.653093985e-005
	,7.356838200e-005
	,8.099300725e-005
	,8.880353267e-005
	,9.699879430e-005
	,1.055778478e-004
	,1.145399707e-004
	,1.238846473e-004
	,1.336114438e-004
	,1.434780347e-004
	,1.534594569e-004
	,1.637900771e-004
	,1.744646212e-004
	,1.854783460e-004
	,1.968269673e-004
	,2.085065110e-004
	,2.205122770e-004
	,2.328424998e-004
	,2.454946390e-004
	,2.584666679e-004
	,2.717571435e-004
	,2.852092909e-004
	,2.988450525e-004
	,3.127419656e-004
	,3.268942263e-004
	,3.412962531e-004
	,3.559425007e-004
	,3.708269474e-004
	,3.859444866e-004
	,4.012904607e-004
	,4.153096668e-004
	,4.294717976e-004
	,4.438033356e-004
	,4.583018754e-004
	,4.729713246e-004
	,4.878095787e-004
	,5.028146855e-004
	,5.179848422e-004
	,5.333183925e-004
	,5.488138239e-004
	,5.644697639e-004
	,5.802849772e-004
	,5.962583619e-004
	,6.123883368e-004
	,6.286621600e-004
	,6.450739712e-004
	,6.616284365e-004
	,6.783340668e-004
	,6.951903825e-004
	,7.121970137e-004
	,7.293536952e-004
	,7.466602611e-004
	,7.641166378e-004
	,7.817228386e-004
	,7.994789561e-004
	,8.173851566e-004
	,8.354416733e-004
	,8.536488006e-004
	,8.720068891e-004
	,8.905163408e-004
	,9.091776055e-004
	,9.279911785e-004
	,9.469575986e-004
	,9.660774480e-004
	,9.852069617e-004
	,1.004402590e-003
	,1.023744454e-003
	,1.043233155e-003
	,1.062869327e-003
	,1.082653649e-003
	,1.102586393e-003
	,1.122665825e-003
	,1.142895569e-003
	,1.163276531e-003
	,1.183809697e-003
	,1.204496144e-003
	,1.225337047e-003
	,1.246333698e-003
	,1.267487516e-003
	,1.288800063e-003
	,1.310273068e-003
	,1.331678865e-003
	,1.353028435e-003
	,1.374610311e-003
	,1.396400401e-003
	,1.417459703e-003
	,1.438479607e-003
	,1.459624510e-003
	,-8.494678198e-012
	,-6.703796769e-012
	,-5.344486610e-012
	,-4.322825458e-012
	,-3.541339817e-012
	,-2.940211082e-012
	,-2.471607962e-012
	,-2.101627832e-012
	,-1.805489742e-012
	,-1.565734678e-012
	,-1.362923636e-012
	,-1.171491742e-012
	,-1.005941205e-012
	,-8.675802007e-013
	,-7.529290315e-013
	,-6.570113726e-013
	,-5.760608050e-013
	,-5.058457662e-013
	,-4.454834342e-013
	,-3.935099231e-013
	,-3.466692288e-013
	,-3.062621657e-013
	,-2.712910355e-013
	,-2.407664424e-013
	,-2.140884204e-013
	,-1.906698487e-013
	,-1.701210364e-013
	,-1.518847304e-013
	,-1.357039218e-013
	,-1.212875566e-013
	,-1.082793102e-013
	,-9.648974165e-014
	,-8.568241523e-014
	,-7.553291063e-014
	,-6.585972375e-014
	,-5.650208039e-014
	,-4.706297950e-014
	,-3.714322692e-014
	,-2.600860829e-014
	,-1.382156874e-014
	,-5.535104918e-018
	,1.642920167e-014
	,3.659641676e-014
	,6.198626091e-014
	,9.454483820e-014
	,1.369876609e-013
	,1.927707218e-013
	,2.667079522e-013
	,3.652229055e-013
	,4.968525406e-013
	,6.733370813e-013
	,9.104003386e-013
	,1.229389304e-012
	,1.659193259e-012
	,2.238985132e-012
	,3.021780622e-012
	,4.079629179e-012
	,5.510323553e-012
	,7.446624647e-012
	,1.006804503e-011
	,1.337705286e-011
	,1.781328700e-011
	,2.377019074e-011
	,3.178098517e-011
	,4.256870570e-011
	,5.711459782e-011
	,7.675097743e-011
	,1.032881222e-010
	,1.391867923e-010
	,1.877936963e-010
	,2.492629611e-010
	,3.302299857e-010
	,4.376726845e-010
	,5.802922899e-010
	,7.696592307e-010
	,1.021160622e-009
	,1.355260728e-009
	,1.799177115e-009
	,2.389107920e-009
	,3.173191471e-009
	,4.215435492e-009
	,5.600930472e-009
	,7.442760012e-009
	,9.891149227e-009
	,1.314555941e-008
	,1.747064917e-008
	,2.321729141e-008
	,3.085017513e-008
	,4.098394003e-008
	,5.443030350e-008
	,7.220303772e-008
	,9.567254715e-008
	,1.267035122e-007
	,1.676678683e-007
	,2.216419943e-007
	,2.925921083e-007
	,3.855949451e-007
	,5.070929088e-007
	,6.651781007e-007
	,8.698926809e-007
	,1.133524014e-006
	,1.470862731e-006
	,1.899381983e-006
	,2.439289687e-006
	,3.113406316e-006
	,3.946832282e-006
	,4.966393220e-006
	,6.199885880e-006
	,7.675185231e-006
	,9.419305296e-006
	,1.145751799e-005
	,1.381262698e-005
	,1.650446439e-005
	,1.954955872e-005
	,2.296125661e-005
	,2.674985807e-005
	,3.092288642e-005
	,3.548552036e-005
	,4.044101139e-005
	,4.579109726e-005
	,5.153639310e-005
	,5.767671853e-005
	,6.421136835e-005
	,7.113933438e-005
	,7.845947400e-005
	,8.617063299e-005
	,9.427171661e-005
	,1.027617435e-004
	,1.116398356e-004
	,1.209047325e-004
	,1.303469701e-004
	,1.398842950e-004
	,1.497755573e-004
	,1.600146102e-004
	,1.705957452e-004
	,1.815135959e-004
	,1.927630768e-004
	,2.043393464e-004
	,2.162377889e-004
	,2.284540087e-004
	,2.409838377e-004
	,2.538233433e-004
	,2.669688515e-004
	,2.804169715e-004
	,2.941646242e-004
	,3.082089897e-004
	,3.225475707e-004
	,3.371786279e-004
	,3.521007078e-004
	,3.673124977e-004
	,3.824559718e-004
	,3.964785113e-004
	,4.107172999e-004
	,4.251725072e-004
	,4.398448881e-004
	,4.545047018e-004
	,4.692820434e-004
	,4.842356550e-004
	,4.993635009e-004
	,5.146636846e-004
	,5.301344405e-004
	,5.457741316e-004
	,5.615777185e-004
	,5.775411934e-004
	,5.936682659e-004
	,6.099429111e-004
	,6.263734750e-004
	,6.429629730e-004
	,6.597104464e-004
	,6.766150293e-004
	,6.936759439e-004
	,7.108924943e-004
	,7.282640607e-004
	,7.457900929e-004
	,7.634701040e-004
	,7.813036644e-004
	,7.992903947e-004
	,8.174299605e-004
	,8.357220662e-004
	,8.541664504e-004
	,8.727628807e-004
	,8.915111477e-004
	,9.104110643e-004
	,9.294624616e-004
	,9.486651869e-004
	,9.680191022e-004
	,9.875240832e-004
	,1.007180019e-003
	,1.026986812e-003
	,1.046944379e-003
	,1.067052653e-003
	,1.087311584e-003
	,1.107719793e-003
	,1.128276328e-003
	,1.148983293e-003
	,1.169840726e-003
	,1.190848695e-003
	,1.212007299e-003
	,1.233316679e-003
	,1.254777015e-003
	,1.276388532e-003
	,-5.255150563e-012
	,-3.728415821e-012
	,-2.662998919e-012
	,-1.917590455e-012
	,-1.391704046e-012
	,-1.019641161e-012
	,-7.556224564e-013
	,-5.671926901e-013
	,-4.317412868e-013
	,-3.336145099e-013
	,-2.618579917e-013
	,-2.085968771e-013
	,-1.687832008e-013
	,-1.386369153e-013
	,-1.152896189e-013
	,-9.678612177e-014
	,-8.107280635e-014
	,-6.733248645e-014
	,-5.650380353e-014
	,-4.780857704e-014
	,-4.070939609e-014
	,-3.490340575e-014
	,-3.013464138e-014
	,-2.610264997e-014
	,-2.276367423e-014
	,-1.987443807e-014
	,-1.745097193e-014
	,-1.529548020e-014
	,-1.333908948e-014
	,-1.172012095e-014
	,-1.025868920e-014
	,-8.968997090e-015
	,-7.906446187e-015
	,-6.856636079e-015
	,-5.913295148e-015
	,-5.001284039e-015
	,-4.077367597e-015
	,-3.177627334e-015
	,-2.249376934e-015
	,-1.212307620e-015
	,1.127856605e-017
	,1.438613026e-015
	,3.195589426e-015
	,5.424967321e-015
	,8.106956707e-015
	,1.151104627e-014
	,1.590761236e-014
	,2.162029205e-014
	,2.915443535e-014
	,3.908802526e-014
	,5.222806578e-014
	,6.971652889e-014
	,9.302142562e-014
	,1.241134017e-013
	,1.656889106e-013
	,2.213566254e-013
	,2.959788824e-013
	,3.961651251e-013
	,5.306957450e-013
	,7.115758074e-013
	,9.550692496e-013
	,1.283026690e-012
	,1.725196003e-012
	,2.321746250e-012
	,3.127053574e-012
	,4.215221671e-012
	,5.593360374e-012
	,7.406243953e-012
	,9.830414545e-012
	,1.307749073e-011
	,1.743396447e-011
	,2.328743860e-011
	,3.116349187e-011
	,4.177460876e-011
	,5.608794300e-011
	,7.541645396e-011
	,1.004877461e-010
	,1.327721014e-010
	,1.755180609e-010
	,2.321379149e-010
	,3.071629499e-010
	,4.066111384e-010
	,5.384759887e-010
	,7.133730086e-010
	,9.454164536e-010
	,1.253358091e-009
	,1.662117709e-009
	,2.204812418e-009
	,2.925451505e-009
	,3.882513342e-009
	,5.153689588e-009
	,6.842173461e-009
	,9.084985332e-009
	,1.206398334e-008
	,1.602040182e-008
	,2.127401606e-008
	,2.824835135e-008
	,3.750376602e-008
	,4.973340406e-008
	,6.587781906e-008
	,8.724274277e-008
	,1.154837036e-007
	,1.527605945e-007
	,2.018785076e-007
	,2.664603571e-007
	,3.511541400e-007
	,4.618752967e-007
	,6.060805885e-007
	,7.930637701e-007
	,1.034255086e-006
	,1.343496691e-006
	,1.737255903e-006
	,2.234730202e-006
	,2.857795698e-006
	,3.630758025e-006
	,4.579884114e-006
	,5.732724103e-006
	,7.117269738e-006
	,8.761030135e-006
	,1.069012613e-005
	,1.292850323e-005
	,1.549734277e-005
	,1.841471354e-005
	,2.169546516e-005
	,2.535133184e-005
	,2.939115947e-005
	,3.382131862e-005
	,3.864615232e-005
	,4.386831312e-005
	,4.948918037e-005
	,5.550921833e-005
	,6.192825467e-005
	,6.874572228e-005
	,7.596084409e-005
	,8.357276994e-005
	,9.158067067e-005
	,9.998375466e-005
	,1.087814021e-004
	,1.178035231e-004
	,1.268952674e-004
	,1.363488816e-004
	,1.461579099e-004
	,1.563162465e-004
	,1.668180919e-004
	,1.776578814e-004
	,1.888302384e-004
	,2.003299472e-004
	,2.121519385e-004
	,2.242912857e-004
	,2.367432080e-004
	,2.495030795e-004
	,2.625664428e-004
	,2.759290243e-004
	,2.895867528e-004
	,3.035357695e-004
	,3.177647668e-004
	,3.322749582e-004
	,3.470655413e-004
	,3.621337082e-004
	,3.758090702e-004
	,3.896736626e-004
	,4.037457474e-004
	,4.180232095e-004
	,4.325043615e-004
	,4.471890335e-004
	,4.620766238e-004
	,4.771667999e-004
	,4.924595072e-004
	,5.079499923e-004
	,5.236432519e-004
	,5.395403794e-004
	,5.556426681e-004
	,5.719414623e-004
	,5.884491413e-004
	,6.051686804e-004
	,6.219087618e-004
	,6.386071766e-004
	,6.554709815e-004
	,6.724989199e-004
	,6.896903348e-004
	,7.070444597e-004
	,7.245605842e-004
	,7.422380472e-004
	,7.600762308e-004
	,7.780745539e-004
	,7.962324666e-004
	,8.145494442e-004
	,8.330249828e-004
	,8.516585947e-004
	,8.704498040e-004
	,8.893981441e-004
	,9.085031539e-004
	,9.277643764e-004
	,9.471813565e-004
	,9.667536397e-004
	,9.864807718e-004
	,1.006362298e-003
	,1.026397762e-003
	,1.046586710e-003
	,1.066928685e-003
	,1.087423235e-003
	,-5.442077125e-012
	,-3.778410280e-012
	,-2.624447626e-012
	,-1.824051773e-012
	,-1.269184966e-012
	,-8.844898977e-013
	,-6.177150561e-013
	,-4.323812506e-013
	,-3.036820505e-013
	,-2.141767183e-013
	,-1.518355426e-013
	,-1.082470927e-013
	,-7.773022768e-014
	,-5.633879981e-014
	,-4.121124762e-014
	,-3.050777955e-014
	,-2.285379968e-014
	,-1.734324956e-014
	,-1.333992495e-014
	,-1.043110765e-014
	,-8.276973545e-015
	,-6.655811922e-015
	,-5.316253179e-015
	,-4.284092204e-015
	,-3.427064931e-015
	,-2.836132278e-015
	,-2.353653024e-015
	,-1.916915310e-015
	,-1.620013033e-015
	,-1.374335014e-015
	,-1.205989439e-015
	,-1.042134472e-015
	,-8.567663602e-016
	,-7.768753149e-016
	,-6.477442331e-016
	,-5.108851287e-016
	,-4.308374343e-016
	,-3.010797562e-016
	,-2.335117741e-016
	,-1.278780586e-016
	,1.065196962e-017
	,1.442214427e-016
	,3.113138251e-016
	,5.215369286e-016
	,7.540564219e-016
	,1.061819704e-015
	,1.455792211e-015
	,2.013985201e-015
	,2.744962157e-015
	,3.670027359e-015
	,4.761767212e-015
	,6.256304139e-015
	,8.134213651e-015
	,1.065798744e-014
	,1.398871300e-014
	,1.833358489e-014
	,2.416954742e-014
	,3.188080865e-014
	,4.212351947e-014
	,5.576911887e-014
	,7.389190644e-014
	,9.813173727e-014
	,1.305869784e-013
	,1.739025977e-013
	,2.319072040e-013
	,3.096292335e-013
	,4.139268365e-013
	,5.539317683e-013
	,7.421170575e-013
	,9.954100502e-013
	,1.336382316e-012
	,1.795943753e-012
	,2.383046858e-012
	,3.136416022e-012
	,4.139253119e-012
	,5.476559666e-012
	,7.263366129e-012
	,9.654812565e-012
	,1.286076826e-011
	,1.716527961e-011
	,2.295291057e-011
	,3.074496117e-011
	,4.110219575e-011
	,5.414184038e-011
	,7.135972902e-011
	,9.410876908e-011
	,1.241799319e-010
	,1.639465400e-010
	,2.165579247e-010
	,2.861908878e-010
	,3.783874363e-010
	,5.005024231e-010
	,6.622984904e-010
	,8.767363562e-010
	,1.161024644e-009
	,1.538013550e-009
	,2.038047768e-009
	,2.701422782e-009
	,3.581646562e-009
	,4.749764307e-009
	,6.300090879e-009
	,8.357801868e-009
	,1.108897862e-008
	,1.471388394e-008
	,1.952448863e-008
	,2.590758109e-008
	,3.433538788e-008
	,4.544950758e-008
	,6.016324590e-008
	,7.962624439e-008
	,1.053447648e-007
	,1.392855275e-007
	,1.840056758e-007
	,2.428130531e-007
	,3.199601585e-007
	,4.208732828e-007
	,5.524149187e-007
	,7.231723706e-007
	,9.437577221e-007
	,1.227095305e-006
	,1.588662340e-006
	,2.046639485e-006
	,2.621923345e-006
	,3.337956546e-006
	,4.220345701e-006
	,5.296264410e-006
	,6.593673917e-006
	,8.140428479e-006
	,9.963360928e-006
	,1.208744950e-005
	,1.453515343e-005
	,1.732597425e-005
	,2.047625800e-005
	,2.399921966e-005
	,2.790514451e-005
	,3.220171323e-005
	,3.689439732e-005
	,4.198686336e-005
	,4.748136220e-005
	,5.337910728e-005
	,5.968056833e-005
	,6.638572961e-005
	,7.349429282e-005
	,8.100582931e-005
	,8.891988705e-005
	,9.723602925e-005
	,1.058353280e-004
	,1.144681485e-004
	,1.234719071e-004
	,1.328397947e-004
	,1.425655927e-004
	,1.526432978e-004
	,1.630671134e-004
	,1.738314024e-004
	,1.849306558e-004
	,1.963594728e-004
	,2.081125536e-004
	,2.201846980e-004
	,2.325708121e-004
	,2.452643964e-004
	,2.582561226e-004
	,2.715464758e-004
	,2.851308807e-004
	,2.990049382e-004
	,3.131642129e-004
	,3.276048281e-004
	,3.423230713e-004
	,3.559270055e-004
	,3.694777259e-004
	,3.832341608e-004
	,3.971943482e-004
	,4.113564477e-004
	,4.257182038e-004
	,4.402746322e-004
	,4.550271387e-004
	,4.699755300e-004
	,4.851189186e-004
	,5.004566145e-004
	,5.159831597e-004
	,5.316976880e-004
	,5.476052571e-004
	,5.637060228e-004
	,5.800003562e-004
	,5.964888499e-004
	,6.131723255e-004
	,6.300518540e-004
	,6.471287448e-004
	,6.644045795e-004
	,6.818812367e-004
	,6.995609185e-004
	,7.174461906e-004
	,7.355400331e-004
	,7.538459080e-004
	,7.723678484e-004
	,7.911105763e-004
	,8.095428212e-004
	,8.281254795e-004
	,8.468725250e-004
	,8.657834635e-004
	,8.848577816e-004
	,9.040949637e-004
	,-5.968380429e-012
	,-4.158219620e-012
	,-2.895199892e-012
	,-2.014840728e-012
	,-1.401520253e-012
	,-9.744808942e-013
	,-6.773365423e-013
	,-4.706210733e-013
	,-3.269514923e-013
	,-2.271041860e-013
	,-1.577714995e-013
	,-1.096520786e-013
	,-7.627772493e-014
	,-5.308347468e-014
	,-3.700976188e-014
	,-2.587963386e-014
	,-1.809918594e-014
	,-1.273050770e-014
	,-8.940695818e-015
	,-6.369144054e-015
	,-4.506795020e-015
	,-3.235953019e-015
	,-2.323263097e-015
	,-1.727526538e-015
	,-1.295227215e-015
	,-9.567084914e-016
	,-7.027802866e-016
	,-5.071255501e-016
	,-3.790387958e-016
	,-3.118885447e-016
	,-2.394644402e-016
	,-1.502788811e-016
	,-1.652649792e-016
	,-1.127353115e-016
	,-6.448738606e-017
	,-8.370301003e-017
	,-3.644719565e-017
	,-7.127551409e-017
	,-2.187882857e-017
	,-1.550843149e-017
	,1.509036102e-017
	,3.555917786e-017
	,2.229622001e-017
	,5.869102953e-017
	,8.735781638e-017
	,9.571243549e-017
	,1.293919938e-016
	,2.022338292e-016
	,2.873465115e-016
	,3.554888736e-016
	,4.927657090e-016
	,6.081116692e-016
	,7.735331277e-016
	,1.067563504e-015
	,1.416577718e-015
	,1.860730157e-015
	,2.375270261e-015
	,3.084368559e-015
	,3.925260973e-015
	,5.090051527e-015
	,6.585215051e-015
	,8.621340162e-015
	,1.121048884e-014
	,1.474872226e-014
	,1.930757683e-014
	,2.543965839e-014
	,3.357815396e-014
	,4.432986995e-014
	,5.872921264e-014
	,7.786954061e-014
	,1.033937897e-013
	,1.374327011e-013
	,1.829485094e-013
	,2.439154547e-013
	,3.255142886e-013
	,4.350699233e-013
	,5.821828606e-013
	,7.798701193e-013
	,1.036268628e-012
	,1.355310489e-012
	,1.778003410e-012
	,2.338752704e-012
	,3.084377553e-012
	,4.078015850e-012
	,5.404719758e-012
	,7.179228379e-012
	,9.556611484e-012
	,1.274669826e-011
	,1.703354481e-011
	,2.243143848e-011
	,2.946539209e-011
	,3.873174996e-011
	,5.094702807e-011
	,6.705825766e-011
	,8.831884707e-011
	,1.163883014e-010
	,1.534644219e-010
	,2.024590291e-010
	,2.672307735e-010
	,3.528946947e-010
	,4.662325533e-010
	,6.162381711e-010
	,8.148412774e-010
	,1.077868149e-009
	,1.426298027e-009
	,1.887986767e-009
	,2.499912535e-009
	,3.311132958e-009
	,4.386740171e-009
	,5.813109129e-009
	,7.704841620e-009
	,1.021394909e-008
	,1.354202687e-008
	,1.795636116e-008
	,2.377783216e-008
	,3.144169372e-008
	,4.158756402e-008
	,5.501142231e-008
	,7.275927666e-008
	,9.620212089e-008
	,1.271311813e-007
	,1.678776570e-007
	,2.214611849e-007
	,2.917707716e-007
	,3.837805179e-007
	,5.037996988e-007
	,6.597522264e-007
	,8.614738812e-007
	,1.121007014e-006
	,1.452862394e-006
	,1.874208193e-006
	,2.404938226e-006
	,3.067579033e-006
	,3.886990144e-006
	,4.889850911e-006
	,6.103951307e-006
	,7.557340445e-006
	,9.277419043e-006
	,1.129007428e-005
	,1.361895126e-005
	,1.628492931e-005
	,1.930583399e-005
	,2.269637796e-005
	,2.646829522e-005
	,3.063061390e-005
	,3.519003035e-005
	,4.015129830e-005
	,4.551764741e-005
	,5.129114876e-005
	,5.747297029e-005
	,6.406373245e-005
	,7.106370074e-005
	,7.847295416e-005
	,8.629150547e-005
	,9.446339568e-005
	,1.026211168e-004
	,1.111590178e-004
	,1.200703449e-004
	,1.293486658e-004
	,1.389878779e-004
	,1.489821142e-004
	,1.593256030e-004
	,1.700126757e-004
	,1.810373506e-004
	,1.923899489e-004
	,2.040688744e-004
	,2.160687194e-004
	,2.283841565e-004
	,2.410099511e-004
	,2.539409751e-004
	,2.671722230e-004
	,2.806988280e-004
	,2.945160784e-004
	,3.086192839e-004
	,3.230040624e-004
	,3.365259169e-004
	,3.497776617e-004
	,3.632371638e-004
	,3.768980757e-004
	,3.907606270e-004
	,4.048235378e-004
	,4.190847646e-004
	,4.335418006e-004
	,4.481938038e-004
	,4.630376273e-004
	,4.780662275e-004
	,4.932855472e-004
	,5.086946877e-004
	,5.242929176e-004
	,5.400796685e-004
	,5.560545322e-004
	,5.722172569e-004
	,5.885677446e-004
	,6.051060545e-004
	,6.218323971e-004
	,6.387471217e-004
	,6.558507217e-004
	,6.731438352e-004
	,6.906272452e-004
	,7.083018837e-004
	,7.261688343e-004
	,-6.408335977e-012
	,-4.483681170e-012
	,-3.136339368e-012
	,-2.193091800e-012
	,-1.533073705e-012
	,-1.071276624e-012
	,-7.483494471e-013
	,-5.225842456e-013
	,-3.647555172e-013
	,-2.544663991e-013
	,-1.774439645e-013
	,-1.236718605e-013
	,-8.615309359e-014
	,-5.996684537e-014
	,-4.171492672e-014
	,-2.908101947e-014
	,-2.017791961e-014
	,-1.404134744e-014
	,-9.757882000e-015
	,-6.760923474e-015
	,-4.716026012e-015
	,-3.290153611e-015
	,-2.290471217e-015
	,-1.606802291e-015
	,-1.119884646e-015
	,-7.704004851e-016
	,-5.322938402e-016
	,-3.506853072e-016
	,-2.879734474e-016
	,-1.959682044e-016
	,-1.316376372e-016
	,-1.165471064e-016
	,-8.401630824e-017
	,-2.438521430e-017
	,-1.738822079e-017
	,-2.730933099e-017
	,-2.422856519e-017
	,-7.310461483e-018
	,1.749231402e-017
	,1.378495178e-017
	,-2.422856520e-017
	,-8.356316731e-019
	,2.579471676e-017
	,8.250016613e-018
	,1.415046636e-017
	,1.717901579e-017
	,2.448930752e-017
	,2.193070541e-017
	,4.104189664e-017
	,4.182514218e-017
	,5.054527588e-017
	,5.096300684e-017
	,8.218839578e-017
	,9.988974504e-017
	,1.302274557e-016
	,1.652646396e-016
	,2.626481687e-016
	,3.221748299e-016
	,4.215425810e-016
	,5.462352713e-016
	,7.183926415e-016
	,9.357693877e-016
	,1.192726142e-015
	,1.509522855e-015
	,1.937644869e-015
	,2.498709759e-015
	,3.183423012e-015
	,4.097052829e-015
	,5.353535327e-015
	,6.948379901e-015
	,9.066066981e-015
	,1.185248911e-014
	,1.557405419e-014
	,2.043800901e-014
	,2.695033018e-014
	,3.554164610e-014
	,4.695541344e-014
	,6.216880933e-014
	,8.237414237e-014
	,1.094310985e-013
	,1.455394491e-013
	,1.938322805e-013
	,2.585071625e-013
	,3.452924395e-013
	,4.601959704e-013
	,5.980800299e-013
	,7.796141546e-013
	,1.019030438e-012
	,1.335885060e-012
	,1.756323800e-012
	,2.315240195e-012
	,3.059861184e-012
	,4.053814189e-012
	,5.382954356e-012
	,7.163233356e-012
	,9.461278179e-012
	,1.238211140e-011
	,1.621862022e-011
	,2.125802314e-011
	,2.788343817e-011
	,3.660101583e-011
	,4.807772050e-011
	,6.319533456e-011
	,8.311955126e-011
	,1.093918321e-010
	,1.440516700e-010
	,1.897982341e-010
	,2.502048520e-010
	,3.300031775e-010
	,4.354555285e-010
	,5.748596571e-010
	,7.592246350e-010
	,1.003134995e-009
	,1.325926276e-009
	,1.753236518e-009
	,2.319064502e-009
	,3.068500925e-009
	,4.061351081e-009
	,5.376939989e-009
	,7.120486983e-009
	,9.431563107e-009
	,1.249531995e-008
	,1.652942828e-008
	,2.182725699e-008
	,2.883836868e-008
	,3.811294074e-008
	,5.037596322e-008
	,6.657988712e-008
	,8.797335378e-008
	,1.161885116e-007
	,1.533510513e-007
	,2.022177614e-007
	,2.663445975e-007
	,3.502890909e-007
	,4.598474781e-007
	,6.023235379e-007
	,7.868202646e-007
	,1.024537571e-006
	,1.329049617e-006
	,1.716525385e-006
	,2.205848423e-006
	,2.818588083e-006
	,3.578782562e-006
	,4.512510864e-006
	,5.647259480e-006
	,7.011125127e-006
	,8.631927763e-006
	,1.053632903e-005
	,1.274905178e-005
	,1.529227942e-005
	,1.818528001e-005
	,2.144426130e-005
	,2.508245547e-005
	,2.911029976e-005
	,3.353577430e-005
	,3.836480348e-005
	,4.360163648e-005
	,4.924922381e-005
	,5.530957108e-005
	,6.178401233e-005
	,6.867345318e-005
	,7.597855591e-005
	,8.369987337e-005
	,9.138333660e-005
	,9.943849990e-005
	,1.078763551e-004
	,1.166906224e-004
	,1.258735286e-004
	,1.354191345e-004
	,1.453226102e-004
	,1.555781599e-004
	,1.661800450e-004
	,1.771226071e-004
	,1.884002054e-004
	,2.000072428e-004
	,2.119381731e-004
	,2.241875127e-004
	,2.367498546e-004
	,2.496198845e-004
	,2.627923982e-004
	,2.762623181e-004
	,2.900247110e-004
	,3.040747314e-004
	,3.175204867e-004
	,3.304701259e-004
	,3.436303343e-004
	,3.569983246e-004
	,3.705707877e-004
	,3.843455735e-004
	,3.983206820e-004
	,4.124930581e-004
	,4.268542982e-004
	,4.414090608e-004
	,4.561561120e-004
	,4.710940122e-004
	,4.862214826e-004
	,5.015374014e-004
	,5.170407991e-004
	,5.327308530e-004
	,5.486068822e-004
	,5.646683418e-004
	,-6.756742288e-012
	,-4.741399134e-012
	,-3.327020913e-012
	,-2.334355825e-012
	,-1.637750033e-012
	,-1.148877981e-012
	,-8.057947638e-013
	,-5.650663873e-013
	,-3.961879963e-013
	,-2.777238311e-013
	,-1.946171974e-013
	,-1.363562609e-013
	,-9.546666633e-014
	,-6.683919841e-014
	,-4.679766813e-014
	,-3.271339900e-014
	,-2.287014341e-014
	,-1.598546731e-014
	,-1.118234456e-014
	,-7.842167837e-015
	,-5.410555943e-015
	,-3.789028805e-015
	,-2.674209316e-015
	,-1.851174901e-015
	,-1.293974022e-015
	,-8.937877662e-016
	,-6.003317697e-016
	,-4.047814660e-016
	,-3.212352748e-016
	,-1.709043471e-016
	,-1.556571672e-016
	,-1.159205100e-016
	,-5.310421751e-017
	,-4.386192011e-017
	,-1.874584640e-017
	,2.046864708e-017
	,-2.976502815e-018
	,-1.441188773e-017
	,-4.699643011e-018
	,1.200806739e-018
	,-4.177479319e-018
	,1.080861872e-017
	,-2.245473652e-018
	,-3.656843520e-019
	,4.208622403e-017
	,3.676015435e-017
	,3.863841571e-018
	,-1.341977673e-017
	,-1.201146271e-018
	,5.743630868e-018
	,3.101635369e-017
	,2.281838368e-017
	,4.333788887e-018
	,1.869329049e-017
	,1.180072972e-017
	,5.367825804e-017
	,1.117413328e-017
	,5.759448575e-017
	,5.054527587e-017
	,8.401596870e-017
	,8.187509755e-017
	,1.034926745e-016
	,1.509573544e-016
	,1.709562239e-016
	,1.952368357e-016
	,2.893307335e-016
	,3.444190033e-016
	,5.212236303e-016
	,6.202258669e-016
	,7.634031520e-016
	,9.559771226e-016
	,1.244420348e-015
	,1.600222689e-015
	,2.007667020e-015
	,2.604447907e-015
	,3.347434628e-015
	,4.381684259e-015
	,5.696962390e-015
	,7.406735192e-015
	,9.665980850e-015
	,1.263187064e-014
	,1.659258669e-014
	,2.181009855e-014
	,2.873978516e-014
	,3.794620991e-014
	,5.019319386e-014
	,6.644412902e-014
	,8.820441332e-014
	,1.171955683e-013
	,1.558677947e-013
	,2.077170831e-013
	,2.691486497e-013
	,3.484759149e-013
	,4.526942012e-013
	,5.899997034e-013
	,7.713442304e-013
	,1.011390452e-012
	,1.329859447e-012
	,1.753349503e-012
	,2.317714729e-012
	,3.071192398e-012
	,4.068880857e-012
	,5.302801603e-012
	,6.915654348e-012
	,9.028135091e-012
	,1.179708468e-011
	,1.542900924e-011
	,2.019590088e-011
	,2.645648301e-011
	,3.468364829e-011
	,4.550156420e-011
	,5.973408776e-011
	,7.846859125e-011
	,1.031419886e-010
	,1.356541440e-010
	,1.784946320e-010
	,2.349918353e-010
	,3.095359492e-010
	,4.079342868e-010
	,5.378744092e-010
	,7.095348180e-010
	,9.363966281e-010
	,1.236318433e-009
	,1.632963603e-009
	,2.157693760e-009
	,2.852081161e-009
	,3.771244736e-009
	,4.988281112e-009
	,6.600133484e-009
	,8.735393231e-009
	,1.154156524e-008
	,1.521475791e-008
	,2.007278983e-008
	,2.649635028e-008
	,3.498731407e-008
	,4.620633552e-008
	,6.102151599e-008
	,8.057103070e-008
	,1.063431261e-007
	,1.402773681e-007
	,1.848913251e-007
	,2.434368009e-007
	,3.200890366e-007
	,4.201705823e-007
	,5.504083917e-007
	,7.192147749e-007
	,9.369907796e-007
	,1.216409852e-006
	,1.572663277e-006
	,2.023622967e-006
	,2.589873888e-006
	,3.294573709e-006
	,4.163108508e-006
	,5.222539143e-006
	,6.500867458e-006
	,8.026184895e-006
	,9.825787901e-006
	,1.192535952e-005
	,1.434830161e-005
	,1.711527543e-005
	,2.024397038e-005
	,2.374910876e-005
	,2.764257391e-005
	,3.193369291e-005
	,3.662962747e-005
	,4.173574358e-005
	,4.725598729e-005
	,5.319325094e-005
	,5.954967034e-005
	,6.632669478e-005
	,7.352500017e-005
	,8.078308315e-005
	,8.833776346e-005
	,9.628350093e-005
	,1.046141073e-004
	,1.133235915e-004
	,1.224060568e-004
	,1.318555759e-004
	,1.416664120e-004
	,1.518328148e-004
	,1.623490323e-004
	,1.732093610e-004
	,1.844087069e-004
	,1.959408296e-004
	,2.078000656e-004
	,2.199807990e-004
	,2.324774782e-004
	,2.452843199e-004
	,2.583928313e-004
	,2.718006025e-004
	,2.855024864e-004
	,2.988910598e-004
	,3.115373920e-004
	,3.243981248e-004
	,3.374704322e-004
	,3.507513533e-004
	,3.642356170e-004
	,3.779181480e-004
	,3.918009940e-004
	,4.058819243e-004
	,4.201588482e-004
	,-7.045062961e-012
	,-4.954033068e-012
	,-3.483847766e-012
	,-2.450034665e-012
	,-1.723126669e-012
	,-1.211856771e-012
	,-8.523357883e-013
	,-5.994187535e-013
	,-4.215739764e-013
	,-2.964581246e-013
	,-2.084730199e-013
	,-1.465614804e-013
	,-1.030730249e-013
	,-7.241695100e-014
	,-5.090913284e-014
	,-3.581264940e-014
	,-2.515058891e-014
	,-1.766161277e-014
	,-1.243209115e-014
	,-8.687080911e-015
	,-6.076262437e-015
	,-4.261900247e-015
	,-3.001136006e-015
	,-2.109541497e-015
	,-1.458873317e-015
	,-1.036338455e-015
	,-7.204816358e-016
	,-4.656657528e-016
	,-3.358558582e-016
	,-2.368014053e-016
	,-1.641684354e-016
	,-8.171878799e-017
	,-7.017897033e-017
	,-2.292315595e-017
	,-1.827589907e-017
	,-1.603059518e-017
	,-2.213991042e-017
	,1.467263007e-017
	,5.378116298e-018
	,1.122634968e-017
	,-1.493405143e-017
	,-1.174885290e-017
	,1.968540153e-017
	,1.200959521e-017
	,1.644798662e-017
	,2.678682777e-017
	,-5.587321306e-018
	,1.028645501e-017
	,1.514257737e-017
	,5.795847236e-018
	,1.383716813e-017
	,4.072707040e-018
	,-1.357795387e-018
	,1.639577023e-017
	,-1.242766572e-017
	,-8.876952597e-018
	,-2.710046555e-017
	,1.681350118e-017
	,6.944607351e-018
	,2.328833100e-017
	,9.033262127e-018
	,-2.141040944e-018
	,2.005091608e-017
	,4.417487878e-017
	,4.057194929e-017
	,6.182401166e-017
	,6.568802300e-017
	,3.216511380e-017
	,7.759335524e-017
	,1.253191169e-016
	,1.315328649e-016
	,1.633848503e-016
	,1.999885253e-016
	,2.675565074e-016
	,3.387274190e-016
	,4.213859319e-016
	,5.153231806e-016
	,6.675861140e-016
	,8.296135085e-016
	,1.043648407e-015
	,1.280815157e-015
	,1.688102839e-015
	,2.173401777e-015
	,2.761566963e-015
	,3.587786577e-015
	,4.653835976e-015
	,6.041172697e-015
	,7.941117517e-015
	,1.035293941e-014
	,1.361938662e-014
	,1.791277316e-014
	,2.360602836e-014
	,3.114372238e-014
	,4.111281942e-014
	,5.437436743e-014
	,7.209127716e-014
	,9.569678353e-014
	,1.242136050e-013
	,1.597341036e-013
	,2.060036030e-013
	,2.666175656e-013
	,3.462361981e-013
	,4.510622308e-013
	,5.895943999e-013
	,7.732461595e-013
	,1.017382281e-012
	,1.342735795e-012
	,1.777999755e-012
	,2.317388116e-012
	,3.007731076e-012
	,3.908901650e-012
	,5.086216665e-012
	,6.625281311e-012
	,8.638745092e-012
	,1.127463823e-011
	,1.472760054e-011
	,1.925395872e-011
	,2.519117470e-011
	,3.298373697e-011
	,4.321217899e-011
	,5.664517641e-011
	,7.430396760e-011
	,9.753066562e-011
	,1.280970529e-010
	,1.683430490e-010
	,2.213602659e-010
	,2.912345550e-010
	,3.833681398e-010
	,5.049057453e-010
	,6.653001820e-010
	,8.770589693e-010
	,1.156737606e-009
	,1.526139825e-009
	,2.014376590e-009
	,2.659917991e-009
	,3.513764564e-009
	,4.643564043e-009
	,6.139106519e-009
	,8.100203439e-009
	,1.065650822e-008
	,1.403444512e-008
	,1.849761020e-008
	,2.439373462e-008
	,3.218102223e-008
	,4.246243116e-008
	,5.603009353e-008
	,7.392255656e-008
	,9.749804163e-008
	,1.285267063e-007
	,1.693091965e-007
	,2.228199004e-007
	,2.928837323e-007
	,3.843867097e-007
	,5.035205097e-007
	,6.580567041e-007
	,8.576399800e-007
	,1.114081399e-006
	,1.441623037e-006
	,1.857135861e-006
	,2.380206072e-006
	,3.033064814e-006
	,3.840325392e-006
	,4.828512840e-006
	,6.025400782e-006
	,7.459202038e-006
	,9.157697350e-006
	,1.114741118e-005
	,1.345286537e-005
	,1.609605059e-005
	,1.909610415e-005
	,2.246909167e-005
	,2.622847786e-005
	,3.038497937e-005
	,3.494701614e-005
	,3.992111829e-005
	,4.531228307e-005
	,5.112433680e-005
	,5.736026369e-005
	,6.402246522e-005
	,7.085020735e-005
	,7.788997908e-005
	,8.532908051e-005
	,9.316165627e-005
	,1.013819529e-004
	,1.099842973e-004
	,1.189629968e-004
	,1.283128401e-004
	,1.380278988e-004
	,1.481022407e-004
	,1.585300806e-004
	,1.693056164e-004
	,1.804230575e-004
	,1.918750230e-004
	,2.036560989e-004
	,2.157612611e-004
	,2.281847879e-004
	,2.409210346e-004
	,2.539650723e-004
	,2.673115761e-004
	,2.806521128e-004
	,2.929884318e-004
	,-7.294629585e-012
	,-5.137553921e-012
	,-3.618724267e-012
	,-2.549279238e-012
	,-1.796111107e-012
	,-1.265539115e-012
	,-8.918226946e-013
	,-6.284762755e-013
	,-4.429559009e-013
	,-3.122198968e-013
	,-2.200726253e-013
	,-1.551354083e-013
	,-1.093465606e-013
	,-7.710399676e-014
	,-5.428935952e-014
	,-3.831537998e-014
	,-2.699998829e-014
	,-1.901030937e-014
	,-1.340482989e-014
	,-9.443487240e-015
	,-6.615396452e-015
	,-4.652113176e-015
	,-3.273601022e-015
	,-2.317937027e-015
	,-1.633328207e-015
	,-1.112208840e-015
	,-7.828801974e-016
	,-5.078043629e-016
	,-3.613896629e-016
	,-2.457304045e-016
	,-1.988401047e-016
	,-1.072525927e-016
	,-8.631382850e-017
	,-6.224208217e-017
	,-3.827476858e-017
	,-5.310421752e-017
	,-1.958130831e-017
	,-2.819700928e-017
	,-1.937244284e-017
	,-1.153998742e-017
	,-1.060009277e-017
	,-1.670940800e-017
	,1.206181158e-017
	,-6.944946908e-018
	,1.268840801e-017
	,4.709899550e-017
	,-8.668087106e-018
	,1.722970419e-018
	,2.135632534e-017
	,4.175611788e-019
	,3.028379651e-018
	,-1.785816814e-017
	,1.968540151e-017
	,1.404603361e-017
	,-4.595210299e-018
	,-5.289535207e-017
	,1.399381723e-017
	,7.623420154e-018
	,2.297350466e-018
	,9.555425822e-018
	,1.456819729e-017
	,-8.772519869e-018
	,-1.143555471e-017
	,1.258397525e-017
	,3.937097279e-017
	,3.085970456e-017
	,3.905767457e-017
	,5.524474910e-017
	,3.148630099e-017
	,1.503814460e-017
	,-1.932175481e-018
	,4.396601329e-017
	,-3.550882938e-018
	,6.192844439e-017
	,3.676015430e-017
	,5.968314050e-017
	,7.665346058e-017
	,1.106985335e-016
	,1.073044695e-016
	,1.552913130e-016
	,1.805640358e-016
	,2.285508794e-016
	,3.036902351e-016
	,3.559588209e-016
	,4.378340883e-016
	,5.596548783e-016
	,6.779771715e-016
	,8.723264987e-016
	,1.119779874e-015
	,1.378616417e-015
	,1.784964204e-015
	,2.274388236e-015
	,3.009333636e-015
	,3.873932282e-015
	,4.963896778e-015
	,6.518795829e-015
	,8.494767683e-015
	,1.115085775e-014
	,1.467311295e-014
	,1.929102424e-014
	,2.546764637e-014
	,3.370681509e-014
	,4.473010842e-014
	,5.854760411e-014
	,7.500166095e-014
	,9.645172780e-014
	,1.238886103e-013
	,1.595965135e-013
	,2.062828561e-013
	,2.674807544e-013
	,3.481081028e-013
	,4.545426085e-013
	,5.955719210e-013
	,7.832330101e-013
	,1.024650590e-012
	,1.326270721e-012
	,1.718629534e-012
	,2.229629003e-012
	,2.895429592e-012
	,3.763801079e-012
	,4.897100150e-012
	,6.377145833e-012
	,8.303853944e-012
	,1.082016147e-011
	,1.411143626e-011
	,1.841973183e-011
	,2.406271744e-011
	,3.145863211e-011
	,4.115796832e-011
	,5.388579689e-011
	,7.059736794e-011
	,9.255188194e-011
	,1.214098501e-010
	,1.593619962e-010
	,2.093000856e-010
	,2.750425234e-010
	,3.615810286e-010
	,4.756055796e-010
	,6.259178266e-010
	,8.241579810e-010
	,1.085727521e-009
	,1.431013907e-009
	,1.887019277e-009
	,2.489528255e-009
	,3.286000696e-009
	,4.339444321e-009
	,5.717437557e-009
	,7.504361022e-009
	,9.863096341e-009
	,1.297594867e-008
	,1.708466794e-008
	,2.250737186e-008
	,2.966301199e-008
	,3.910265468e-008
	,5.155004257e-008
	,6.795392428e-008
	,8.955514679e-008
	,1.179720089e-007
	,1.553078012e-007
	,2.042846693e-007
	,2.684077151e-007
	,3.521623891e-007
	,4.612460605e-007
	,6.028312500e-007
	,7.858524332e-007
	,1.021300825e-006
	,1.322502352e-006
	,1.705341749e-006
	,2.188401925e-006
	,2.792953413e-006
	,3.542769295e-006
	,4.463739112e-006
	,5.583279985e-006
	,6.929586929e-006
	,8.530787456e-006
	,1.041408943e-005
	,1.260501382e-005
	,1.512678943e-005
	,1.799995638e-005
	,2.124218891e-005
	,2.486831832e-005
	,2.889051551e-005
	,3.331866883e-005
	,3.816057007e-005
	,4.342238111e-005
	,4.910901014e-005
	,5.522444159e-005
	,6.161656088e-005
	,6.812798070e-005
	,7.504613413e-005
	,8.236579313e-005
	,9.008160244e-005
	,9.818820759e-005
	,1.066801963e-004
	,1.155520488e-004
	,1.247981392e-004
	,1.344115134e-004
	,1.443873502e-004
	,1.547203267e-004
	,1.654041582e-004
	,1.764329349e-004
	,-7.516193039e-012
	,-5.300339915e-012
	,-3.738406432e-012
	,-2.637176306e-012
	,-1.860628139e-012
	,-1.312905315e-012
	,-9.265851160e-013
	,-6.540319066e-013
	,-4.617152060e-013
	,-3.259992746e-013
	,-2.302196235e-013
	,-1.625467387e-013
	,-1.147735645e-013
	,-8.110183865e-014
	,-5.727347282e-014
	,-4.048888636e-014
	,-2.858882798e-014
	,-2.014700752e-014
	,-1.421355702e-014
	,-1.002345446e-014
	,-7.054170605e-015
	,-4.964471498e-015
	,-3.454321876e-015
	,-2.404459552e-015
	,-1.686484471e-015
	,-1.149334678e-015
	,-8.245488602e-016
	,-5.294219399e-016
	,-3.794565268e-016
	,-2.535106436e-016
	,-2.044794726e-016
	,-1.055294525e-016
	,-6.104110567e-017
	,-4.840474426e-017
	,-2.986793310e-017
	,-3.091226049e-017
	,-2.140888124e-017
	,-1.916357736e-017
	,-1.425523863e-017
	,1.764896312e-017
	,-7.780408815e-018
	,3.091192097e-017
	,7.675636547e-018
	,4.124923421e-018
	,1.336722082e-017
	,1.498592827e-017
	,-1.728378807e-017
	,2.072972891e-017
	,2.772672242e-017
	,3.028532452e-017
	,4.229356149e-018
	,-1.435967139e-017
	,-1.315869489e-017
	,3.602759710e-018
	,-3.289801063e-018
	,-1.294982942e-017
	,1.931835882e-018
	,-7.153812409e-018
	,1.237510977e-017
	,2.506368756e-017
	,3.498326960e-018
	,1.012980588e-017
	,7.466771037e-018
	,8.876613011e-018
	,-9.294683569e-018
	,-1.164442020e-017
	,1.300170620e-017
	,2.281838366e-017
	,-9.869063640e-018
	,9.242127588e-018
	,-1.568189199e-019
	,-1.096560740e-017
	,-2.480294532e-017
	,2.083416161e-017
	,3.362717213e-017
	,1.195737879e-017
	,1.712679937e-017
	,2.119967619e-017
	,2.939764619e-017
	,-5.169590404e-018
	,2.710012593e-017
	,2.266173453e-017
	,6.046638603e-017
	,5.665459105e-017
	,5.331274341e-017
	,7.002198164e-017
	,1.361801218e-016
	,1.288176137e-016
	,1.414539751e-016
	,1.783187319e-016
	,2.337725163e-016
	,2.645801743e-016
	,3.456199797e-016
	,4.366331117e-016
	,5.439899674e-016
	,7.219433546e-016
	,8.925342337e-016
	,1.174972576e-015
	,1.469681766e-015
	,1.889605809e-015
	,2.457302178e-015
	,3.195693859e-015
	,4.125301885e-015
	,5.411338848e-015
	,7.051193932e-015
	,9.219687540e-015
	,1.208265886e-014
	,1.586004325e-014
	,2.092941726e-014
	,2.753113285e-014
	,3.513315744e-014
	,4.492268239e-014
	,5.762269556e-014
	,7.404187186e-014
	,9.541324864e-014
	,1.232717261e-013
	,1.596822527e-013
	,2.075356313e-013
	,2.705384406e-013
	,3.540417099e-013
	,4.635145817e-013
	,5.971325116e-013
	,7.700931262e-013
	,9.945083257e-013
	,1.285834991e-012
	,1.664189112e-012
	,2.156183912e-012
	,2.796413309e-012
	,3.630201738e-012
	,4.716848563e-012
	,6.134155652e-012
	,7.983983566e-012
	,1.039996501e-011
	,1.355758709e-011
	,1.768709486e-011
	,2.309113069e-011
	,3.015126873e-011
	,3.939111974e-011
	,5.149566761e-011
	,6.736591546e-011
	,8.818697108e-011
	,1.155191096e-010
	,1.514185586e-010
	,1.985968063e-010
	,2.606309178e-010
	,3.422420348e-010
	,4.496646736e-010
	,5.911357960e-010
	,7.775442645e-010
	,1.023292879e-009
	,1.347444617e-009
	,1.775255550e-009
	,2.340125852e-009
	,3.086413418e-009
	,4.059940203e-009
	,5.314221326e-009
	,6.967807965e-009
	,9.147969853e-009
	,1.202260805e-008
	,1.581308156e-008
	,2.081100760e-008
	,2.740020995e-008
	,3.608530184e-008
	,4.752876802e-008
	,6.259885180e-008
	,8.243039921e-008
	,1.085013753e-007
	,1.427387497e-007
	,1.876357731e-007
	,2.464060836e-007
	,3.231683177e-007
	,4.231645511e-007
	,5.530115812e-007
	,7.209792770e-007
	,9.372834679e-007
	,1.214372294e-006
	,1.567175322e-006
	,2.013275970e-006
	,2.572962734e-006
	,3.269116760e-006
	,4.126905402e-006
	,5.173274441e-006
	,6.436262450e-006
	,7.944193297e-006
	,9.724829053e-006
	,1.180458252e-005
	,1.420788270e-005
	,1.695661102e-005
	,2.006992402e-005
	,2.356418082e-005
	,2.745310431e-005
	,3.174794446e-005
	,3.645788860e-005
	,4.159040294e-005
	,4.715159567e-005
	,5.310398417e-005
	,5.907642005e-005
	,6.546085480e-005
	,7.225355713e-005
	,7.944940816e-005
	,8.704398041e-005
	,-7.715416399e-012
	,-5.446864844e-012
	,-3.846063845e-012
	,-2.716302747e-012
	,-1.918752269e-012
	,-1.355649739e-012
	,-9.579677807e-013
	,-6.770747816e-013
	,-4.785799968e-013
	,-3.384161706e-013
	,-2.392681459e-013
	,-1.692063100e-013
	,-1.196794491e-013
	,-8.460623586e-014
	,-5.990110496e-014
	,-4.238329625e-014
	,-2.992029318e-014
	,-2.112204379e-014
	,-1.493602271e-014
	,-1.050546376e-014
	,-7.357704361e-015
	,-5.149056364e-015
	,-3.642405239e-015
	,-2.491660889e-015
	,-1.679121963e-015
	,-1.197164873e-015
	,-8.415191803e-016
	,-6.032036700e-016
	,-3.785688485e-016
	,-2.699065836e-016
	,-1.641162190e-016
	,-1.718442417e-016
	,-1.038063123e-016
	,-2.861474023e-017
	,-9.508617858e-017
	,-2.924133666e-017
	,-2.381083424e-017
	,-1.832811545e-017
	,-1.044497150e-018
	,-1.253362629e-018
	,3.707192470e-018
	,-3.425410814e-017
	,-4.020830216e-018
	,1.300170623e-017
	,3.602759724e-018
	,-5.378455828e-018
	,4.594870741e-018
	,8.875085064e-019
	,2.767297806e-018
	,2.161740719e-017
	,2.349719649e-017
	,-2.845809115e-017
	,1.206181157e-017
	,4.697775406e-019
	,3.159073375e-017
	,-1.294982942e-017
	,3.895324184e-017
	,4.697775340e-019
	,3.127743553e-017
	,2.469817297e-017
	,2.281838367e-017
	,2.015534882e-017
	,-2.193257318e-018
	,5.952496319e-018
	,7.832285619e-018
	,1.650020295e-017
	,1.159186422e-017
	,7.780069245e-018
	,6.318010898e-018
	,-4.699643064e-018
	,3.383603761e-017
	,1.467263001e-017
	,3.028379614e-018
	,1.556030829e-017
	,5.325899868e-018
	,9.137694838e-018
	,4.380936417e-017
	,1.059975318e-017
	,9.503209420e-018
	,8.615531137e-018
	,4.192957486e-017
	,3.654976034e-018
	,4.093746384e-017
	,1.879772318e-017
	,-6.109485064e-018
	,1.921545413e-017
	,4.333788829e-018
	,3.905767453e-017
	,4.161627663e-017
	,5.608021098e-017
	,4.809110645e-017
	,6.286833901e-017
	,5.769891843e-017
	,7.106630901e-017
	,8.239726119e-017
	,1.138315156e-016
	,1.516883835e-016
	,1.599907862e-016
	,2.345035455e-016
	,2.068288697e-016
	,3.300072853e-016
	,3.833201985e-016
	,4.384084683e-016
	,5.499426335e-016
	,7.511845215e-016
	,9.784301614e-016
	,1.258414335e-015
	,1.572704662e-015
	,2.043069719e-015
	,2.615152263e-015
	,3.419858733e-015
	,4.461157573e-015
	,5.769177628e-015
	,7.589962432e-015
	,1.003394961e-014
	,1.318813162e-014
	,1.680427186e-014
	,2.137048893e-014
	,2.724509158e-014
	,3.480262782e-014
	,4.465784096e-014
	,5.733769861e-014
	,7.383384184e-014
	,9.532249659e-014
	,1.234106738e-013
	,1.602981970e-013
	,2.088744590e-013
	,2.701661379e-013
	,3.481936332e-013
	,4.491824415e-013
	,5.799654403e-013
	,7.494593579e-013
	,9.693491212e-013
	,1.254513315e-012
	,1.621824928e-012
	,2.098333240e-012
	,2.717500172e-012
	,3.522705569e-012
	,4.570654269e-012
	,5.935545208e-012
	,7.714460316e-012
	,1.003420125e-011
	,1.306176624e-011
	,1.701575219e-011
	,2.218300709e-011
	,2.894004487e-011
	,3.778155312e-011
	,4.935758278e-011
	,6.452305454e-011
	,8.440243248e-011
	,1.104331672e-010
	,1.445589674e-010
	,1.893527446e-010
	,2.481837722e-010
	,3.254848783e-010
	,4.271168942e-010
	,5.608278022e-010
	,7.368496017e-010
	,9.687175459e-010
	,1.274354887e-009
	,1.677527116e-009
	,2.209800988e-009
	,2.902165144e-009
	,3.787238064e-009
	,4.952446812e-009
	,6.486653953e-009
	,8.507042666e-009
	,1.116805928e-008
	,1.467315960e-008
	,1.928929195e-008
	,2.536894604e-008
	,3.337492072e-008
	,4.391433343e-008
	,5.778258151e-008
	,7.601967284e-008
	,9.998215383e-008
	,1.314342012e-007
	,1.726618139e-007
	,2.266141410e-007
	,2.970756071e-007
	,3.888713183e-007
	,5.081058739e-007
	,6.624261160e-007
	,8.613093608e-007
	,1.116376936e-006
	,1.441632438e-006
	,1.853676796e-006
	,2.371809055e-006
	,3.017981302e-006
	,3.816571096e-006
	,4.793954995e-006
	,5.977895197e-006
	,7.396782018e-006
	,9.078805832e-006
	,1.105114537e-005
	,1.333925832e-005
	,1.596634177e-005
	,1.895299863e-005
	,2.231711294e-005
	,2.607385604e-005
	,3.023597975e-005
	,-7.896090572e-012
	,-5.579721981e-012
	,-3.943813097e-012
	,-2.788194818e-012
	,-1.971546935e-012
	,-1.394447337e-012
	,-9.865194826e-013
	,-6.980133369e-013
	,-4.939512950e-013
	,-3.496877527e-013
	,-2.475237106e-013
	,-1.752815802e-013
	,-1.241007657e-013
	,-8.785440734e-014
	,-6.223235700e-014
	,-4.406513329e-014
	,-3.115301723e-014
	,-2.200648466e-014
	,-1.549666987e-014
	,-1.085317257e-014
	,-7.644633311e-015
	,-5.327166401e-015
	,-3.681202002e-015
	,-2.580846448e-015
	,-1.784442380e-015
	,-1.245882746e-015
	,-8.238178310e-016
	,-6.239857850e-016
	,-4.161646345e-016
	,-2.770602262e-016
	,-1.922086258e-016
	,-1.345617539e-016
	,-6.986567212e-017
	,-6.678490632e-017
	,-4.119888527e-017
	,-2.130444850e-017
	,-2.146109761e-017
	,-1.216658385e-017
	,-3.749152305e-017
	,2.814445339e-017
	,-1.733600443e-017
	,1.597803930e-017
	,-5.065157606e-018
	,3.399268676e-017
	,-4.856292132e-018
	,1.185294610e-017
	,6.264266604e-019
	,-3.498666530e-018
	,7.936718384e-018
	,1.263619164e-017
	,6.786430232e-019
	,-7.414894248e-018
	,2.078194527e-017
	,-1.430745502e-017
	,1.096373972e-018
	,3.653447979e-019
	,-7.884841582e-018
	,2.663017864e-017
	,9.085478496e-018
	,6.840174607e-018
	,3.514144686e-017
	,-1.096713558e-018
	,-9.451332676e-018
	,1.514257735e-017
	,-1.357795410e-018
	,1.133078237e-017
	,4.036308380e-017
	,2.609120390e-019
	,8.719963893e-018
	,1.723123212e-017
	,4.083303112e-017
	,-5.952835936e-018
	,6.631309107e-018
	,-5.952835939e-018
	,2.657796225e-017
	,4.751519801e-018
	,6.004712667e-018
	,2.031199790e-017
	,2.997202626e-017
	,2.146075803e-017
	,-2.093893399e-017
	,4.083303110e-017
	,8.197800176e-018
	,1.331500438e-017
	,1.430711540e-017
	,-1.300204584e-017
	,3.968274241e-018
	,1.070418590e-017
	,1.817112674e-017
	,-3.342017491e-018
	,2.955429528e-017
	,3.336609025e-017
	,6.735741814e-018
	,1.200959513e-017
	,4.443596058e-017
	,2.845775151e-017
	,2.015534876e-017
	,2.746564049e-017
	,6.198066071e-017
	,2.871883335e-017
	,3.754339980e-017
	,5.675902376e-017
	,8.808884545e-017
	,1.092364751e-016
	,6.386045001e-017
	,1.548213656e-016
	,1.820783105e-016
	,2.335114344e-016
	,2.506906200e-016
	,3.001395219e-016
	,3.847822568e-016
	,5.080651052e-016
	,6.111402185e-016
	,7.857517581e-016
	,1.015086053e-015
	,1.296166770e-015
	,1.681053629e-015
	,2.162227474e-015
	,2.818952753e-015
	,3.688773036e-015
	,4.755449031e-015
	,6.248732766e-015
	,8.073955961e-015
	,1.016078317e-014
	,1.295331461e-014
	,1.652214681e-014
	,2.115937815e-014
	,2.707930461e-014
	,3.476826945e-014
	,4.470969182e-014
	,5.762964033e-014
	,7.433334363e-014
	,9.608574326e-014
	,1.241403976e-013
	,1.594690011e-013
	,2.049796922e-013
	,2.637251965e-013
	,3.395699431e-013
	,4.377093041e-013
	,5.646944497e-013
	,7.290980023e-013
	,9.420293079e-013
	,1.218205498e-012
	,1.576572916e-012
	,2.041935958e-012
	,2.646144205e-012
	,3.431450467e-012
	,4.452983531e-012
	,5.775631376e-012
	,7.495079767e-012
	,9.734387127e-012
	,1.265286628e-011
	,1.645909942e-011
	,2.142640652e-011
	,2.791322521e-011
	,3.638992651e-011
	,4.747365757e-011
	,6.197441151e-011
	,8.095870589e-011
	,1.058282486e-010
	,1.384273001e-010
	,1.811846168e-010
	,2.373000991e-010
	,3.109932717e-010
	,4.077163551e-010
	,5.347793003e-010
	,7.019277340e-010
	,9.219801345e-010
	,1.211933018e-009
	,1.594371431e-009
	,2.090310984e-009
	,2.718209171e-009
	,3.543515416e-009
	,4.628483947e-009
	,6.055155071e-009
	,7.931599156e-009
	,1.040011791e-008
	,1.364799707e-008
	,1.792157869e-008
	,2.354463704e-008
	,3.094231004e-008
	,4.067216361e-008
	,5.346435364e-008
	,7.027329297e-008
	,9.234370695e-008
	,1.212934224e-007
	,1.592175769e-007
	,2.088267499e-007
	,2.735996323e-007
	,3.579780054e-007
	,4.675927023e-007
	,6.095207965e-007
	,7.925666810e-007
	,1.027552628e-006
	,1.327595760e-006
	,1.708339010e-006
	,2.188095897e-006
	,2.787865701e-006
	,3.531180159e-006
	,4.443708296e-006
	,5.552836620e-006
	,-8.061151895e-012
	,-5.701170207e-012
	,-4.033123662e-012
	,-2.853859671e-012
	,-2.019906551e-012
	,-1.429977287e-012
	,-1.012587356e-012
	,-7.171979965e-013
	,-5.081137320e-013
	,-3.600161506e-013
	,-2.551600413e-013
	,-1.807820525e-013
	,-1.281608495e-013
	,-9.082703304e-014
	,-6.434283822e-014
	,-4.555538848e-014
	,-3.219348061e-014
	,-2.275719940e-014
	,-1.595779263e-014
	,-1.115054479e-014
	,-7.779769275e-015
	,-5.453895529e-015
	,-3.756341357e-015
	,-2.619538778e-015
	,-1.837807510e-015
	,-1.263375229e-015
	,-8.855375798e-016
	,-6.178242534e-016
	,-4.298975397e-016
	,-3.074501533e-016
	,-1.717920253e-016
	,-1.228652871e-016
	,-1.180091648e-016
	,-3.065117864e-017
	,-6.897799384e-017
	,-4.772593146e-017
	,-2.109558303e-017
	,-1.999903927e-017
	,-1.932175431e-018
	,1.112191694e-017
	,9.816507699e-018
	,5.117034444e-018
	,4.175611889e-019
	,-2.506402712e-017
	,-2.454339136e-018
	,2.287060006e-017
	,-1.717935533e-017
	,4.020490675e-018
	,1.002537316e-017
	,3.654976085e-018
	,8.406665706e-018
	,2.203513814e-017
	,3.414933586e-017
	,1.754453036e-017
	,3.916057924e-018
	,1.409824997e-017
	,1.707458303e-017
	,1.221846067e-017
	,8.824396648e-018
	,8.876613016e-018
	,3.101635367e-017
	,3.571582693e-017
	,-5.065157640e-018
	,3.707192431e-018
	,3.195624832e-017
	,-1.827742737e-018
	,3.169516647e-017
	,-1.080895829e-017
	,-5.743970453e-018
	,-1.294982944e-017
	,-1.905914467e-017
	,-1.879959117e-018
	,3.942318914e-017
	,2.798780422e-017
	,2.642131314e-017
	,2.187848899e-017
	,1.326278802e-017
	,1.044310407e-017
	,3.352273938e-017
	,7.414554637e-018
	,-1.425523870e-017
	,4.697774932e-019
	,1.404603356e-017
	,1.357455771e-018
	,9.033262083e-018
	,2.730899140e-017
	,3.806556351e-017
	,2.072972884e-017
	,1.759674667e-017
	,-1.984391885e-018
	,8.928829334e-018
	,5.586981686e-018
	,3.926654000e-017
	,9.816507611e-018
	,1.801447762e-017
	,-6.005052345e-018
	,2.187848896e-017
	,2.156519074e-017
	,1.660463564e-017
	,1.644798653e-017
	,3.597690871e-017
	,3.498479769e-017
	,6.715008129e-017
	,2.099081066e-017
	,5.644572554e-017
	,3.258284469e-017
	,6.281612261e-017
	,6.380823363e-017
	,5.357382521e-017
	,2.788337143e-017
	,6.944760153e-017
	,1.047980837e-016
	,7.143182357e-017
	,1.498085942e-016
	,1.076699840e-016
	,1.662567505e-016
	,1.803029539e-016
	,2.561733388e-016
	,3.530869205e-016
	,4.492694731e-016
	,5.443032656e-016
	,6.567251091e-016
	,8.848062109e-016
	,1.123435019e-015
	,1.369582985e-015
	,1.790812438e-015
	,2.354174848e-015
	,3.029802453e-015
	,3.881869170e-015
	,4.911262678e-015
	,6.225496481e-015
	,7.952709551e-015
	,1.006611489e-014
	,1.289436233e-014
	,1.650475876e-014
	,2.108664075e-014
	,2.699523625e-014
	,3.476957486e-014
	,4.475485898e-014
	,5.776007682e-014
	,7.411361715e-014
	,9.507196245e-014
	,1.221180054e-013
	,1.568912878e-013
	,2.017995064e-013
	,2.593550519e-013
	,3.336922597e-013
	,4.296018773e-013
	,5.536487556e-013
	,7.140531087e-013
	,9.215940662e-013
	,1.190513852e-012
	,1.538911181e-012
	,1.990841353e-012
	,2.577300891e-012
	,3.338872567e-012
	,4.328480908e-012
	,5.614793261e-012
	,7.288134703e-012
	,9.466436529e-012
	,1.230391216e-011
	,1.600224253e-011
	,2.080886096e-011
	,2.706881065e-011
	,3.523797842e-011
	,4.590588526e-011
	,5.984607662e-011
	,7.807436230e-011
	,1.019257839e-010
	,1.331557933e-010
	,1.740748353e-010
	,2.277261317e-010
	,2.981212605e-010
	,3.905519331e-010
	,5.120187024e-010
	,6.717841640e-010
	,8.821329958e-010
	,1.159400966e-009
	,1.517681787e-009
	,1.965877641e-009
	,2.553960690e-009
	,3.325749177e-009
	,4.338939355e-009
	,5.669474357e-009
	,7.417285787e-009
	,9.713827232e-009
	,1.273192237e-008
	,1.669845058e-008
	,2.191185130e-008
	,2.876347216e-008
	,3.776622778e-008
	,4.959143266e-008
	,6.511621651e-008
	,8.548421561e-008
	,1.121827161e-007
	,1.471398583e-007
	,1.928458024e-007
	,2.525017282e-007
	,3.301999791e-007
	,4.311371947e-007
	,5.618595908e-007
	,-8.213117978e-012
	,-5.812934124e-012
	,-4.115342827e-012
	,-2.914299909e-012
	,-2.064347328e-012
	,-1.462703792e-012
	,-1.036665682e-012
	,-7.348525599e-013
	,-5.210448548e-013
	,-3.695517474e-013
	,-2.621400645e-013
	,-1.859616031e-013
	,-1.319186006e-013
	,-9.355727035e-014
	,-6.630852345e-014
	,-4.690293633e-014
	,-3.314825693e-014
	,-2.334881087e-014
	,-1.640946423e-014
	,-1.138839035e-014
	,-7.943467593e-015
	,-5.509714828e-015
	,-3.842916098e-015
	,-2.689822011e-015
	,-1.840470545e-015
	,-1.271625416e-015
	,-9.081994841e-016
	,-6.010105825e-016
	,-4.208641078e-016
	,-2.727262675e-016
	,-1.809298900e-016
	,-1.082447037e-016
	,-7.477401085e-017
	,-5.534952140e-017
	,-5.242540471e-017
	,-2.616057087e-017
	,-1.603059519e-017
	,-2.208769405e-017
	,1.978983427e-017
	,-1.979017380e-017
	,-1.477740233e-017
	,2.255730185e-017
	,2.344498013e-017
	,5.848063613e-018
	,3.498326985e-018
	,-7.467110608e-018
	,2.453999592e-018
	,2.516812031e-017
	,3.038975726e-017
	,-2.506555514e-018
	,2.177405629e-017
	,1.634355386e-017
	,2.506215951e-018
	,3.670793796e-017
	,1.315835532e-017
	,1.368051901e-017
	,-7.571543365e-018
	,-3.394233809e-018
	,-1.467296962e-017
	,1.461888550e-018
	,2.041643067e-017
	,6.422443647e-018
	,1.451598091e-017
	,1.749231397e-017
	,-2.344531970e-017
	,1.827403126e-018
	,4.908168924e-018
	,1.712679938e-017
	,4.229356117e-018
	,2.276616728e-017
	,-4.699643067e-018
	,3.085970455e-017
	,2.396714377e-017
	,1.070418592e-017
	,2.062529612e-017
	,9.712074901e-018
	,7.153472794e-018
	,2.835331880e-017
	,1.629133745e-017
	,6.579092725e-018
	,2.532476937e-017
	,1.806669401e-017
	,7.675636479e-018
	,3.811625136e-018
	,3.759561619e-017
	,2.609120080e-019
	,1.519479368e-017
	,1.305239394e-018
	,3.289614293e-017
	,2.072972884e-017
	,7.780069205e-018
	,2.955429528e-017
	,5.487923447e-017
	,6.996823658e-018
	,1.613468832e-017
	,7.675636458e-018
	,2.537698571e-017
	,2.694347679e-017
	,7.988934670e-018
	,1.853664130e-017
	,-8.145923503e-018
	,3.357495571e-017
	,1.357455740e-018
	,4.124923320e-018
	,2.850996787e-017
	,-1.571729708e-017
	,3.164295003e-017
	,2.224400352e-017
	,5.581912910e-017
	,9.659858476e-018
	,3.383603754e-017
	,1.770117937e-017
	,3.508923041e-017
	,2.621244760e-017
	,2.746564046e-017
	,5.989200591e-017
	,8.182288109e-017
	,3.843107805e-017
	,7.623572955e-017
	,5.085857398e-017
	,9.320604963e-017
	,1.479288048e-016
	,1.316372976e-016
	,1.609828972e-016
	,1.914772570e-016
	,2.591496718e-016
	,3.327225364e-016
	,3.795606198e-016
	,4.177307859e-016
	,5.298915476e-016
	,6.955218716e-016
	,8.893490351e-016
	,1.148812175e-015
	,1.503935704e-015
	,1.879266968e-015
	,2.412500533e-015
	,3.072254361e-015
	,3.912676828e-015
	,4.888548557e-015
	,6.191503625e-015
	,7.923520600e-015
	,1.010861901e-014
	,1.292731085e-014
	,1.653708069e-014
	,2.121488415e-014
	,2.723130646e-014
	,3.488873261e-014
	,4.461152504e-014
	,5.710909535e-014
	,7.316620334e-014
	,9.381271248e-014
	,1.203263573e-013
	,1.545931409e-013
	,1.986304427e-013
	,2.554634703e-013
	,3.287720679e-013
	,4.234169528e-013
	,5.457026773e-013
	,7.037380260e-013
	,9.072715337e-013
	,1.170554458e-012
	,1.511363809e-012
	,1.952825643e-012
	,2.525027919e-012
	,3.267205286e-012
	,4.230443944e-012
	,5.481391977e-012
	,7.107056897e-012
	,9.221029044e-012
	,1.197098367e-011
	,1.555089024e-011
	,2.021452139e-011
	,2.629383299e-011
	,3.422351112e-011
	,4.457339922e-011
	,5.809076331e-011
	,7.571878956e-011
	,9.872491164e-011
	,1.288169530e-010
	,1.682079177e-010
	,2.198128910e-010
	,2.874766326e-010
	,3.762782432e-010
	,4.929397386e-010
	,6.463792841e-010
	,8.484661820e-010
	,1.109065028e-009
	,1.430966197e-009
	,1.852683155e-009
	,2.405267476e-009
	,3.129597610e-009
	,4.079425587e-009
	,5.324623311e-009
	,6.957138736e-009
	,9.099513831e-009
	,1.191163358e-008
	,1.560341812e-008
	,2.045030537e-008
	,2.681340459e-008
	,3.516565301e-008
	,4.612564853e-008
	,-8.354296107e-012
	,-5.916666537e-012
	,-4.191629324e-012
	,-2.970354600e-012
	,-2.105600140e-012
	,-1.492994613e-012
	,-1.058921134e-012
	,-7.512317907e-013
	,-5.330902314e-013
	,-3.783941196e-013
	,-2.685990728e-013
	,-1.906509464e-013
	,-1.353241000e-013
	,-9.598909111e-014
	,-6.802471886e-014
	,-4.808976219e-014
	,-3.391897054e-014
	,-2.388194000e-014
	,-1.665503781e-014
	,-1.162325958e-014
	,-8.077820312e-015
	,-5.610962369e-015
	,-3.939881896e-015
	,-2.741568433e-015
	,-1.914878871e-015
	,-1.281128795e-015
	,-9.104447880e-016
	,-5.922382324e-016
	,-4.292187269e-016
	,-3.102176208e-016
	,-2.449993754e-016
	,-1.553960853e-016
	,-9.085665265e-017
	,-6.709820454e-017
	,-9.816847217e-018
	,-3.206102062e-017
	,-7.675976071e-018
	,-3.603099254e-018
	,-1.451632048e-017
	,3.023310817e-017
	,-1.529956602e-017
	,8.615531198e-018
	,-2.454186342e-017
	,-2.819853721e-018
	,2.720455873e-017
	,1.697015031e-017
	,1.174851336e-017
	,1.634355387e-017
	,8.563314817e-018
	,-5.952835900e-018
	,1.253175889e-017
	,2.897991528e-017
	,1.864107412e-017
	,-2.663051822e-017
	,1.775339584e-017
	,-1.676162439e-017
	,2.788337151e-017
	,8.667747541e-018
	,3.576804330e-017
	,-7.884841587e-018
	,7.832285624e-018
	,3.174738284e-017
	,-2.558771906e-018
	,2.663017863e-017
	,7.988934726e-018
	,1.764896308e-017
	,5.534765357e-018
	,-1.568189179e-019
	,1.926767053e-017
	,-2.612516603e-019
	,2.871730507e-018
	,4.072707003e-018
	,2.031199791e-017
	,4.986646303e-017
	,3.305279206e-017
	,3.341830664e-017
	,2.553363485e-017
	,3.723010161e-017
	,-9.869063660e-018
	,2.683904408e-017
	,1.112191687e-017
	,7.936718328e-018
	,1.482927910e-017
	,3.221733013e-017
	,-5.639537742e-018
	,3.159073370e-017
	,5.064817998e-018
	,3.446263401e-017
	,1.545587552e-017
	,-6.944946987e-018
	,4.124923341e-018
	,-4.751859473e-018
	,9.137694807e-018
	,1.042628857e-019
	,1.430711538e-017
	,1.080861863e-017
	,1.086083499e-017
	,-9.451332736e-018
	,1.775339576e-017
	,2.375827825e-017
	,5.346939248e-017
	,3.362717208e-017
	,-2.715421081e-018
	,2.245286901e-017
	,2.563806754e-017
	,7.634016231e-017
	,3.117300271e-017
	,3.446263398e-017
	,-2.062563582e-017
	,3.451485035e-017
	,4.145962749e-017
	,2.292281632e-017
	,5.905654400e-017
	,-8.356317972e-019
	,-1.467296971e-017
	,1.817112669e-017
	,2.490703835e-017
	,1.258397515e-017
	,2.819514059e-018
	,3.582025957e-017
	,6.506142648e-017
	,1.482927903e-017
	,5.728118742e-017
	,2.997202618e-017
	,7.806330247e-017
	,8.417261770e-017
	,5.179846862e-017
	,5.164181951e-017
	,8.840214362e-017
	,9.022971655e-017
	,1.110118316e-016
	,1.163901177e-016
	,1.970644085e-016
	,2.072988169e-016
	,2.151312723e-016
	,3.037424513e-016
	,3.473953362e-016
	,4.603915598e-016
	,6.086338327e-016
	,7.141631155e-016
	,9.493456436e-016
	,1.250216365e-015
	,1.534638929e-015
	,1.902137737e-015
	,2.417461088e-015
	,3.061915520e-015
	,3.897011917e-015
	,4.931000466e-015
	,6.246226380e-015
	,7.996519085e-015
	,1.017133087e-014
	,1.299169364e-014
	,1.667618510e-014
	,2.126067791e-014
	,2.716812465e-014
	,3.473532092e-014
	,4.440422606e-014
	,5.678430953e-014
	,7.275259748e-014
	,9.319645489e-014
	,1.195190400e-013
	,1.533219334e-013
	,1.968957627e-013
	,2.529360414e-013
	,3.252315891e-013
	,4.184359289e-013
	,5.387543495e-013
	,6.941147579e-013
	,8.948727046e-013
	,1.154433802e-012
	,1.490191742e-012
	,1.924929883e-012
	,2.488043377e-012
	,3.215770909e-012
	,4.158735151e-012
	,5.381812071e-012
	,6.969373035e-012
	,9.031318984e-012
	,1.171119789e-011
	,1.519643310e-011
	,1.973201076e-011
	,2.563730217e-011
	,3.333172064e-011
	,4.336443122e-011
	,5.645534788e-011
	,7.354903138e-011
	,9.588563083e-011
	,1.250963331e-010
	,1.633282189e-010
	,2.134124007e-010
	,2.790089127e-010
	,3.649526004e-010
	,4.778772704e-010
	,6.264875522e-010
	,8.176116582e-010
	,1.049917288e-009
	,1.353661523e-009
	,1.750890738e-009
	,2.270580573e-009
	,2.950799787e-009
	,3.841556162e-009
	,-8.486393340e-012
	,-6.013692176e-012
	,-4.262854175e-012
	,-3.022737853e-012
	,-2.144071229e-012
	,-1.521301629e-012
	,-1.079723927e-012
	,-7.664992828e-013
	,-5.443502215e-013
	,-3.865863980e-013
	,-2.745819722e-013
	,-1.950351894e-013
	,-1.384896129e-013
	,-9.828065870e-014
	,-6.957679823e-014
	,-4.915910122e-014
	,-3.461689453e-014
	,-2.421810898e-014
	,-1.693491755e-014
	,-1.179531252e-014
	,-8.181939753e-015
	,-5.680410140e-015
	,-3.937323294e-015
	,-2.751071812e-015
	,-1.944851067e-015
	,-1.335381603e-015
	,-9.132644720e-016
	,-6.490496424e-016
	,-4.718795007e-016
	,-3.136639012e-016
	,-1.945583624e-016
	,-1.796766971e-016
	,-1.406188528e-016
	,-1.126308787e-016
	,-7.190211053e-017
	,-1.430745499e-017
	,-4.025899063e-017
	,-1.926801010e-017
	,-2.276650685e-017
	,-1.681384074e-017
	,-4.438561170e-018
	,4.647087118e-018
	,1.049532050e-017
	,-1.634389342e-017
	,9.555425844e-018
	,1.509036101e-017
	,-4.177479333e-018
	,1.754453037e-017
	,-9.138034437e-018
	,9.555425835e-018
	,1.341943718e-017
	,1.931835888e-018
	,3.247841203e-017
	,1.263619163e-017
	,1.566321297e-018
	,-1.420302229e-017
	,-2.490737803e-017
	,1.665685207e-017
	,1.096526780e-017
	,3.393894220e-018
	,2.569028399e-017
	,2.971094443e-017
	,-9.400644520e-019
	,-2.041677027e-017
	,2.438487474e-017
	,1.545587556e-017
	,-4.073046628e-018
	,3.910989093e-017
	,1.597803925e-017
	,2.981537716e-017
	,2.349566812e-018
	,1.331500440e-017
	,1.075640229e-017
	,-5.223335147e-019
	,1.216624427e-017
	,3.498326932e-018
	,2.193070536e-017
	,2.689126046e-017
	,9.555425786e-018
	,3.284392657e-017
	,4.960385269e-018
	,2.762228962e-017
	,4.229508944e-017
	,8.511098388e-018
	,-1.671093662e-018
	,4.266060402e-017
	,2.349719642e-017
	,3.837886172e-017
	,7.362338251e-018
	,-6.527216032e-018
	,4.824775555e-017
	,1.978983418e-017
	,2.166962348e-017
	,3.038975718e-017
	,9.294343912e-018
	,1.122634958e-017
	,4.344384955e-017
	,2.109524341e-017
	,1.524701003e-017
	,-5.482888659e-018
	,1.284505703e-017
	,2.213957079e-017
	,2.621244761e-017
	,2.558432234e-018
	,1.749231390e-017
	,2.475038926e-017
	,6.965646701e-017
	,4.521920609e-017
	,3.999756914e-017
	,5.153738680e-017
	,-6.944947023e-018
	,7.310121844e-018
	,3.952762181e-017
	,3.185181550e-017
	,3.258284467e-017
	,3.273949377e-017
	,8.772180181e-018
	,1.848442490e-017
	,3.284392651e-017
	,2.370606185e-017
	,2.918878064e-017
	,4.229356028e-018
	,2.824888599e-017
	,2.903213153e-017
	,5.508809990e-017
	,4.887435193e-017
	,4.119854561e-017
	,5.331274333e-017
	,2.417600916e-017
	,6.187622792e-017
	,2.454152374e-017
	,4.229508936e-017
	,6.156292970e-017
	,8.041303908e-017
	,6.532250830e-017
	,4.819553911e-017
	,5.054527573e-017
	,5.769891835e-017
	,8.526916144e-017
	,1.382165601e-016
	,1.468844774e-016
	,1.219772692e-016
	,1.638547975e-016
	,2.662510980e-016
	,3.584652065e-016
	,4.073397284e-016
	,5.095271634e-016
	,6.341676374e-016
	,7.958817337e-016
	,9.594756193e-016
	,1.270319667e-015
	,1.520592726e-015
	,1.976232766e-015
	,2.440697372e-015
	,3.104471861e-015
	,3.938367282e-015
	,4.992824647e-015
	,6.375044163e-015
	,8.062781658e-015
	,1.034296608e-014
	,1.312813501e-014
	,1.671320651e-014
	,2.129843034e-014
	,2.718002999e-014
	,3.474471987e-014
	,4.438840450e-014
	,5.679898233e-014
	,7.268774475e-014
	,9.308210104e-014
	,1.193024988e-013
	,1.530003328e-013
	,1.963174142e-013
	,2.521154611e-013
	,3.238698907e-013
	,4.162771475e-013
	,5.353683790e-013
	,6.890296146e-013
	,8.874037273e-013
	,1.143470088e-012
	,1.474480567e-012
	,1.902480394e-012
	,2.456318330e-012
	,3.173308244e-012
	,4.102138925e-012
	,5.306196293e-012
	,6.868002682e-012
	,8.895153261e-012
	,1.152354677e-011
	,1.493545563e-011
	,1.937080522e-011
	,2.514086887e-011
	,3.265266002e-011
	,4.243924446e-011
	,5.519739637e-011
	,7.184353076e-011
	,9.358212903e-011
	,1.219970041e-010
	,1.591760812e-010
	,2.078761133e-010
	,2.717481862e-010
	,3.556424083e-010
	,-8.610838785e-012
	,-6.105052494e-012
	,-4.329941244e-012
	,-3.072021229e-012
	,-2.180261559e-012
	,-1.547877933e-012
	,-1.099233999e-012
	,-7.808655203e-013
	,-5.547984560e-013
	,-3.942701412e-013
	,-2.802547586e-013
	,-1.991116169e-013
	,-1.413961327e-013
	,-1.003327620e-013
	,-7.101875327e-014
	,-5.004792826e-014
	,-3.516913486e-014
	,-2.458983732e-014
	,-1.714252984e-014
	,-1.195989852e-014
	,-8.304961519e-015
	,-5.738318094e-015
	,-4.006405551e-015
	,-2.820467367e-015
	,-1.946052044e-015
	,-1.317575821e-015
	,-9.586927134e-016
	,-6.536446829e-016
	,-4.742814537e-016
	,-3.583611135e-016
	,-2.097011096e-016
	,-1.616620497e-016
	,-9.848024259e-017
	,-8.213651895e-017
	,-3.764817215e-017
	,-4.683825318e-017
	,-7.206028746e-018
	,-3.253096795e-017
	,1.362830267e-017
	,5.273683555e-018
	,1.697015032e-017
	,1.409824999e-017
	,1.148590361e-018
	,-7.101596019e-018
	,1.028645502e-017
	,-4.177479331e-018
	,2.730899146e-017
	,1.488149553e-017
	,6.892390993e-018
	,1.096373980e-018
	,-4.177479340e-018
	,6.786430203e-019
	,3.362717216e-017
	,7.362338310e-018
	,1.608247201e-017
	,-1.566660874e-018
	,-3.133151960e-018
	,3.926654006e-017
	,1.587360653e-017
	,9.242127601e-018
	,4.908168933e-018
	,1.712679939e-017
	,3.054640634e-017
	,-7.467110639e-018
	,-2.610988279e-018
	,2.438487474e-017
	,1.394160084e-017
	,3.226954653e-017
	,1.263619160e-017
	,1.341943714e-017
	,2.976316079e-017
	,3.723010162e-017
	,1.900658867e-017
	,3.237245088e-018
	,6.892390949e-018
	,2.365384555e-017
	,-2.767637408e-018
	,-1.263653124e-017
	,3.054640632e-017
	,1.916323777e-017
	,3.696901976e-017
	,1.127856597e-017
	,6.422443611e-018
	,6.786429661e-019
	,2.845775153e-017
	,3.117300274e-017
	,2.574250031e-017
	,3.441041764e-017
	,1.012980583e-017
	,1.368051896e-017
	,2.031199788e-017
	,2.830110241e-017
	,1.206181150e-017
	,2.271395087e-017
	,1.101748410e-017
	,2.443709106e-017
	,1.618690468e-017
	,-5.169590439e-018
	,3.185028676e-018
	,3.268727743e-017
	,1.352386983e-017
	,2.506215867e-018
	,-3.498666624e-018
	,5.524474904e-017
	,1.169629689e-017
	,1.368051893e-017
	,2.835331875e-017
	,1.467262995e-017
	,3.796113073e-017
	,3.702123608e-017
	,-1.336756047e-017
	,7.257905473e-018
	,5.952496235e-018
	,6.265794450e-018
	,2.480260561e-017
	,3.226954645e-017
	,2.062529605e-017
	,2.386271096e-017
	,2.088637790e-017
	,5.315609423e-017
	,4.704677900e-017
	,3.947540543e-017
	,5.858659665e-017
	,5.059749212e-017
	,1.415046622e-017
	,5.796000022e-017
	,3.383603751e-017
	,8.834992725e-017
	,5.085857396e-017
	,5.017976116e-017
	,7.973422628e-017
	,3.080748808e-017
	,7.518987287e-018
	,5.905654396e-017
	,6.093633326e-017
	,7.221506907e-017
	,2.595136571e-017
	,2.809223685e-017
	,5.910876032e-017
	,4.417487865e-017
	,5.759448561e-017
	,7.493032027e-017
	,5.910876032e-017
	,7.038749612e-017
	,7.628794587e-017
	,4.302611851e-017
	,7.440815657e-017
	,1.090276095e-016
	,1.482943194e-016
	,1.452135536e-016
	,2.203006929e-016
	,1.881876257e-016
	,2.823337398e-016
	,3.254644610e-016
	,4.457187599e-016
	,5.465485694e-016
	,6.660718391e-016
	,8.124343228e-016
	,1.007723545e-015
	,1.251626206e-015
	,1.552392495e-015
	,2.010800002e-015
	,2.491138385e-015
	,3.217102570e-015
	,4.014028801e-015
	,5.107961742e-015
	,6.481774423e-015
	,8.232745940e-015
	,1.044447470e-014
	,1.326656061e-014
	,1.686045667e-014
	,2.155747575e-014
	,2.744957089e-014
	,3.505645159e-014
	,4.473543449e-014
	,5.718992629e-014
	,7.311534460e-014
	,9.356557241e-014
	,1.198108251e-013
	,1.535086069e-013
	,1.968211455e-013
	,2.524716290e-013
	,3.240528568e-013
	,4.162622136e-013
	,5.350012979e-013
	,6.879966181e-013
	,8.852947604e-013
	,1.139753692e-012
	,1.468049652e-012
	,1.892093410e-012
	,2.440108019e-012
	,3.148808585e-012
	,4.065902122e-012
	,5.253520733e-012
	,6.792398496e-012
	,8.787644821e-012
	,1.137645906e-011
	,1.473775276e-011
	,1.910508933e-011
	,2.478354844e-011
	,3.217266590e-011
	,-8.728634686e-012
	,-6.191533454e-012
	,-4.393413322e-012
	,-3.118576195e-012
	,-2.214480461e-012
	,-1.572965862e-012
	,-1.117665646e-012
	,-7.943894556e-013
	,-5.647466143e-013
	,-4.014990798e-013
	,-2.854774398e-013
	,-2.028916643e-013
	,-1.441365000e-013
	,-1.021871742e-013
	,-7.223685674e-014
	,-5.087571437e-014
	,-3.562790788e-014
	,-2.487989925e-014
	,-1.736157751e-014
	,-1.203728318e-014
	,-8.352791714e-015
	,-5.845883815e-015
	,-4.075174510e-015
	,-2.835975629e-015
	,-1.986258648e-015
	,-1.329585586e-015
	,-9.748275716e-016
	,-7.157821626e-016
	,-4.890586863e-016
	,-3.237416605e-016
	,-2.141395010e-016
	,-1.310110408e-016
	,-8.370301003e-017
	,-6.788145008e-017
	,-2.020790474e-017
	,-2.950241851e-017
	,-2.193257276e-018
	,6.161361839e-018
	,2.819514191e-018
	,8.615531201e-018
	,-1.597837883e-017
	,1.180072974e-017
	,2.370606198e-017
	,-3.289801047e-018
	,-2.090352491e-019
	,1.707458305e-017
	,1.200959521e-017
	,2.015534884e-017
	,5.221467170e-018
	,2.438487477e-017
	,1.044310411e-017
	,1.237510978e-017
	,2.923946906e-018
	,6.579092768e-018
	,2.396714380e-017
	,-1.237544936e-017
	,1.164408060e-017
	,2.052086341e-017
	,8.406665691e-018
	,1.911102143e-017
	,1.535144283e-017
	,2.673461137e-017
	,-2.574283996e-017
	,2.240065270e-017
	,1.592582289e-017
	,1.535144282e-017
	,2.610801493e-017
	,6.213578158e-018
	,7.308593608e-019
	,1.874550683e-017
	,-2.193257333e-018
	,2.422822562e-017
	,2.610648655e-018
	,8.302232927e-018
	,4.093746385e-017
	,1.937210325e-017
	,1.180072968e-017
	,1.895437229e-017
	,2.610648645e-018
	,3.863994358e-017
	,2.302724911e-017
	,3.597690874e-017
	,4.266060403e-017
	,2.198292171e-017
	,8.352920726e-019
	,1.968540145e-017
	,2.997202624e-017
	,2.213957082e-017
	,1.007758946e-017
	,2.396714374e-017
	,-7.311990220e-019
	,2.642131311e-017
	,2.950207890e-017
	,1.247954245e-017
	,3.117300272e-017
	,4.135519477e-017
	,2.208735443e-017
	,2.010313239e-017
	,2.892769883e-017
	,9.189911164e-018
	,-1.336756045e-017
	,3.561139412e-017
	,-7.937058031e-018
	,3.002424258e-017
	,-3.446450259e-018
	,5.164181954e-017
	,1.707458294e-017
	,3.884880901e-017
	,4.302611857e-017
	,3.858772716e-017
	,3.524587952e-017
	,5.038862666e-017
	,5.054527577e-017
	,4.015421824e-017
	,5.148517042e-017
	,3.341677755e-018
	,3.989313639e-017
	,2.135632522e-017
	,7.278944916e-017
	,3.540252861e-017
	,4.135519473e-017
	,7.049192890e-017
	,3.425376848e-017
	,4.803889002e-017
	,1.587360642e-017
	,3.853551077e-017
	,2.777893865e-017
	,4.459260962e-017
	,4.584580249e-017
	,3.655128872e-017
	,2.464595648e-017
	,5.054527574e-017
	,4.657683166e-017
	,3.879659260e-017
	,1.263619149e-017
	,5.064817915e-018
	,1.665685194e-017
	,5.064970847e-017
	,2.840553507e-017
	,5.613242726e-017
	,7.785443696e-017
	,6.030973682e-017
	,9.425037698e-017
	,3.905767443e-017
	,-5.169590517e-018
	,7.435594020e-017
	,3.362717200e-017
	,1.472484625e-017
	,7.127517440e-017
	,6.850770681e-017
	,2.965872792e-017
	,7.331161280e-017
	,9.900206658e-017
	,7.466923840e-017
	,1.021872651e-016
	,1.415061913e-016
	,1.309062683e-016
	,1.036493235e-016
	,1.781620827e-016
	,2.207706402e-016
	,2.734569570e-016
	,3.302161506e-016
	,3.947033669e-016
	,4.232657210e-016
	,5.478017622e-016
	,6.741653764e-016
	,8.250184678e-016
	,1.076074772e-015
	,1.306192313e-015
	,1.644136656e-015
	,2.067820278e-015
	,2.587582020e-015
	,3.292972955e-015
	,4.135327427e-015
	,5.241844513e-015
	,6.631896485e-015
	,8.400203837e-015
	,1.065412343e-014
	,1.355735357e-014
	,1.724544796e-014
	,2.193865525e-014
	,2.793168462e-014
	,3.562628883e-014
	,4.546975329e-014
	,5.800439722e-014
	,7.404213294e-014
	,9.472874425e-014
	,1.211525247e-013
	,1.550210541e-013
	,1.985459044e-013
	,2.544725603e-013
	,3.263697493e-013
	,4.187357031e-013
	,5.376641239e-013
	,6.905920850e-013
	,8.877043892e-013
	,1.141718960e-012
	,1.469303941e-012
	,1.892020307e-012
	,2.437922294e-012
	,3.143307172e-012
	,-3.059675333e-008
	,-2.838327485e-008
	,-2.631317333e-008
	,-2.441419516e-008
	,-2.266953656e-008
	,-2.103232187e-008
	,-1.953046274e-008
	,-1.804025761e-008
	,-1.668244519e-008
	,-1.544615271e-008
	,-1.431213208e-008
	,-1.326656719e-008
	,-1.228366839e-008
	,-1.131869783e-008
	,-1.042321437e-008
	,-9.604815390e-009
	,-8.828058089e-009
	,-8.109563192e-009
	,-7.456530420e-009
	,-6.861825229e-009
	,-6.319298241e-009
	,-5.823289842e-009
	,-5.369077441e-009
	,-4.952258876e-009
	,-4.568998995e-009
	,-4.216082234e-009
	,-3.890367689e-009
	,-3.589184342e-009
	,-3.309591478e-009
	,-3.048635023e-009
	,-2.803253127e-009
	,-2.570155032e-009
	,-2.345646797e-009
	,-2.125399784e-009
	,-1.904143978e-009
	,-1.675255304e-009
	,-1.430190528e-009
	,-1.151545493e-009
	,-8.328172576e-010
	,-4.576737327e-010
	,-1.415080587e-017
	,5.750661139e-010
	,1.314101925e-009
	,2.280110377e-009
	,3.559782774e-009
	,5.270815280e-009
	,7.550024914e-009
	,1.046175480e-008
	,1.432641839e-008
	,1.946728442e-008
	,2.631467038e-008
	,3.544073573e-008
	,4.760478438e-008
	,6.381226997e-008
	,8.539088173e-008
	,1.140877830e-007
	,1.521925112e-007
	,2.026899176e-007
	,2.694472628e-007
	,3.573390153e-007
	,4.726791649e-007
	,6.234713543e-007
	,8.196146524e-007
	,1.073240431e-006
	,1.398960950e-006
	,1.814026014e-006
	,2.338339374e-006
	,2.994279729e-006
	,3.806287610e-006
	,4.800214612e-006
	,6.002471158e-006
	,7.439023923e-006
	,9.134425183e-006
	,1.111091688e-005
	,1.338770177e-005
	,1.598052198e-005
	,1.890150225e-005
	,2.215924098e-005
	,2.575905427e-005
	,2.970340218e-005
	,3.399247123e-005
	,3.862450087e-005
	,4.359620193e-005
	,4.890306166e-005
	,5.453974974e-005
	,6.050087562e-005
	,6.678064336e-005
	,7.337305620e-005
	,8.027210698e-005
	,8.747185588e-005
	,9.496646582e-005
	,1.027502498e-004
	,1.108177014e-004
	,1.191634577e-004
	,1.277818569e-004
	,1.366551588e-004
	,1.457875980e-004
	,1.551726864e-004
	,1.648057938e-004
	,1.746815732e-004
	,1.847946045e-004
	,1.951394587e-004
	,2.055074085e-004
	,2.159348925e-004
	,2.265676739e-004
	,2.373995363e-004
	,2.484138901e-004
	,2.596066038e-004
	,2.709802866e-004
	,2.825300274e-004
	,2.942511529e-004
	,3.061391899e-004
	,3.181897613e-004
	,3.303986844e-004
	,3.427618196e-004
	,3.552761354e-004
	,3.679375324e-004
	,3.807431236e-004
	,3.936899294e-004
	,4.067744011e-004
	,4.199941857e-004
	,4.333467562e-004
	,4.468296550e-004
	,4.604405881e-004
	,4.741475810e-004
	,4.879620770e-004
	,5.018955585e-004
	,5.159462098e-004
	,5.301123644e-004
	,5.440286508e-004
	,5.577007872e-004
	,5.714830241e-004
	,5.853746146e-004
	,5.993749086e-004
	,6.134833620e-004
	,6.276995324e-004
	,6.419826475e-004
	,6.563587403e-004
	,6.708370899e-004
	,6.854175738e-004
	,7.001001075e-004
	,7.148846697e-004
	,7.297713104e-004
	,7.447601445e-004
	,7.598436961e-004
	,7.750267169e-004
	,7.903135297e-004
	,8.057045701e-004
	,8.212002925e-004
	,8.368011580e-004
	,8.525076231e-004
	,8.683201274e-004
	,8.842390838e-004
	,9.002648679e-004
	,9.163978104e-004
	,9.326381892e-004
	,9.489862250e-004
	,9.654420766e-004
	,9.820058398e-004
	,9.986775464e-004
	,1.015457166e-003
	,1.032344607e-003
	,1.049339721e-003
	,1.066442309e-003
	,1.083652122e-003
	,1.100968720e-003
	,1.118389638e-003
	,1.135873470e-003
	,1.153398859e-003
	,1.171027009e-003
	,1.188757365e-003
	,1.206589354e-003
	,1.224522818e-003
	,1.242557051e-003
	,1.260691077e-003
	,1.278683570e-003
	,1.295841614e-003
	,1.313261089e-003
	,1.330865322e-003
	,1.348620324e-003
	,1.366507639e-003
	,1.384515989e-003
	,1.402637902e-003
	,1.420868150e-003
	,1.439202903e-003
	,1.457639234e-003
	,1.476173486e-003
	,1.494782191e-003
	,1.513486025e-003
	,1.532283655e-003
	,1.551112396e-003
	,1.570012967e-003
	,1.589003157e-003
	,1.608082088e-003
	,1.627248938e-003
	,1.646502929e-003
	,1.665843315e-003
	,1.685269356e-003
	,1.704780362e-003
	,1.724375623e-003
	,1.744054077e-003
	,-2.961269018e-009
	,-2.692299189e-009
	,-2.454182922e-009
	,-2.242172940e-009
	,-2.052503561e-009
	,-1.882127812e-009
	,-1.728532536e-009
	,-1.589585893e-009
	,-1.463456345e-009
	,-1.341634764e-009
	,-1.226088980e-009
	,-1.122147737e-009
	,-1.028445523e-009
	,-9.438040672e-010
	,-8.667015509e-010
	,-7.913343439e-010
	,-7.230105357e-010
	,-6.610169489e-010
	,-6.047172656e-010
	,-5.535423090e-010
	,-5.069821488e-010
	,-4.645865782e-010
	,-4.240545551e-010
	,-3.870060457e-010
	,-3.535438150e-010
	,-3.232262155e-010
	,-2.956660537e-010
	,-2.705167322e-010
	,-2.474639277e-010
	,-2.262122156e-010
	,-2.064750672e-010
	,-1.879623103e-010
	,-1.703660644e-010
	,-1.533436739e-010
	,-1.364960145e-010
	,-1.193385077e-010
	,-1.012647625e-010
	,-8.149477277e-011
	,-5.900730023e-011
	,-3.244722030e-011
	,1.911102148e-017
	,4.077964527e-011
	,9.320158762e-011
	,1.609277545e-010
	,2.489020695e-010
	,3.654266247e-010
	,5.210772779e-010
	,7.302332569e-010
	,1.012466349e-009
	,1.394435160e-009
	,1.912467125e-009
	,2.616075192e-009
	,3.572744915e-009
	,4.794716989e-009
	,6.406197305e-009
	,8.553795801e-009
	,1.141603060e-008
	,1.523041841e-008
	,2.031269190e-008
	,2.708209048e-008
	,3.609451937e-008
	,4.808582989e-008
	,6.402797151e-008
	,8.520148638e-008
	,1.132879862e-007
	,1.504871994e-007
	,1.996630228e-007
	,2.644285027e-007
	,3.495145103e-007
	,4.610189498e-007
	,6.065597788e-007
	,7.956317361e-007
	,1.039905984e-006
	,1.353500384e-006
	,1.753179156e-006
	,2.258434477e-006
	,2.891395865e-006
	,3.676528118e-006
	,4.640096453e-006
	,5.809414086e-006
	,7.211927864e-006
	,8.874234906e-006
	,1.082114075e-005
	,1.307486026e-005
	,1.565446052e-005
	,1.857556859e-005
	,2.185031870e-005
	,2.548753112e-005
	,2.949303833e-005
	,3.387011268e-005
	,3.861991500e-005
	,4.374193527e-005
	,4.923440076e-005
	,5.509463491e-005
	,6.131933837e-005
	,6.790482471e-005
	,7.484719866e-005
	,8.214188740e-005
	,8.978306170e-005
	,9.776815132e-005
	,1.060931523e-004
	,1.147541412e-004
	,1.237322309e-004
	,1.330040766e-004
	,1.425886524e-004
	,1.524807362e-004
	,1.626750144e-004
	,1.731660599e-004
	,1.837244360e-004
	,1.943451969e-004
	,2.052276041e-004
	,2.163563579e-004
	,2.276948587e-004
	,2.392447030e-004
	,2.510191699e-004
	,2.630117500e-004
	,2.752161104e-004
	,2.876266534e-004
	,3.002378725e-004
	,3.130444484e-004
	,3.260414449e-004
	,3.392243719e-004
	,3.525889136e-004
	,3.661306662e-004
	,3.798456883e-004
	,3.937310218e-004
	,4.077832754e-004
	,4.219991883e-004
	,4.363574744e-004
	,4.508327312e-004
	,4.652836162e-004
	,4.798625652e-004
	,4.941765933e-004
	,5.079922060e-004
	,5.219265908e-004
	,5.359783279e-004
	,5.501460545e-004
	,5.644285563e-004
	,5.788247455e-004
	,5.933336567e-004
	,6.079228620e-004
	,6.226133770e-004
	,6.374103255e-004
	,6.523130738e-004
	,6.673210945e-004
	,6.824339611e-004
	,6.976513421e-004
	,7.129729952e-004
	,7.283917685e-004
	,7.439127465e-004
	,7.595383739e-004
	,7.752688232e-004
	,7.911043129e-004
	,8.070450961e-004
	,8.230914478e-004
	,8.392436521e-004
	,8.555019911e-004
	,8.718667327e-004
	,8.883381214e-004
	,9.049163685e-004
	,9.216016452e-004
	,9.383940769e-004
	,9.552937383e-004
	,9.723006518e-004
	,9.894147860e-004
	,1.006636056e-003
	,1.023964327e-003
	,1.041399414e-003
	,1.058941089e-003
	,1.076589084e-003
	,1.094343096e-003
	,1.112195188e-003
	,1.130063629e-003
	,1.148034606e-003
	,1.166107086e-003
	,1.184280531e-003
	,1.202554362e-003
	,1.220927982e-003
	,1.239400776e-003
	,1.257772133e-003
	,1.275382363e-003
	,1.293234541e-003
	,1.311258844e-003
	,1.329424684e-003
	,1.347715570e-003
	,1.366121476e-003
	,1.384635791e-003
	,1.403253894e-003
	,1.421972400e-003
	,1.440788712e-003
	,1.459700816e-003
	,1.478707065e-003
	,1.497806083e-003
	,1.516996695e-003
	,1.536264249e-003
	,1.555608121e-003
	,1.575039933e-003
	,1.594559002e-003
	,1.614164591e-003
	,1.633855994e-003
	,1.653632529e-003
	,-2.946136455e-010
	,-2.588163759e-010
	,-2.276547158e-010
	,-2.016112852e-010
	,-1.795848756e-010
	,-1.607479864e-010
	,-1.439827521e-010
	,-1.295674268e-010
	,-1.170458378e-010
	,-1.060752225e-010
	,-9.639769342e-011
	,-8.763667587e-011
	,-7.922526377e-011
	,-7.178325391e-011
	,-6.517470538e-011
	,-5.928722158e-011
	,-5.402670824e-011
	,-4.906490381e-011
	,-4.454076248e-011
	,-4.047040619e-011
	,-3.680281565e-011
	,-3.349356194e-011
	,-3.050340115e-011
	,-2.779771122e-011
	,-2.534560424e-011
	,-2.311930137e-011
	,-2.109381164e-011
	,-1.924602361e-011
	,-1.744354174e-011
	,-1.578511549e-011
	,-1.427461429e-011
	,-1.288362775e-011
	,-1.158485427e-011
	,-1.035026699e-011
	,-9.149338684e-012
	,-7.947329555e-012
	,-6.702450421e-012
	,-5.362784479e-012
	,-3.861759093e-012
	,-2.112481996e-012
	,-1.984239015e-017
	,2.629485669e-012
	,5.982714918e-012
	,1.033911185e-011
	,1.607718785e-011
	,2.371082475e-011
	,3.393885013e-011
	,4.771248668e-011
	,6.632765948e-011
	,9.122436419e-011
	,1.238832297e-010
	,1.679476482e-010
	,2.275138293e-010
	,3.081571747e-010
	,4.174696952e-010
	,5.657940609e-010
	,7.672236243e-010
	,1.040966874e-009
	,1.413206921e-009
	,1.901388583e-009
	,2.531879342e-009
	,3.371748381e-009
	,4.490593654e-009
	,5.981098188e-009
	,7.966639459e-009
	,1.061137100e-008
	,1.413355701e-008
	,1.882317300e-008
	,2.506507358e-008
	,3.336938714e-008
	,4.441123143e-008
	,5.908234429e-008
	,7.855778734e-008
	,1.043814592e-007
	,1.385746999e-007
	,1.836925786e-007
	,2.431104459e-007
	,3.212553199e-007
	,4.237083601e-007
	,5.575310035e-007
	,7.315591949e-007
	,9.567066840e-007
	,1.246251596e-006
	,1.616069785e-006
	,2.084769201e-006
	,2.673675036e-006
	,3.406619874e-006
	,4.309509887e-006
	,5.409668007e-006
	,6.734993436e-006
	,8.313015295e-006
	,1.016994520e-005
	,1.232983647e-005
	,1.481394102e-005
	,1.764031745e-005
	,2.082369830e-005
	,2.437334141e-005
	,2.829532971e-005
	,3.259704701e-005
	,3.728124335e-005
	,4.234913813e-005
	,4.780032727e-005
	,5.363336488e-005
	,5.984603730e-005
	,6.643561427e-005
	,7.339903860e-005
	,8.073306527e-005
	,8.843435731e-005
	,9.649952273e-005
	,1.049251897e-004
	,1.137080045e-004
	,1.228445970e-004
	,1.323314655e-004
	,1.421652112e-004
	,1.523422807e-004
	,1.627658338e-004
	,1.731345568e-004
	,1.838104440e-004
	,1.947856182e-004
	,2.060526876e-004
	,2.176045843e-004
	,2.294345024e-004
	,2.415358709e-004
	,2.539023393e-004
	,2.665277724e-004
	,2.794062503e-004
	,2.925320733e-004
	,3.058997463e-004
	,3.195038282e-004
	,3.333394859e-004
	,3.474020064e-004
	,3.616868953e-004
	,3.761889198e-004
	,3.908911831e-004
	,4.058023737e-004
	,4.209182833e-004
	,4.362362513e-004
	,4.513140014e-004
	,4.656076308e-004
	,4.800674853e-004
	,4.946928918e-004
	,5.094354308e-004
	,5.242618899e-004
	,5.392445817e-004
	,5.543827859e-004
	,5.696596275e-004
	,5.847860267e-004
	,6.000130080e-004
	,6.153660436e-004
	,6.308445590e-004
	,6.464480507e-004
	,6.621761545e-004
	,6.780285465e-004
	,6.939995109e-004
	,7.100950943e-004
	,7.263155461e-004
	,7.426612323e-004
	,7.591326277e-004
	,7.757303079e-004
	,7.924549411e-004
	,8.093072808e-004
	,8.262881595e-004
	,8.433984831e-004
	,8.606392274e-004
	,8.779969265e-004
	,8.952093685e-004
	,9.125301883e-004
	,9.299591650e-004
	,9.474961748e-004
	,9.651410305e-004
	,9.828935114e-004
	,1.000753362e-003
	,1.018720293e-003
	,1.036794122e-003
	,1.054974662e-003
	,1.073261267e-003
	,1.091653534e-003
	,1.110075096e-003
	,1.128594587e-003
	,1.147215126e-003
	,1.165936129e-003
	,1.184756979e-003
	,1.203677038e-003
	,1.222695657e-003
	,1.241348336e-003
	,1.259710613e-003
	,1.278261964e-003
	,1.296958142e-003
	,1.315778274e-003
	,1.334710693e-003
	,1.353748126e-003
	,1.372885682e-003
	,1.392119888e-003
	,1.411448158e-003
	,1.430868495e-003
	,1.450379302e-003
	,1.469979256e-003
	,1.489667233e-003
	,1.509442275e-003
	,1.529303520e-003
	,1.549250182e-003
	,-5.708038894e-011
	,-4.514010014e-011
	,-3.636059501e-011
	,-2.959434950e-011
	,-2.440967752e-011
	,-2.043473385e-011
	,-1.734760789e-011
	,-1.476263360e-011
	,-1.265485838e-011
	,-1.096215313e-011
	,-9.582527409e-012
	,-8.441028697e-012
	,-7.481806993e-012
	,-6.659007499e-012
	,-5.891078323e-012
	,-5.226657134e-012
	,-4.658662088e-012
	,-4.168945279e-012
	,-3.743638198e-012
	,-3.362090262e-012
	,-3.016309861e-012
	,-2.710832351e-012
	,-2.440012203e-012
	,-2.199098771e-012
	,-1.984188987e-012
	,-1.791937087e-012
	,-1.619385170e-012
	,-1.464027843e-012
	,-1.323495108e-012
	,-1.195862479e-012
	,-1.079083075e-012
	,-9.713784586e-013
	,-8.708678478e-013
	,-7.755332368e-013
	,-6.772396286e-013
	,-5.804288609e-013
	,-4.835372622e-013
	,-3.825366008e-013
	,-2.725714853e-013
	,-1.476327514e-013
	,-1.916357735e-017
	,1.805739700e-013
	,4.074416678e-013
	,6.987547045e-013
	,1.078677354e-012
	,1.579955806e-012
	,2.246775554e-012
	,3.138946897e-012
	,4.337697359e-012
	,5.953232459e-012
	,8.135157475e-012
	,1.108703709e-011
	,1.508558443e-011
	,2.050742807e-011
	,2.786533246e-011
	,3.782097951e-011
	,5.066321033e-011
	,6.797319518e-011
	,9.133632580e-011
	,1.229077355e-010
	,1.656179792e-010
	,2.234540821e-010
	,3.018431958e-010
	,4.081746956e-010
	,5.525130525e-010
	,7.467115954e-010
	,9.923023202e-010
	,1.319018453e-009
	,1.753733733e-009
	,2.332231997e-009
	,3.102155983e-009
	,4.126926946e-009
	,5.490948687e-009
	,7.306512121e-009
	,9.722942698e-009
	,1.293870111e-008
	,1.721735958e-008
	,2.290864479e-008
	,3.047607116e-008
	,4.053309767e-008
	,5.389022353e-008
	,7.161599635e-008
	,9.511551453e-008
	,1.261640987e-007
	,1.671217099e-007
	,2.211380611e-007
	,2.922060463e-007
	,3.854385308e-007
	,5.073254231e-007
	,6.660194608e-007
	,8.716378448e-007
	,1.136557666e-006
	,1.475672392e-006
	,1.906568316e-006
	,2.449569568e-006
	,3.127605836e-006
	,3.965864886e-006
	,4.991220356e-006
	,6.231458070e-006
	,7.714364731e-006
	,9.466774688e-006
	,1.151368179e-005
	,1.387751507e-005
	,1.657764592e-005
	,1.963015160e-005
	,2.304782021e-005
	,2.684035215e-005
	,3.101469807e-005
	,3.557548492e-005
	,4.052544940e-005
	,4.586586338e-005
	,5.159693630e-005
	,5.771814749e-005
	,6.422852513e-005
	,7.112687442e-005
	,7.841195384e-005
	,8.608264185e-005
	,9.413800110e-005
	,1.025772364e-004
	,1.113999420e-004
	,1.206050609e-004
	,1.301929903e-004
	,1.401647791e-004
	,1.502796387e-004
	,1.605039663e-004
	,1.710328680e-004
	,1.818302766e-004
	,1.929422313e-004
	,2.043616546e-004
	,2.160816430e-004
	,2.280954279e-004
	,2.403963611e-004
	,2.529779096e-004
	,2.658336584e-004
	,2.789573178e-004
	,2.923427338e-004
	,3.059838776e-004
	,3.198734118e-004
	,3.339994767e-004
	,3.483631040e-004
	,3.629588533e-004
	,3.777806162e-004
	,3.928243418e-004
	,4.080852995e-004
	,4.229426297e-004
	,4.370854408e-004
	,4.513992541e-004
	,4.658820954e-004
	,4.805319751e-004
	,4.953471144e-004
	,5.103160501e-004
	,5.254449827e-004
	,5.407333986e-004
	,5.561800782e-004
	,5.717839514e-004
	,5.875440946e-004
	,6.034597274e-004
	,6.195298704e-004
	,6.357524795e-004
	,6.521292155e-004
	,6.686598834e-004
	,6.853444240e-004
	,7.021829017e-004
	,7.191754994e-004
	,7.363225128e-004
	,7.536243450e-004
	,7.710815013e-004
	,7.886841099e-004
	,8.062685410e-004
	,8.240022517e-004
	,8.418859444e-004
	,8.599204538e-004
	,8.781067776e-004
	,8.964457025e-004
	,9.149382205e-004
	,9.335853909e-004
	,9.523883488e-004
	,9.713483031e-004
	,9.904665516e-004
	,1.009744492e-003
	,1.029183632e-003
	,1.048785610e-003
	,1.068138777e-003
	,1.087344894e-003
	,1.106666407e-003
	,1.126107958e-003
	,1.145671596e-003
	,1.165357419e-003
	,1.185165578e-003
	,1.205096273e-003
	,1.224558274e-003
	,1.244163460e-003
	,1.263943027e-003
	,1.283875593e-003
	,1.303951256e-003
	,1.324149856e-003
	,1.344036969e-003
	,1.364018363e-003
	,1.384090955e-003
	,1.404252936e-003
	,1.424502693e-003
	,-3.830856636e-011
	,-2.705450509e-011
	,-1.922085913e-011
	,-1.375882084e-011
	,-9.941132098e-012
	,-7.261650978e-012
	,-5.347579281e-012
	,-3.989696717e-012
	,-3.020659380e-012
	,-2.324161884e-012
	,-1.818307189e-012
	,-1.447415414e-012
	,-1.172776004e-012
	,-9.523706035e-013
	,-7.845711071e-013
	,-6.561769028e-013
	,-5.546660875e-013
	,-4.710484121e-013
	,-4.041371030e-013
	,-3.498858094e-013
	,-3.049002583e-013
	,-2.664103192e-013
	,-2.328415118e-013
	,-2.045935003e-013
	,-1.805536581e-013
	,-1.598994732e-013
	,-1.420353133e-013
	,-1.264286237e-013
	,-1.126489849e-013
	,-1.004378736e-013
	,-8.948225265e-014
	,-7.955372773e-014
	,-7.054750054e-014
	,-6.214045618e-014
	,-5.415589448e-014
	,-4.642400778e-014
	,-3.863995694e-014
	,-3.057216234e-014
	,-2.170733707e-014
	,-1.172429826e-014
	,-3.134679696e-019
	,1.392339032e-014
	,3.091846096e-014
	,5.231406614e-014
	,7.974828558e-014
	,1.154562410e-013
	,1.624141610e-013
	,2.245790543e-013
	,3.073491013e-013
	,4.180032640e-013
	,5.663369156e-013
	,7.655967224e-013
	,1.033711227e-012
	,1.394931435e-012
	,1.882185510e-012
	,2.539968954e-012
	,3.428869673e-012
	,4.630892117e-012
	,6.257511290e-012
	,8.460100099e-012
	,1.144463609e-011
	,1.549111665e-011
	,2.068566024e-011
	,2.760424294e-011
	,3.691053374e-011
	,4.944578938e-011
	,6.635213815e-011
	,8.918046322e-011
	,1.200387058e-010
	,1.617929183e-010
	,2.183417628e-010
	,2.949904858e-010
	,3.928707878e-010
	,5.211065458e-010
	,6.914438652e-010
	,9.177631098e-010
	,1.218531986e-009
	,1.618322604e-009
	,2.149828474e-009
	,2.856545673e-009
	,3.796334809e-009
	,5.046149262e-009
	,6.708306491e-009
	,8.918796483e-009
	,1.185827360e-008
	,1.576657281e-008
	,2.096184194e-008
	,2.786568891e-008
	,3.703613364e-008
	,4.921061723e-008
	,6.536188169e-008
	,8.671481020e-008
	,1.149035701e-007
	,1.521502396e-007
	,2.012764145e-007
	,2.659284699e-007
	,3.507866749e-007
	,4.618095372e-007
	,6.065095850e-007
	,7.942505736e-007
	,1.036547719e-006
	,1.347342500e-006
	,1.743213242e-006
	,2.243474617e-006
	,2.870117056e-006
	,3.647544609e-006
	,4.602089952e-006
	,5.761317032e-006
	,7.153159989e-006
	,8.804982294e-006
	,1.074266026e-005
	,1.298979314e-005
	,1.556711999e-005
	,1.849219053e-005
	,2.177926442e-005
	,2.543944295e-005
	,2.948095146e-005
	,3.390952808e-005
	,3.872884616e-005
	,4.394094008e-005
	,4.954659827e-005
	,5.554572861e-005
	,6.193764017e-005
	,6.872106578e-005
	,7.589460297e-005
	,8.345725017e-005
	,9.140782148e-005
	,9.974522789e-005
	,1.084686207e-004
	,1.175773085e-004
	,1.270707393e-004
	,1.367499694e-004
	,1.465076310e-004
	,1.566171298e-004
	,1.670727253e-004
	,1.778691692e-004
	,1.890016186e-004
	,2.004655838e-004
	,2.122569028e-004
	,2.243717354e-004
	,2.368065723e-004
	,2.495582587e-004
	,2.626215898e-004
	,2.759941807e-004
	,2.896761935e-004
	,3.036663725e-004
	,3.179638402e-004
	,3.324810581e-004
	,3.470555767e-004
	,3.618768560e-004
	,3.769384712e-004
	,3.920846864e-004
	,4.059982071e-004
	,4.200936858e-004
	,4.343694561e-004
	,4.488180871e-004
	,4.634393487e-004
	,4.782330205e-004
	,4.931970096e-004
	,5.083293663e-004
	,5.236282882e-004
	,5.390920980e-004
	,5.547185481e-004
	,5.705061300e-004
	,5.864544043e-004
	,6.025622361e-004
	,6.188286097e-004
	,6.352526234e-004
	,6.518334844e-004
	,6.685705025e-004
	,6.854630843e-004
	,7.025107265e-004
	,7.197130092e-004
	,7.370695895e-004
	,7.545801937e-004
	,7.722446116e-004
	,7.900626895e-004
	,8.080343241e-004
	,8.261594575e-004
	,8.444380722e-004
	,8.628701871e-004
	,8.814558564e-004
	,9.001951777e-004
	,9.190882499e-004
	,9.381352163e-004
	,9.573362503e-004
	,9.766915571e-004
	,9.962013754e-004
	,1.015865980e-003
	,1.035683760e-003
	,1.055630289e-003
	,1.075731536e-003
	,1.095974392e-003
	,1.116138960e-003
	,1.136449056e-003
	,1.156905641e-003
	,1.177324103e-003
	,1.197701610e-003
	,1.218269170e-003
	,1.239007622e-003
	,1.259908851e-003
	,-4.202519961e-011
	,-2.908068287e-011
	,-2.013363918e-011
	,-1.394987933e-011
	,-9.675625749e-012
	,-6.720335938e-012
	,-4.676529120e-012
	,-3.262204525e-012
	,-2.282137524e-012
	,-1.601381175e-012
	,-1.128594271e-012
	,-7.997058652e-013
	,-5.704314626e-013
	,-4.102567049e-013
	,-2.979479098e-013
	,-2.188430864e-013
	,-1.629098513e-013
	,-1.230260484e-013
	,-9.434051589e-014
	,-7.229988190e-014
	,-5.620898991e-014
	,-4.439686389e-014
	,-3.561323508e-014
	,-2.894248945e-014
	,-2.388585622e-014
	,-1.993688885e-014
	,-1.672568656e-014
	,-1.421199053e-014
	,-1.220045933e-014
	,-1.046348180e-014
	,-8.993277702e-015
	,-7.766924048e-015
	,-6.682494487e-015
	,-5.804946181e-015
	,-4.930844156e-015
	,-4.166657589e-015
	,-3.408580337e-015
	,-2.665071452e-015
	,-1.871278203e-015
	,-9.747753552e-016
	,-7.989274285e-018
	,1.193457171e-015
	,2.633950156e-015
	,4.418287934e-015
	,6.760557620e-015
	,9.792814412e-015
	,1.354221082e-014
	,1.835828323e-014
	,2.469129338e-014
	,3.298977990e-014
	,4.406408863e-014
	,5.874331106e-014
	,7.829411191e-014
	,1.043739432e-013
	,1.392363067e-013
	,1.859145036e-013
	,2.484797398e-013
	,3.324289891e-013
	,4.452008389e-013
	,5.967652739e-013
	,8.006508767e-013
	,1.075257338e-012
	,1.445358819e-012
	,1.944534310e-012
	,2.618355698e-012
	,3.528601633e-012
	,4.759106853e-012
	,6.423677772e-012
	,8.572559225e-012
	,1.137837733e-011
	,1.513743768e-011
	,2.018161553e-011
	,2.696063274e-011
	,3.608375614e-011
	,4.837734174e-011
	,6.496284728e-011
	,8.736414109e-011
	,1.176513474e-010
	,1.573374129e-010
	,2.081716273e-010
	,2.755562038e-010
	,3.649110209e-010
	,4.834382374e-010
	,6.407103432e-010
	,8.494513986e-010
	,1.126576784e-009
	,1.494574471e-009
	,1.983342078e-009
	,2.632626463e-009
	,3.495260802e-009
	,4.641469679e-009
	,6.164570099e-009
	,8.188522072e-009
	,1.087792485e-008
	,1.445122134e-008
	,1.919811316e-008
	,2.550247713e-008
	,3.387244403e-008
	,4.497975759e-008
	,5.966504201e-008
	,7.905068818e-008
	,1.046959841e-007
	,1.385765949e-007
	,1.832633071e-007
	,2.420838638e-007
	,3.193187555e-007
	,4.204323806e-007
	,5.523375421e-007
	,7.236858270e-007
	,9.451688266e-007
	,1.229805666e-006
	,1.593181929e-006
	,2.053595941e-006
	,2.632063731e-006
	,3.352137665e-006
	,4.239509104e-006
	,5.321392851e-006
	,6.625727525e-006
	,8.180262615e-006
	,1.001163019e-005
	,1.214450410e-005
	,1.460093662e-005
	,1.739992861e-005
	,2.055724674e-005
	,2.408543738e-005
	,2.799407528e-005
	,3.229015827e-005
	,3.697843499e-005
	,4.206185668e-005
	,4.754197190e-005
	,5.341931218e-005
	,5.969368808e-005
	,6.636445069e-005
	,7.343068657e-005
	,8.089138190e-005
	,8.874553069e-005
	,9.699219184e-005
	,1.056305377e-004
	,1.146598890e-004
	,1.239169373e-004
	,1.332301408e-004
	,1.429015903e-004
	,1.529249138e-004
	,1.632941744e-004
	,1.740037661e-004
	,1.850483461e-004
	,1.964214547e-004
	,2.081173902e-004
	,2.201329988e-004
	,2.324637037e-004
	,2.451051220e-004
	,2.580530790e-004
	,2.713036259e-004
	,2.848530626e-004
	,2.986979623e-004
	,3.128350052e-004
	,3.272614519e-004
	,3.419749647e-004
	,3.569735113e-004
	,3.721946185e-004
	,3.860349614e-004
	,4.000853849e-004
	,4.143477491e-004
	,4.288201468e-004
	,4.435033074e-004
	,4.583975568e-004
	,4.735035172e-004
	,4.888222108e-004
	,5.042115986e-004
	,5.196070585e-004
	,5.351745965e-004
	,5.509124123e-004
	,5.668191430e-004
	,5.828934438e-004
	,5.991340772e-004
	,6.155399068e-004
	,6.321098913e-004
	,6.488430783e-004
	,6.657385975e-004
	,6.827956555e-004
	,7.000135248e-004
	,7.173915406e-004
	,7.349290937e-004
	,7.526256231e-004
	,7.704806107e-004
	,7.884935749e-004
	,8.066640662e-004
	,8.249916617e-004
	,8.434759619e-004
	,8.621165872e-004
	,8.809131754e-004
	,8.998653795e-004
	,9.189728669e-004
	,9.382353187e-004
	,9.576524289e-004
	,9.772239059e-004
	,9.969494723e-004
	,1.016806123e-003
	,1.036815048e-003
	,1.056976145e-003
	,1.077289134e-003
	,-4.875457556e-011
	,-3.381503024e-011
	,-2.343501830e-011
	,-1.623150665e-011
	,-1.123669918e-011
	,-7.775980860e-012
	,-5.379821949e-012
	,-3.721615422e-012
	,-2.574621147e-012
	,-1.781429013e-012
	,-1.233005967e-012
	,-8.538183155e-013
	,-5.916242072e-013
	,-4.103418176e-013
	,-2.849749095e-013
	,-1.981498958e-013
	,-1.381002355e-013
	,-9.646880289e-014
	,-6.768651344e-014
	,-4.762482763e-014
	,-3.368159492e-014
	,-2.397739152e-014
	,-1.717991676e-014
	,-1.242404983e-014
	,-9.016357337e-015
	,-6.617328458e-015
	,-4.865260396e-015
	,-3.627105843e-015
	,-2.760888490e-015
	,-2.124214297e-015
	,-1.624085910e-015
	,-1.307498062e-015
	,-1.017958293e-015
	,-7.877363197e-016
	,-6.605372437e-016
	,-5.188742333e-016
	,-3.925628355e-016
	,-2.483934394e-016
	,-1.769092296e-016
	,-1.241706964e-016
	,-2.412413246e-017
	,1.024483472e-016
	,2.291774759e-016
	,4.094805997e-016
	,6.400158710e-016
	,8.708644404e-016
	,1.210740789e-015
	,1.642100218e-015
	,2.242118519e-015
	,3.007662712e-015
	,4.016952918e-015
	,5.341943293e-015
	,6.973078243e-015
	,9.072280729e-015
	,1.186784072e-014
	,1.553285548e-014
	,2.041962885e-014
	,2.686934259e-014
	,3.544744777e-014
	,4.691003741e-014
	,6.208750845e-014
	,8.240380127e-014
	,1.094499487e-013
	,1.456822608e-013
	,1.940890806e-013
	,2.590211804e-013
	,3.460739097e-013
	,4.629015615e-013
	,6.198744637e-013
	,8.309162677e-013
	,1.115013629e-012
	,1.497734866e-012
	,2.013742042e-012
	,2.710071088e-012
	,3.618474516e-012
	,4.774934523e-012
	,6.317399811e-012
	,8.378573428e-012
	,1.113711593e-011
	,1.483529628e-011
	,1.980112575e-011
	,2.647815939e-011
	,3.546846304e-011
	,4.758838221e-011
	,6.386585315e-011
	,8.425605793e-011
	,1.112194099e-010
	,1.468909054e-010
	,1.941027397e-010
	,2.566132087e-010
	,3.394111895e-010
	,4.491198455e-010
	,5.945339940e-010
	,7.873338189e-010
	,1.043033566e-009
	,1.382241962e-009
	,1.832336394e-009
	,2.429686621e-009
	,3.222601899e-009
	,4.275238344e-009
	,5.672826514e-009
	,7.528514090e-009
	,9.992479013e-009
	,1.326396292e-008
	,1.760715551e-008
	,2.337212918e-008
	,3.102238053e-008
	,4.113271342e-008
	,5.446859594e-008
	,7.212169559e-008
	,9.546669801e-008
	,1.263013752e-007
	,1.669674815e-007
	,2.205006847e-007
	,2.908132695e-007
	,3.829118910e-007
	,5.031497892e-007
	,6.595082379e-007
	,8.618956540e-007
	,1.122442849e-006
	,1.455764004e-006
	,1.879142596e-006
	,2.412594811e-006
	,3.078763502e-006
	,3.902606426e-006
	,4.910865608e-006
	,6.131337973e-006
	,7.592003531e-006
	,9.320101418e-006
	,1.134125300e-005
	,1.367872958e-005
	,1.635293395e-005
	,1.938112387e-005
	,2.277736948e-005
	,2.655270640e-005
	,3.071542754e-005
	,3.527147302e-005
	,4.022483302e-005
	,4.557795296e-005
	,5.133211685e-005
	,5.748777603e-005
	,6.404481759e-005
	,7.100278777e-005
	,7.836106155e-005
	,8.611896556e-005
	,9.427584696e-005
	,1.028311221e-004
	,1.116661260e-004
	,1.205273183e-004
	,1.297552083e-004
	,1.393416151e-004
	,1.492812410e-004
	,1.595683464e-004
	,1.701971951e-004
	,1.811622299e-004
	,1.924580418e-004
	,2.040793518e-004
	,2.160210053e-004
	,2.282779725e-004
	,2.408453559e-004
	,2.537184021e-004
	,2.668925162e-004
	,2.803632782e-004
	,2.941264619e-004
	,3.081779394e-004
	,3.225091459e-004
	,3.371199233e-004
	,3.520077054e-004
	,3.657536484e-004
	,3.794584958e-004
	,3.933694133e-004
	,4.074846230e-004
	,4.218022864e-004
	,4.363209621e-004
	,4.510401310e-004
	,4.659590082e-004
	,4.810770445e-004
	,4.963939333e-004
	,5.119096182e-004
	,5.276243028e-004
	,5.435384628e-004
	,5.596528607e-004
	,5.759685648e-004
	,5.924869733e-004
	,6.092098457e-004
	,6.261393430e-004
	,6.432780802e-004
	,6.606291957e-004
	,6.780764730e-004
	,6.953922152e-004
	,7.128743813e-004
	,7.305223246e-004
	,7.483354174e-004
	,7.663130618e-004
	,7.844546852e-004
	,8.027597356e-004
	,8.212276778e-004
	,8.398579896e-004
	,8.586501594e-004
	,8.776036840e-004
	,8.967180667e-004
	,-5.461456258e-011
	,-3.814402297e-011
	,-2.662207522e-011
	,-1.856671371e-011
	,-1.293859911e-011
	,-9.009072566e-012
	,-6.267338464e-012
	,-4.356229732e-012
	,-3.025241889e-012
	,-2.099233816e-012
	,-1.455578399e-012
	,-1.008556566e-012
	,-6.984189014e-013
	,-4.833894899e-013
	,-3.344819804e-013
	,-2.313454084e-013
	,-1.600229649e-013
	,-1.106807933e-013
	,-7.653180978e-014
	,-5.293538906e-014
	,-3.658101327e-014
	,-2.534979436e-014
	,-1.756140955e-014
	,-1.216568323e-014
	,-8.443543764e-015
	,-5.884419496e-015
	,-4.062955879e-015
	,-2.907773137e-015
	,-2.003176752e-015
	,-1.391879715e-015
	,-9.740443260e-016
	,-6.781863766e-016
	,-4.850380258e-016
	,-2.944482772e-016
	,-2.505343105e-016
	,-1.693378560e-016
	,-9.675710240e-017
	,-7.879467130e-017
	,-5.404411217e-017
	,-3.336642985e-017
	,-2.156553035e-017
	,3.054640639e-017
	,3.999756926e-017
	,3.242619568e-017
	,5.435707086e-017
	,1.105418844e-016
	,1.763345100e-016
	,1.663089670e-016
	,2.154967871e-016
	,3.153344855e-016
	,4.200283063e-016
	,5.002848662e-016
	,6.731732656e-016
	,8.906022281e-016
	,1.162440648e-015
	,1.517042013e-015
	,1.983334192e-015
	,2.610348357e-015
	,3.406961290e-015
	,4.400847666e-015
	,5.618846701e-015
	,7.345955338e-015
	,9.547293042e-015
	,1.247323731e-014
	,1.634200034e-014
	,2.145184204e-014
	,2.822393965e-014
	,3.723846924e-014
	,4.917419141e-014
	,6.510984413e-014
	,8.634874798e-014
	,1.146933598e-013
	,1.526074568e-013
	,2.032896572e-013
	,2.711424796e-013
	,3.621218276e-013
	,4.842332539e-013
	,6.482445049e-013
	,8.685901172e-013
	,1.165218363e-012
	,1.558313740e-012
	,2.043401410e-012
	,2.687254205e-012
	,3.543641357e-012
	,4.684942952e-012
	,6.208630920e-012
	,8.246067968e-012
	,1.097559106e-011
	,1.463805777e-011
	,1.955954865e-011
	,2.618177578e-011
	,3.461981958e-011
	,4.555408060e-011
	,5.998137007e-011
	,7.902707780e-011
	,1.041820020e-010
	,1.374213196e-010
	,1.813626543e-010
	,2.394717508e-010
	,3.163475770e-010
	,4.180949407e-010
	,5.528086892e-010
	,7.312278805e-010
	,9.676050845e-010
	,1.280860659e-009
	,1.696107058e-009
	,2.246680237e-009
	,2.976832724e-009
	,3.945306527e-009
	,5.230069441e-009
	,6.934591953e-009
	,9.196157634e-009
	,1.219685886e-008
	,1.617813882e-008
	,2.145999300e-008
	,2.843455502e-008
	,3.762037188e-008
	,4.978203226e-008
	,6.587233596e-008
	,8.714176562e-008
	,1.152265738e-007
	,1.522599821e-007
	,2.010107774e-007
	,2.650528574e-007
	,3.489706310e-007
	,4.585974788e-007
	,6.012870294e-007
	,7.862068276e-007
	,1.024637305e-006
	,1.330249080e-006
	,1.719321491e-006
	,2.210857229e-006
	,2.826545437e-006
	,3.590532216e-006
	,4.528975976e-006
	,5.669394636e-006
	,7.039847707e-006
	,8.668030294e-006
	,1.058037707e-005
	,1.280127428e-005
	,1.535245973e-005
	,1.825265911e-005
	,2.151745338e-005
	,2.515934785e-005
	,2.918802189e-005
	,3.361067505e-005
	,3.843242199e-005
	,4.365669436e-005
	,4.928562202e-005
	,5.532039202e-005
	,6.176152508e-005
	,6.860911920e-005
	,7.586292258e-005
	,8.352202481e-005
	,9.158667680e-005
	,9.999526796e-005
	,1.083879138e-004
	,1.171561447e-004
	,1.262931145e-004
	,1.357923405e-004
	,1.456477678e-004
	,1.558534788e-004
	,1.664037095e-004
	,1.772928145e-004
	,1.885152462e-004
	,2.000655449e-004
	,2.119383369e-004
	,2.241283399e-004
	,2.366303730e-004
	,2.494388080e-004
	,2.625455844e-004
	,2.759487684e-004
	,2.896434876e-004
	,3.036255332e-004
	,3.178903793e-004
	,3.324341720e-004
	,3.461044562e-004
	,3.595020794e-004
	,3.731054230e-004
	,3.869126888e-004
	,4.009219654e-004
	,4.151313891e-004
	,4.295384584e-004
	,4.441422996e-004
	,4.589417061e-004
	,4.739355517e-004
	,4.891228950e-004
	,5.045029774e-004
	,5.200752201e-004
	,5.358392250e-004
	,5.517947729e-004
	,5.679418222e-004
	,5.842805083e-004
	,6.008111445e-004
	,6.175342235e-004
	,6.344504200e-004
	,6.515605964e-004
	,6.688658095e-004
	,6.863673209e-004
	,7.040666117e-004
	,7.219654005e-004
	,-5.888683241e-011
	,-4.132648151e-011
	,-2.899009635e-011
	,-2.032617524e-011
	,-1.424352926e-011
	,-9.975047048e-012
	,-6.981153205e-012
	,-4.882492098e-012
	,-3.412195263e-012
	,-2.382677010e-012
	,-1.662179357e-012
	,-1.158299798e-012
	,-8.061935924e-013
	,-5.603446176e-013
	,-3.889085122e-013
	,-2.694204885e-013
	,-1.864513926e-013
	,-1.288374170e-013
	,-8.887361865e-014
	,-6.129282786e-014
	,-4.217354309e-014
	,-2.907898303e-014
	,-1.998592002e-014
	,-1.373144328e-014
	,-9.471736295e-015
	,-6.466840881e-015
	,-4.497396073e-015
	,-3.048496253e-015
	,-2.133926541e-015
	,-1.446393604e-015
	,-9.888737750e-016
	,-6.454989293e-016
	,-4.798163889e-016
	,-3.101131881e-016
	,-2.022863851e-016
	,-1.262593512e-016
	,-9.816694438e-017
	,-5.075448089e-017
	,-7.419963079e-017
	,-2.819853709e-018
	,-9.555765374e-018
	,-1.707492258e-017
	,1.018202229e-017
	,2.161740720e-017
	,2.396714383e-017
	,2.532476943e-017
	,3.023310816e-017
	,3.968427104e-017
	,9.712074952e-018
	,5.644572564e-017
	,6.218952628e-017
	,4.161627670e-017
	,9.800995574e-017
	,9.633903191e-017
	,1.027094290e-016
	,1.488164832e-016
	,2.058367587e-016
	,2.738224718e-016
	,3.809704619e-016
	,4.544911102e-016
	,6.132288734e-016
	,7.917566406e-016
	,1.024954947e-015
	,1.309273079e-015
	,1.700582551e-015
	,2.164472778e-015
	,2.748408438e-015
	,3.547632189e-015
	,4.585693614e-015
	,5.903634780e-015
	,7.683064219e-015
	,1.001264533e-014
	,1.313121578e-014
	,1.715688900e-014
	,2.254796807e-014
	,2.974082518e-014
	,3.918953388e-014
	,5.185341333e-014
	,6.866316807e-014
	,9.107156195e-014
	,1.210401029e-013
	,1.610216026e-013
	,2.145656255e-013
	,2.862228804e-013
	,3.821569875e-013
	,5.109405693e-013
	,6.839413904e-013
	,8.927904202e-013
	,1.166592227e-012
	,1.529056960e-012
	,2.009803414e-012
	,2.648788233e-012
	,3.499900749e-012
	,4.635852411e-012
	,6.153951191e-012
	,8.185912256e-012
	,1.091094459e-011
	,1.447102742e-011
	,1.897210551e-011
	,2.489328584e-011
	,3.268709306e-011
	,4.295165236e-011
	,5.647791913e-011
	,7.431168586e-011
	,9.783555992e-011
	,1.288765166e-010
	,1.698610732e-010
	,2.239990093e-010
	,2.955419213e-010
	,3.901240378e-010
	,5.152125814e-010
	,6.807070549e-010
	,8.997336172e-010
	,1.189700295e-009
	,1.573696165e-009
	,2.082349324e-009
	,2.756290928e-009
	,3.649424101e-009
	,4.833244259e-009
	,6.402533781e-009
	,8.483163774e-009
	,1.124201198e-008
	,1.490039574e-008
	,1.972549789e-008
	,2.606598697e-008
	,3.445889340e-008
	,4.556327004e-008
	,6.024617762e-008
	,7.964576193e-008
	,1.052518968e-007
	,1.390083301e-007
	,1.834405615e-007
	,2.418136086e-007
	,3.183230829e-007
	,4.183212258e-007
	,5.485763380e-007
	,7.175588570e-007
	,9.357401161e-007
	,1.215880652e-006
	,1.573274791e-006
	,2.025909242e-006
	,2.594488553e-006
	,3.302283266e-006
	,4.174770477e-006
	,5.239062142e-006
	,6.523150369e-006
	,8.055033883e-006
	,9.861820042e-006
	,1.196889239e-005
	,1.439923989e-005
	,1.717300246e-005
	,2.030725097e-005
	,2.381598682e-005
	,2.771025926e-005
	,3.199854788e-005
	,3.668718133e-005
	,4.178063004e-005
	,4.728192738e-005
	,5.319304231e-005
	,5.951517670e-005
	,6.624902275e-005
	,7.339511409e-005
	,8.095360193e-005
	,8.892467384e-005
	,9.684081855e-005
	,1.051342793e-004
	,1.138057422e-004
	,1.228487703e-004
	,1.322570875e-004
	,1.420247660e-004
	,1.521459545e-004
	,1.626148830e-004
	,1.734257851e-004
	,1.845729017e-004
	,1.960486781e-004
	,2.078486429e-004
	,2.199678577e-004
	,2.324009137e-004
	,2.451424980e-004
	,2.581874100e-004
	,2.715305779e-004
	,2.851670762e-004
	,2.990921347e-004
	,3.133009290e-004
	,3.268954967e-004
	,3.399935409e-004
	,3.533005199e-004
	,3.668134240e-004
	,3.805295614e-004
	,3.944472044e-004
	,4.085642664e-004
	,4.228785234e-004
	,4.373878812e-004
	,4.520913347e-004
	,4.669874829e-004
	,4.820750861e-004
	,4.973530621e-004
	,5.128204894e-004
	,5.284765989e-004
	,5.443207693e-004
	,5.603525216e-004
	,-6.212913671e-011
	,-4.372619082e-011
	,-3.076424504e-011
	,-2.163637173e-011
	,-1.521034307e-011
	,-1.068793667e-011
	,-7.506071313e-012
	,-5.267688810e-012
	,-3.693280418e-012
	,-2.586088906e-012
	,-1.807815302e-012
	,-1.261330528e-012
	,-8.781927601e-013
	,-6.102551122e-013
	,-4.234670808e-013
	,-2.934938535e-013
	,-2.032726350e-013
	,-1.406738237e-013
	,-9.727799997e-014
	,-6.725948797e-014
	,-4.643857615e-014
	,-3.208142428e-014
	,-2.214172505e-014
	,-1.527213948e-014
	,-1.055971657e-014
	,-7.239434284e-015
	,-4.983112742e-015
	,-3.407483793e-015
	,-2.360388936e-015
	,-1.604295906e-015
	,-1.139465785e-015
	,-7.807393262e-016
	,-5.294219399e-016
	,-3.021240836e-016
	,-2.406654167e-016
	,-1.750816566e-016
	,-7.832472397e-017
	,-2.736154736e-017
	,-1.101782372e-017
	,-1.420302226e-017
	,5.848063622e-018
	,2.563806765e-017
	,9.764291330e-018
	,-1.232323296e-017
	,2.475038937e-017
	,1.462041369e-017
	,3.822221269e-017
	,3.028532453e-017
	,2.845775159e-017
	,3.566361058e-017
	,4.741229371e-017
	,5.221619970e-017
	,3.127743554e-017
	,5.132852142e-017
	,1.963318514e-017
	,3.284392662e-017
	,5.200733422e-017
	,9.466810808e-017
	,4.913543389e-017
	,8.902874017e-017
	,7.503475315e-017
	,1.237004095e-016
	,1.241703568e-016
	,1.675621599e-016
	,2.321538089e-016
	,2.716816006e-016
	,3.501628039e-016
	,4.427946434e-016
	,5.388205469e-016
	,7.149985775e-016
	,8.595334882e-016
	,1.077641264e-015
	,1.417935343e-015
	,1.787261725e-015
	,2.264780424e-015
	,2.876756274e-015
	,3.713001431e-015
	,4.804845717e-015
	,6.266799630e-015
	,8.100168578e-015
	,1.060718091e-014
	,1.389649889e-014
	,1.824528700e-014
	,2.392225069e-014
	,3.158307091e-014
	,4.168876598e-014
	,5.512315017e-014
	,7.303503582e-014
	,9.683259400e-014
	,1.286595155e-013
	,1.712206606e-013
	,2.281421949e-013
	,3.045279553e-013
	,3.979805316e-013
	,5.167712579e-013
	,6.731864370e-013
	,8.797103763e-013
	,1.152912426e-012
	,1.515303586e-012
	,1.996686401e-012
	,2.636843582e-012
	,3.490975039e-012
	,4.632500642e-012
	,6.160965625e-012
	,8.045776888e-012
	,1.051621317e-011
	,1.375772299e-011
	,1.801392678e-011
	,2.360571894e-011
	,3.095613801e-011
	,4.062475773e-011
	,5.334345532e-011
	,7.008732617e-011
	,9.214571367e-011
	,1.212201087e-010
	,1.595611709e-010
	,2.101460105e-010
	,2.769147782e-010
	,3.650831001e-010
	,4.815575779e-010
	,6.354857809e-010
	,8.389865521e-010
	,1.108118984e-009
	,1.464165252e-009
	,1.935299131e-009
	,2.558944749e-009
	,3.384691840e-009
	,4.478303009e-009
	,5.926998961e-009
	,7.846476899e-009
	,1.039024197e-008
	,1.374028797e-008
	,1.812902102e-008
	,2.393553731e-008
	,3.161550021e-008
	,4.176933402e-008
	,5.518686413e-008
	,7.290491067e-008
	,9.628108444e-008
	,1.270867542e-007
	,1.676264529e-007
	,2.208831614e-007
	,2.906962390e-007
	,3.819742661e-007
	,5.009419632e-007
	,6.554166724e-007
	,8.551037880e-007
	,1.111891680e-006
	,1.440115656e-006
	,1.856753519e-006
	,2.381506269e-006
	,3.036718241e-006
	,3.847100451e-006
	,4.839242205e-006
	,6.040927081e-006
	,7.480304471e-006
	,9.185001767e-006
	,1.118126495e-005
	,1.349322255e-005
	,1.614235592e-005
	,1.914718926e-005
	,2.252320672e-005
	,2.628296252e-005
	,3.043633151e-005
	,3.499086560e-005
	,3.995219216e-005
	,4.532444732e-005
	,5.111043551e-005
	,5.731216675e-005
	,6.393105609e-005
	,7.096814695e-005
	,7.842427682e-005
	,8.591901586e-005
	,9.372085720e-005
	,1.019097043e-004
	,1.104792363e-004
	,1.194233315e-004
	,1.287359565e-004
	,1.384099796e-004
	,1.484406267e-004
	,1.588220361e-004
	,1.695484325e-004
	,1.806140698e-004
	,1.920132338e-004
	,2.037402503e-004
	,2.157894965e-004
	,2.281554157e-004
	,2.408325336e-004
	,2.538154763e-004
	,2.670989883e-004
	,2.806779506e-004
	,2.945473979e-004
	,3.080769048e-004
	,3.208739199e-004
	,3.338833399e-004
	,3.471024348e-004
	,3.605284061e-004
	,3.741577220e-004
	,3.879888084e-004
	,4.020194571e-004
	,4.162476035e-004
	,-6.475965746e-011
	,-4.565988141e-011
	,-3.218315079e-011
	,-2.267625341e-011
	,-1.597126423e-011
	,-1.124262918e-011
	,-7.907644801e-012
	,-5.555246706e-012
	,-3.895971989e-012
	,-2.726398364e-012
	,-1.903480860e-012
	,-1.326311920e-012
	,-9.226920201e-013
	,-6.413199881e-013
	,-4.454453685e-013
	,-3.092760423e-013
	,-2.146536626e-013
	,-1.489470897e-013
	,-1.033692483e-013
	,-7.174732827e-014
	,-4.972324687e-014
	,-3.448259403e-014
	,-2.389885810e-014
	,-1.660318696e-014
	,-1.146906464e-014
	,-7.939864664e-015
	,-5.521985675e-015
	,-3.771379672e-015
	,-2.589932096e-015
	,-1.830758300e-015
	,-1.218521368e-015
	,-8.533722962e-016
	,-5.769910525e-016
	,-3.834771872e-016
	,-2.507953924e-016
	,-1.652127628e-016
	,-9.895018992e-017
	,-6.558392982e-017
	,-4.234764541e-017
	,-2.240099227e-017
	,-2.495959437e-017
	,1.817112682e-017
	,1.456819732e-017
	,5.070192500e-017
	,2.908434803e-017
	,2.657796230e-017
	,2.929321351e-017
	,3.268727752e-017
	,1.545587559e-017
	,2.866661707e-017
	,2.579471675e-017
	,6.051860245e-017
	,6.902987067e-017
	,2.198292177e-017
	,3.952762191e-017
	,3.749118350e-017
	,3.743896713e-017
	,6.312942091e-017
	,2.104302711e-017
	,5.205955058e-017
	,5.435707084e-017
	,4.866548656e-017
	,4.720342821e-017
	,1.639577022e-017
	,7.665346060e-017
	,6.041416969e-017
	,9.028193303e-017
	,7.017863078e-017
	,9.691341195e-017
	,1.226560821e-016
	,1.427593844e-016
	,1.660478851e-016
	,2.017638819e-016
	,2.531447894e-016
	,3.233235900e-016
	,3.881241045e-016
	,5.198660047e-016
	,5.965718515e-016
	,7.394880548e-016
	,9.368137150e-016
	,1.165886928e-015
	,1.483832402e-015
	,1.874254196e-015
	,2.407174463e-015
	,3.057947076e-015
	,3.956381929e-015
	,5.138978265e-015
	,6.676593697e-015
	,8.687759384e-015
	,1.138337724e-014
	,1.491163733e-014
	,1.955309819e-014
	,2.574439312e-014
	,3.393228537e-014
	,4.478624101e-014
	,5.923565921e-014
	,7.849378730e-014
	,1.042073729e-013
	,1.385429777e-013
	,1.815154833e-013
	,2.340955398e-013
	,3.029339462e-013
	,3.932662289e-013
	,5.120477652e-013
	,6.688679866e-013
	,8.766986928e-013
	,1.152147143e-012
	,1.518224935e-012
	,2.005874968e-012
	,2.656929549e-012
	,3.479781990e-012
	,4.528360210e-012
	,5.899701229e-012
	,7.694325736e-012
	,1.004466912e-011
	,1.312472676e-011
	,1.715883721e-011
	,2.245068152e-011
	,2.939766083e-011
	,3.852300740e-011
	,5.051686283e-011
	,6.628995931e-011
	,8.704440016e-011
	,1.143679292e-010
	,1.503579527e-010
	,1.977865957e-010
	,2.603184955e-010
	,3.427971878e-010
	,4.515927812e-010
	,5.952014399e-010
	,7.848491930e-010
	,1.035393253e-009
	,1.366510437e-009
	,1.804268710e-009
	,2.383211406e-009
	,3.149126000e-009
	,4.162723381e-009
	,5.504532667e-009
	,7.281425227e-009
	,9.617432073e-009
	,1.266556649e-008
	,1.669536395e-008
	,2.202207216e-008
	,2.906123282e-008
	,3.836054379e-008
	,5.064023899e-008
	,6.684566737e-008
	,8.821483937e-008
	,1.163643958e-007
	,1.533980325e-007
	,2.020415717e-007
	,2.658086631e-007
	,3.492001237e-007
	,4.579378448e-007
	,5.992305311e-007
	,7.820629260e-007
	,1.017492473e-006
	,1.318927961e-006
	,1.702354844e-006
	,2.186459545e-006
	,2.792622740e-006
	,3.544722273e-006
	,4.468722299e-006
	,5.592068463e-006
	,6.942915528e-006
	,8.549260119e-006
	,1.043807941e-005
	,1.263454531e-005
	,1.516140420e-005
	,1.803860497e-005
	,2.128312244e-005
	,2.490899593e-005
	,2.892752716e-005
	,3.334759280e-005
	,3.817601273e-005
	,4.341793152e-005
	,4.907727573e-005
	,5.515693185e-005
	,6.165908218e-005
	,6.858550797e-005
	,7.565250422e-005
	,8.294602535e-005
	,9.063503724e-005
	,9.871369488e-005
	,1.071757762e-004
	,1.160154070e-004
	,1.252267365e-004
	,1.348038484e-004
	,1.447410179e-004
	,1.550324291e-004
	,1.656722644e-004
	,1.766547087e-004
	,1.879739586e-004
	,1.996242342e-004
	,2.116004608e-004
	,2.238966526e-004
	,2.365069759e-004
	,2.494259092e-004
	,2.626480420e-004
	,2.761680940e-004
	,2.896434626e-004
	,-6.699338749e-011
	,-4.729424949e-011
	,-3.337687563e-011
	,-2.354577779e-011
	,-1.660110978e-011
	,-1.169452176e-011
	,-8.226730524e-012
	,-5.775866298e-012
	,-4.045212169e-012
	,-2.826320548e-012
	,-1.970850368e-012
	,-1.372622096e-012
	,-9.552167090e-013
	,-6.645209220e-013
	,-4.621963276e-013
	,-3.214595312e-013
	,-2.235236573e-013
	,-1.555040558e-013
	,-1.081328433e-013
	,-7.519674164e-014
	,-5.231552854e-014
	,-3.635434201e-014
	,-2.525100099e-014
	,-1.757827544e-014
	,-1.219309682e-014
	,-8.469860814e-015
	,-5.883427385e-015
	,-4.077524246e-015
	,-2.811172853e-015
	,-1.967408539e-015
	,-1.311362073e-015
	,-9.689793382e-016
	,-6.381886375e-016
	,-4.255113646e-016
	,-2.819685649e-016
	,-1.628108098e-016
	,-1.083491364e-016
	,-7.869023856e-017
	,-3.958017782e-017
	,4.229356168e-018
	,1.978983427e-017
	,1.697015032e-017
	,1.702236669e-017
	,3.420155224e-017
	,3.498479778e-017
	,2.798780427e-017
	,4.407044607e-017
	,3.660350523e-017
	,2.804002064e-017
	,3.237397930e-017
	,4.213844039e-017
	,2.459374025e-017
	,5.044084314e-017
	,3.676015433e-017
	,4.036308382e-017
	,6.678456678e-017
	,3.895324184e-017
	,5.665459110e-017
	,6.568802302e-017
	,4.485369159e-017
	,5.326052708e-017
	,7.174512187e-017
	,4.323498413e-017
	,8.892430743e-017
	,4.678569725e-017
	,7.931649544e-017
	,6.177179529e-017
	,6.949981797e-017
	,8.365045410e-017
	,6.485256109e-017
	,6.699343223e-017
	,8.605240709e-017
	,4.840440470e-017
	,1.020306161e-016
	,8.949868747e-017
	,9.894985035e-017
	,1.213506729e-016
	,1.662045342e-016
	,1.540903365e-016
	,2.012939345e-016
	,2.104840155e-016
	,2.809761143e-016
	,3.085985738e-016
	,3.836857131e-016
	,4.507837479e-016
	,5.373062721e-016
	,6.869583870e-016
	,8.068993877e-016
	,1.014407240e-015
	,1.283791490e-015
	,1.608159577e-015
	,2.002288734e-015
	,2.587738669e-015
	,3.277360261e-015
	,4.234120799e-015
	,5.481047702e-015
	,7.138604134e-015
	,9.366311106e-015
	,1.219158221e-014
	,1.606306049e-014
	,2.107948711e-014
	,2.791236457e-014
	,3.686627096e-014
	,4.888679251e-014
	,6.475398957e-014
	,8.513137554e-014
	,1.089476794e-013
	,1.399067649e-013
	,1.801575966e-013
	,2.328410415e-013
	,3.019142127e-013
	,3.928672437e-013
	,5.129530926e-013
	,6.719221221e-013
	,8.832175410e-013
	,1.164914568e-012
	,1.532347375e-012
	,1.987569527e-012
	,2.580877764e-012
	,3.354176558e-012
	,4.358295724e-012
	,5.668852817e-012
	,7.381399613e-012
	,9.620792399e-012
	,1.255123093e-011
	,1.638846968e-011
	,2.141649627e-011
	,2.800896236e-011
	,3.665801167e-011
	,4.801195252e-011
	,6.292502268e-011
	,8.252422904e-011
	,1.082873282e-010
	,1.421640790e-010
	,1.867507874e-010
	,2.454628035e-010
	,3.228128330e-010
	,4.247654142e-010
	,5.592071678e-010
	,7.365699484e-010
	,9.706571093e-010
	,1.279740325e-009
	,1.688015528e-009
	,2.227537312e-009
	,2.940793283e-009
	,3.883832804e-009
	,5.131573247e-009
	,6.768664141e-009
	,8.894075170e-009
	,1.170120393e-008
	,1.540849157e-008
	,2.030415324e-008
	,2.676809305e-008
	,3.530048892e-008
	,4.655893333e-008
	,6.140646216e-008
	,8.097330243e-008
	,1.067356860e-007
	,1.406155444e-007
	,1.851052072e-007
	,2.434211874e-007
	,3.196904925e-007
	,4.191702321e-007
	,5.485031840e-007
	,7.159987423e-007
	,9.319267866e-007
	,1.208806023e-006
	,1.561652811e-006
	,2.008150864e-006
	,2.568695923e-006
	,3.266272341e-006
	,4.126131571e-006
	,5.175264740e-006
	,6.441694745e-006
	,7.953646066e-006
	,9.738677483e-006
	,1.182287012e-005
	,1.423015637e-005
	,1.698185564e-005
	,2.009642002e-005
	,2.358938960e-005
	,2.747349259e-005
	,3.175893128e-005
	,3.645384422e-005
	,4.156453495e-005
	,4.709606425e-005
	,5.305228173e-005
	,5.943619635e-005
	,6.606948582e-005
	,7.284081512e-005
	,8.001530409e-005
	,8.758735422e-005
	,9.555136158e-005
	,1.039017086e-004
	,1.126331032e-004
	,1.217397664e-004
	,1.312157549e-004
	,1.410553292e-004
	,1.512531703e-004
	,1.618036915e-004
	,1.727004398e-004
	,-6.893874206e-011
	,-4.871452962e-011
	,-3.441049804e-011
	,-2.429361045e-011
	,-1.713626631e-011
	,-1.207068733e-011
	,-8.484851390e-012
	,-5.948767751e-012
	,-4.160007769e-012
	,-2.903567304e-012
	,-2.023987364e-012
	,-1.409996223e-012
	,-9.819417257e-013
	,-6.837421853e-013
	,-4.761095881e-013
	,-3.315833975e-013
	,-2.309395306e-013
	,-1.608596278e-013
	,-1.120221274e-013
	,-7.808858862e-014
	,-5.438637753e-014
	,-3.790595143e-014
	,-2.639527051e-014
	,-1.838418289e-014
	,-1.279102647e-014
	,-8.888844963e-015
	,-6.184506971e-015
	,-4.318032844e-015
	,-2.982077031e-015
	,-2.074086582e-015
	,-1.450048750e-015
	,-9.858974419e-016
	,-6.542712793e-016
	,-4.961601125e-016
	,-2.954403883e-016
	,-2.208754127e-016
	,-1.406188528e-016
	,-9.096108539e-017
	,-5.326086663e-017
	,-8.720303463e-018
	,-1.671093585e-018
	,2.715234237e-017
	,1.989426701e-017
	,6.004712724e-018
	,2.662865075e-018
	,6.365158463e-017
	,3.279171026e-017
	,5.482701818e-017
	,3.822221268e-017
	,1.759674674e-017
	,3.796113083e-017
	,4.328720052e-017
	,4.313055141e-017
	,4.897878479e-017
	,4.192957491e-017
	,4.814332287e-017
	,5.028419402e-017
	,7.472145494e-017
	,3.472371591e-017
	,7.435594035e-017
	,1.124216737e-016
	,7.983865914e-017
	,5.059749223e-017
	,5.211176694e-017
	,5.179846872e-017
	,3.289614297e-017
	,6.725451409e-017
	,7.440815670e-017
	,7.681010970e-017
	,6.641905217e-017
	,7.827216804e-017
	,5.440928719e-017
	,9.049079849e-017
	,8.547802702e-017
	,9.388486251e-017
	,8.077855377e-017
	,6.083190062e-017
	,1.292353446e-016
	,9.529470448e-017
	,6.474812833e-017
	,9.707006104e-017
	,9.472032441e-017
	,9.847990301e-017
	,1.227082984e-016
	,1.150324921e-016
	,1.813994977e-016
	,1.732537441e-016
	,2.187342019e-016
	,2.020249637e-016
	,2.613949758e-016
	,2.963277270e-016
	,3.021759603e-016
	,4.037890153e-016
	,4.497394205e-016
	,5.517702064e-016
	,6.735387801e-016
	,8.362972037e-016
	,1.036338115e-015
	,1.338618678e-015
	,1.685857535e-015
	,2.181756396e-015
	,2.788771691e-015
	,3.568205439e-015
	,4.565903610e-015
	,5.953240331e-015
	,7.760344446e-015
	,1.009096988e-014
	,1.320421426e-014
	,1.736168160e-014
	,2.283395712e-014
	,3.021881382e-014
	,3.994233728e-014
	,5.112426394e-014
	,6.549676743e-014
	,8.407232314e-014
	,1.082928861e-013
	,1.398684380e-013
	,1.810817741e-013
	,2.345162471e-013
	,3.047713358e-013
	,3.975259881e-013
	,5.203110578e-013
	,6.835612553e-013
	,8.839293545e-013
	,1.142611338e-012
	,1.478758968e-012
	,1.915964332e-012
	,2.485041615e-012
	,3.226390518e-012
	,4.192824243e-012
	,5.453762730e-012
	,7.099961319e-012
	,9.250757337e-012
	,1.206262690e-011
	,1.572901411e-011
	,2.052282381e-011
	,2.679838724e-011
	,3.501979686e-011
	,4.579717360e-011
	,5.993363277e-011
	,7.848703893e-011
	,1.028513548e-010
	,1.348643482e-010
	,1.769496453e-010
	,2.323057548e-010
	,3.051545631e-010
	,4.010721332e-010
	,5.274249440e-010
	,6.939519618e-010
	,9.134397223e-010
	,1.202955129e-009
	,1.585053368e-009
	,2.089600899e-009
	,2.756202875e-009
	,3.637438690e-009
	,4.791236381e-009
	,6.279939105e-009
	,8.243906828e-009
	,1.083493623e-008
	,1.425331626e-008
	,1.876312106e-008
	,2.471215794e-008
	,3.255666809e-008
	,4.289885922e-008
	,5.652770808e-008
	,7.447632622e-008
	,9.809418972e-008
	,1.291387756e-007
	,1.698905592e-007
	,2.232954998e-007
	,2.931387376e-007
	,3.842520100e-007
	,5.027548663e-007
	,6.563256564e-007
	,8.544922589e-007
	,1.108924446e-006
	,1.433700140e-006
	,1.845508682e-006
	,2.363747312e-006
	,3.010466353e-006
	,3.810127111e-006
	,4.789155018e-006
	,5.975311639e-006
	,7.396904609e-006
	,9.081935601e-006
	,1.105727290e-005
	,1.334792826e-005
	,1.597651989e-005
	,1.896293609e-005
	,2.232420519e-005
	,2.607458685e-005
	,3.022578031e-005
	,3.478724853e-005
	,3.976657305e-005
	,4.516985992e-005
	,5.100224294e-005
	,5.719731724e-005
	,6.343403034e-005
	,7.008035065e-005
	,7.713150886e-005
	,8.458258415e-005
	,-7.065929984e-011
	,-4.996747812e-011
	,-3.531823963e-011
	,-2.494449172e-011
	,-1.759480609e-011
	,-1.238557570e-011
	,-8.695429721e-012
	,-6.088069276e-012
	,-4.253435804e-012
	,-2.967625198e-012
	,-2.069041110e-012
	,-1.442132005e-012
	,-1.005100573e-012
	,-7.005333511e-013
	,-4.882957922e-013
	,-3.404602326e-013
	,-2.374034994e-013
	,-1.655695965e-013
	,-1.155243837e-013
	,-8.056082485e-014
	,-5.621060862e-014
	,-3.922310935e-014
	,-2.733882031e-014
	,-1.908268126e-014
	,-1.328306132e-014
	,-9.251383216e-015
	,-6.447311959e-015
	,-4.516455048e-015
	,-3.138830572e-015
	,-2.147137283e-015
	,-1.498557757e-015
	,-1.036338455e-015
	,-7.481040953e-016
	,-4.678066239e-016
	,-3.218618712e-016
	,-2.429629369e-016
	,-1.590512312e-016
	,-9.414628393e-017
	,-5.801255625e-017
	,-2.506555495e-018
	,1.044157628e-018
	,2.673461141e-017
	,1.681350121e-017
	,4.997089583e-017
	,2.793558790e-017
	,1.305392260e-017
	,5.320831073e-017
	,4.913543391e-017
	,5.707232207e-017
	,5.628907652e-017
	,4.584580262e-017
	,6.636683583e-017
	,5.477480180e-017
	,5.101522320e-017
	,5.085857409e-017
	,7.419929124e-017
	,5.691567294e-017
	,7.910762997e-017
	,5.049305950e-017
	,5.007532854e-017
	,6.292055543e-017
	,6.135406434e-017
	,6.730673046e-017
	,8.631348895e-017
	,6.558359026e-017
	,7.325939658e-017
	,8.464256512e-017
	,8.996863481e-017
	,7.832438441e-017
	,4.903100113e-017
	,9.613016640e-017
	,1.031793763e-016
	,9.947201404e-017
	,1.090798260e-016
	,9.607795003e-017
	,9.111739492e-017
	,7.592243140e-017
	,8.406818504e-017
	,1.045370019e-016
	,1.028138617e-016
	,8.161401567e-017
	,9.566021906e-017
	,9.487697351e-017
	,1.097586388e-016
	,1.180088252e-016
	,1.245358714e-016
	,1.136226502e-016
	,9.539913720e-017
	,1.002030432e-016
	,9.754000835e-017
	,1.022394816e-016
	,1.222383511e-016
	,1.444825245e-016
	,1.588942425e-016
	,1.787886793e-016
	,1.954979175e-016
	,2.060978405e-016
	,2.088130917e-016
	,2.607161630e-016
	,2.995129255e-016
	,3.953299635e-016
	,4.098983306e-016
	,5.018513572e-016
	,5.912457818e-016
	,7.517066852e-016
	,9.351950075e-016
	,1.140405340e-015
	,1.421381624e-015
	,1.806164050e-015
	,2.338092206e-015
	,2.978212680e-015
	,3.828086309e-015
	,4.943271312e-015
	,6.436555047e-015
	,8.383755681e-015
	,1.095614291e-014
	,1.438263329e-014
	,1.893193226e-014
	,2.424614883e-014
	,3.090765217e-014
	,3.947322542e-014
	,5.053500221e-014
	,6.487502711e-014
	,8.350984840e-014
	,1.077854474e-013
	,1.394970752e-013
	,1.810516453e-013
	,2.358166958e-013
	,3.082147443e-013
	,4.003435312e-013
	,5.167530344e-013
	,6.677112896e-013
	,8.612996677e-013
	,1.111945760e-012
	,1.437219854e-012
	,1.859750591e-012
	,2.408926231e-012
	,3.123361668e-012
	,4.053341057e-012
	,5.264764484e-012
	,6.844147790e-012
	,8.904743998e-012
	,1.159495924e-011
	,1.510961174e-011
	,1.970423896e-011
	,2.571461895e-011
	,3.358178295e-011
	,4.388560108e-011
	,5.735672047e-011
	,7.500778683e-011
	,9.815742037e-011
	,1.285305080e-010
	,1.684043979e-010
	,2.207869992e-010
	,2.896408201e-010
	,3.801953740e-010
	,4.993558602e-010
	,6.562458145e-010
	,8.629280015e-010
	,1.135363362e-009
	,1.494690167e-009
	,1.968935757e-009
	,2.595317478e-009
	,3.413632792e-009
	,4.461465018e-009
	,5.841870198e-009
	,7.660317457e-009
	,1.005654020e-008
	,1.321441242e-008
	,1.737617545e-008
	,2.286071588e-008
	,3.008741026e-008
	,3.960712850e-008
	,5.214238386e-008
	,6.863906944e-008
	,9.033271585e-008
	,1.188327013e-007
	,1.562282669e-007
	,2.052193891e-007
	,2.692735030e-007
	,3.528362337e-007
	,4.615441279e-007
	,6.024895384e-007
	,7.845044239e-007
	,1.018453090e-006
	,1.317510689e-006
	,1.697393636e-006
	,2.176500801e-006
	,2.775920978e-006
	,3.519266940e-006
	,4.432311675e-006
	,5.542428087e-006
	,6.877865709e-006
	,8.466928073e-006
	,1.033713701e-005
	,1.251447247e-005
	,1.502276447e-005
	,1.788328534e-005
	,2.111455548e-005
	,2.473245338e-005
	,2.875017918e-005
	,-7.219556971e-011
	,-5.108269330e-011
	,-3.612094898e-011
	,-2.551315091e-011
	,-1.798791619e-011
	,-1.264954281e-011
	,-8.869715431e-012
	,-6.204135039e-012
	,-4.332714716e-012
	,-3.023209523e-012
	,-2.108658035e-012
	,-1.470613006e-012
	,-1.025758257e-012
	,-7.155252973e-013
	,-4.992144439e-013
	,-3.483779573e-013
	,-2.431660457e-013
	,-1.697856506e-013
	,-1.185530375e-013
	,-8.272206038e-014
	,-5.778587205e-014
	,-4.038487135e-014
	,-2.821783067e-014
	,-1.970259400e-014
	,-1.372517732e-014
	,-9.594131465e-015
	,-6.714764203e-015
	,-4.665741648e-015
	,-3.246448509e-015
	,-2.278565885e-015
	,-1.609256461e-015
	,-1.105629577e-015
	,-7.878929688e-016
	,-5.603862470e-016
	,-3.414430098e-016
	,-2.467225155e-016
	,-1.621319970e-016
	,-1.030752831e-016
	,-2.647386909e-017
	,-2.861474024e-017
	,1.848442503e-017
	,3.931875645e-017
	,3.555917785e-017
	,7.466923859e-017
	,4.506255709e-017
	,5.305166162e-017
	,5.414820538e-017
	,4.756894282e-017
	,3.973648740e-017
	,6.709786500e-017
	,8.051747196e-017
	,4.427931154e-017
	,6.788111054e-017
	,5.205955059e-017
	,6.594910487e-017
	,6.949981799e-017
	,6.845549060e-017
	,7.461702220e-017
	,6.537472480e-017
	,7.430372398e-017
	,8.793219641e-017
	,6.688899951e-017
	,8.197953028e-017
	,9.064744762e-017
	,8.610462347e-017
	,9.064744761e-017
	,9.832325392e-017
	,7.868989900e-017
	,9.414594436e-017
	,9.174399137e-017
	,8.678343626e-017
	,6.913430338e-017
	,9.472032442e-017
	,5.096300680e-017
	,8.600019071e-017
	,1.159201704e-016
	,1.069911712e-016
	,8.970755294e-017
	,1.186876380e-016
	,9.043858211e-017
	,1.051113819e-016
	,9.122182765e-017
	,1.008296396e-016
	,1.160246032e-016
	,1.078788495e-016
	,9.200507319e-017
	,1.169644978e-016
	,1.017695343e-016
	,1.058946275e-016
	,7.660124418e-017
	,9.472032439e-017
	,1.344047652e-016
	,1.193142344e-016
	,1.182176907e-016
	,1.501741088e-016
	,1.010907215e-016
	,1.259457133e-016
	,1.429682498e-016
	,1.303318884e-016
	,1.188965034e-016
	,1.675099434e-016
	,1.682409726e-016
	,1.459967992e-016
	,1.412451096e-016
	,1.891275204e-016
	,2.168021962e-016
	,2.551290114e-016
	,2.777909158e-016
	,3.191984968e-016
	,3.662454457e-016
	,4.557965193e-016
	,5.284294893e-016
	,6.539054251e-016
	,7.970304939e-016
	,9.630785488e-016
	,1.234655886e-015
	,1.528268532e-015
	,1.911014520e-015
	,2.480486246e-015
	,3.163424142e-015
	,4.067289498e-015
	,5.331969967e-015
	,6.898669917e-015
	,9.044606053e-015
	,1.162127502e-014
	,1.482114636e-014
	,1.887825384e-014
	,2.404850988e-014
	,3.074625137e-014
	,3.937996698e-014
	,5.049312468e-014
	,6.493491929e-014
	,8.367657527e-014
	,1.082313752e-013
	,1.403428760e-013
	,1.821227075e-013
	,2.342730232e-013
	,3.015595069e-013
	,3.886313996e-013
	,5.013318696e-013
	,6.472457624e-013
	,8.362909508e-013
	,1.081499857e-012
	,1.399725159e-012
	,1.812582552e-012
	,2.348933904e-012
	,3.041486923e-012
	,3.941172724e-012
	,5.111529386e-012
	,6.635175268e-012
	,8.620282115e-012
	,1.120829462e-011
	,1.458470595e-011
	,1.899260994e-011
	,2.475035935e-011
	,3.227631409e-011
	,4.212014939e-011
	,5.500373500e-011
	,7.187603106e-011
	,9.398508019e-011
	,1.229733964e-010
	,1.610040580e-010
	,2.108386949e-010
	,2.762464487e-010
	,3.621793676e-010
	,4.751490564e-010
	,6.237577855e-010
	,8.193686702e-010
	,1.077012918e-009
	,1.416668269e-009
	,1.864843318e-009
	,2.449007973e-009
	,3.190081030e-009
	,4.164964283e-009
	,5.447613356e-009
	,7.135527031e-009
	,9.357182916e-009
	,1.228179968e-008
	,1.613212942e-008
	,2.120118627e-008
	,2.787406687e-008
	,3.665632446e-008
	,4.820922145e-008
	,6.340007477e-008
	,8.336180283e-008
	,1.095694878e-007
	,1.439385456e-007
	,1.889466457e-007
	,2.477838576e-007
	,3.245344080e-007
	,4.243919410e-007
	,5.539073865e-007
	,7.212640420e-007
	,9.365680076e-007
	,1.212133796e-006
	,1.562723327e-006
	,2.005731489e-006
	,2.561285047e-006
	,3.252099893e-006
	,4.103215860e-006
	,5.141514460e-006
	,-7.358132041e-011
	,-5.208371327e-011
	,-3.683489186e-011
	,-2.601153323e-011
	,-1.832562206e-011
	,-1.287275933e-011
	,-9.017176025e-012
	,-6.303911592e-012
	,-4.402064843e-012
	,-3.072380216e-012
	,-2.144028412e-012
	,-1.496277456e-012
	,-1.044365403e-012
	,-7.290500158e-013
	,-5.091017701e-013
	,-3.555700312e-013
	,-2.484108145e-013
	,-1.735392766e-013
	,-1.212864078e-013
	,-8.481572793e-014
	,-5.922620839e-014
	,-4.142408154e-014
	,-2.894050522e-014
	,-2.025128361e-014
	,-1.417977303e-014
	,-9.873750124e-015
	,-6.926606014e-015
	,-4.848237860e-015
	,-3.349053675e-015
	,-2.398036938e-015
	,-1.614269232e-015
	,-1.098580367e-015
	,-8.019913886e-016
	,-5.372543953e-016
	,-3.552803477e-016
	,-2.491244685e-016
	,-1.371725724e-016
	,-1.050595052e-016
	,-3.937131235e-017
	,-2.443743068e-017
	,1.138299878e-017
	,6.318010943e-018
	,1.070418598e-017
	,3.921432371e-017
	,4.365271512e-017
	,3.263506115e-017
	,5.284279614e-017
	,4.965759760e-017
	,2.720455872e-017
	,5.696788933e-017
	,7.821995170e-017
	,6.929095252e-017
	,8.265834310e-017
	,7.252836742e-017
	,9.184842413e-017
	,8.281499221e-017
	,8.479921425e-017
	,9.487697355e-017
	,7.284166563e-017
	,8.297164131e-017
	,6.506142658e-017
	,8.208396302e-017
	,9.017750029e-017
	,8.182288117e-017
	,9.341491520e-017
	,9.362378067e-017
	,7.143182364e-017
	,8.928982200e-017
	,9.999417774e-017
	,1.193142345e-016
	,8.448591601e-017
	,9.456367531e-017
	,8.761889817e-017
	,8.156179931e-017
	,9.122182766e-017
	,8.981198568e-017
	,1.093931242e-016
	,9.644346460e-017
	,1.055813293e-016
	,1.040148382e-016
	,1.245880877e-016
	,8.072633738e-017
	,1.064167912e-016
	,1.290786955e-016
	,1.190531526e-016
	,1.186876380e-016
	,1.011951542e-016
	,1.136226501e-016
	,1.354490926e-016
	,1.044847855e-016
	,9.988974497e-017
	,1.504351906e-016
	,1.189487198e-016
	,1.362323381e-016
	,1.150847085e-016
	,1.169644978e-016
	,1.152413576e-016
	,1.498085942e-016
	,1.266245261e-016
	,1.197319654e-016
	,1.497041614e-016
	,1.600430026e-016
	,1.382165601e-016
	,1.587898097e-016
	,1.440647935e-016
	,1.620272246e-016
	,1.504874070e-016
	,1.457357173e-016
	,1.957067829e-016
	,1.988397651e-016
	,2.230681605e-016
	,2.063589223e-016
	,2.358611711e-016
	,2.630136832e-016
	,2.560689060e-016
	,2.692274312e-016
	,3.346545421e-016
	,3.365343314e-016
	,4.351188370e-016
	,4.856642826e-016
	,6.410079818e-016
	,6.901435855e-016
	,8.541552021e-016
	,1.091269736e-015
	,1.343265935e-015
	,1.669931542e-015
	,2.090273317e-015
	,2.669039556e-015
	,3.444765941e-015
	,4.410977642e-015
	,5.698320015e-015
	,7.183927943e-015
	,9.060636479e-015
	,1.154023522e-014
	,1.465718696e-014
	,1.873230908e-014
	,2.390345280e-014
	,3.061873900e-014
	,3.931057143e-014
	,5.060800070e-014
	,6.528330691e-014
	,8.446415477e-014
	,1.085561088e-013
	,1.391750569e-013
	,1.786716232e-013
	,2.296421101e-013
	,2.953343758e-013
	,3.802633086e-013
	,4.900279655e-013
	,6.319756595e-013
	,8.157406242e-013
	,1.053797037e-012
	,1.362374215e-012
	,1.762683075e-012
	,2.282198199e-012
	,2.957153361e-012
	,3.833944373e-012
	,4.974048698e-012
	,6.457725717e-012
	,8.389489313e-012
	,1.089468514e-011
	,1.415495406e-011
	,1.840520299e-011
	,2.394982612e-011
	,3.118774131e-011
	,4.064235543e-011
	,5.300065277e-011
	,6.916476725e-011
	,9.032027430e-011
	,1.180261807e-010
	,1.543318237e-010
	,2.019383017e-010
	,2.644056595e-010
	,3.464285828e-010
	,4.542049464e-010
	,5.959270629e-010
	,7.821943346e-010
	,1.027374203e-009
	,1.350579860e-009
	,1.770931219e-009
	,2.298248114e-009
	,2.990781696e-009
	,3.900462042e-009
	,5.095691086e-009
	,6.666398481e-009
	,8.731248672e-009
	,1.144625270e-008
	,1.501659513e-008
	,1.971196026e-008
	,2.588652026e-008
	,3.400492584e-008
	,4.467598686e-008
	,5.869613138e-008
	,7.710518510e-008
	,1.012575003e-007
	,1.329119267e-007
	,1.743444780e-007
	,2.284876593e-007
	,2.990989979e-007
	,3.909573294e-007
	,5.101179768e-007
	,-7.484392606e-011
	,-5.299002199e-011
	,-3.747425713e-011
	,-2.645045907e-011
	,-1.861778941e-011
	,-1.306465036e-011
	,-9.145198135e-012
	,-6.391790071e-012
	,-4.463973772e-012
	,-3.116738022e-012
	,-2.176039291e-012
	,-1.519539483e-012
	,-1.061239175e-012
	,-7.413991872e-013
	,-5.180743700e-013
	,-3.621345165e-013
	,-2.531099744e-013
	,-1.770192887e-013
	,-1.238166042e-013
	,-8.655578623e-014
	,-6.056608043e-014
	,-4.238799572e-014
	,-2.967576392e-014
	,-2.076843453e-014
	,-1.451155584e-014
	,-1.016261108e-014
	,-7.136985767e-015
	,-4.963218305e-015
	,-3.501264392e-015
	,-2.420646626e-015
	,-1.700478458e-015
	,-1.156801619e-015
	,-7.704527014e-016
	,-5.423715995e-016
	,-3.476567578e-016
	,-2.591500115e-016
	,-1.641162190e-016
	,-9.393741845e-017
	,-5.352194848e-017
	,-5.623719969e-017
	,3.602759731e-018
	,2.798780428e-017
	,7.884502025e-018
	,3.644685613e-017
	,2.871730552e-018
	,6.250282450e-017
	,8.631348898e-017
	,4.856105384e-017
	,6.981311622e-017
	,9.398929529e-017
	,3.300057573e-017
	,6.412153194e-017
	,5.294722887e-017
	,8.887209107e-017
	,7.926427908e-017
	,7.560913322e-017
	,8.636570533e-017
	,8.072633742e-017
	,8.720116724e-017
	,1.136226502e-016
	,8.526916156e-017
	,8.657457080e-017
	,7.284166562e-017
	,1.088187442e-016
	,4.793445738e-017
	,1.105941008e-016
	,9.586908456e-017
	,1.020306162e-016
	,1.045370019e-016
	,5.874324585e-017
	,8.265834307e-017
	,1.261023625e-016
	,1.200974800e-016
	,8.422483415e-017
	,9.372821340e-017
	,1.271466899e-016
	,1.225516493e-016
	,1.348747125e-016
	,1.047458674e-016
	,1.122128082e-016
	,1.391564548e-016
	,1.189487198e-016
	,1.146147612e-016
	,1.332037887e-016
	,1.104896680e-016
	,9.017750025e-017
	,1.461012320e-016
	,1.108551826e-016
	,1.208285091e-016
	,1.054768965e-016
	,1.160246031e-016
	,1.581109969e-016
	,1.292875610e-016
	,1.414539751e-016
	,1.217684038e-016
	,1.416106242e-016
	,1.541947692e-016
	,1.462578811e-016
	,1.424983025e-016
	,1.381643438e-016
	,1.653690723e-016
	,9.675676278e-017
	,1.652646395e-016
	,1.539336874e-016
	,1.847413454e-016
	,1.593641898e-016
	,1.310629175e-016
	,1.429682498e-016
	,1.831748543e-016
	,1.527327109e-016
	,1.510617870e-016
	,1.323161104e-016
	,2.243213534e-016
	,1.482943194e-016
	,1.498608105e-016
	,1.867777837e-016
	,1.905895787e-016
	,2.080820625e-016
	,2.135647813e-016
	,2.202484766e-016
	,2.474532051e-016
	,2.257834117e-016
	,2.805583833e-016
	,2.790441086e-016
	,2.762766410e-016
	,3.658277147e-016
	,3.831113330e-016
	,4.474419002e-016
	,5.193438409e-016
	,6.398592217e-016
	,7.457540190e-016
	,9.425575156e-016
	,1.126985733e-015
	,1.404098005e-015
	,1.778228293e-015
	,2.285249240e-015
	,2.890959126e-015
	,3.620369592e-015
	,4.504392727e-015
	,5.681819642e-015
	,7.163981290e-015
	,9.112957281e-015
	,1.155986857e-014
	,1.471055209e-014
	,1.875904386e-014
	,2.399430928e-014
	,3.071272846e-014
	,3.951995907e-014
	,5.066522984e-014
	,6.487763793e-014
	,8.313425606e-014
	,1.065688060e-013
	,1.368338837e-013
	,1.758267187e-013
	,2.260762542e-013
	,2.909259566e-013
	,3.745961616e-013
	,4.821798974e-013
	,6.211583598e-013
	,8.009237594e-013
	,1.033420904e-012
	,1.334448274e-012
	,1.724562305e-012
	,2.230278784e-012
	,2.886353708e-012
	,3.738069113e-012
	,4.844455658e-012
	,6.282701198e-012
	,8.152761807e-012
	,1.058623871e-011
	,1.375518605e-011
	,1.788440841e-011
	,2.326814544e-011
	,3.029207367e-011
	,3.943377268e-011
	,5.135256719e-011
	,6.692230800e-011
	,8.727583872e-011
	,1.139015964e-010
	,1.487570327e-010
	,1.944193726e-010
	,2.542844620e-010
	,3.328327312e-010
	,4.359831530e-010
	,5.715691046e-010
	,7.499790671e-010
	,9.850215199e-010
	,1.290192547e-009
	,1.668055823e-009
	,2.163563664e-009
	,2.812792198e-009
	,3.663930439e-009
	,4.780705944e-009
	,6.246542201e-009
	,8.171140548e-009
	,1.069870921e-008
	,1.401873333e-008
	,1.838004528e-008
	,2.410916870e-008
	,3.163416677e-008
	,4.151505406e-008
	,-7.600403683e-011
	,-5.381657558e-011
	,-3.805020211e-011
	,-2.683926430e-011
	,-1.887352978e-011
	,-1.323293046e-011
	,-9.258895259e-012
	,-6.470886592e-012
	,-4.520163494e-012
	,-3.157122736e-012
	,-2.205364944e-012
	,-1.540845485e-012
	,-1.076762005e-012
	,-7.527466920e-013
	,-5.263693058e-013
	,-3.680998190e-013
	,-2.575045563e-013
	,-1.802388456e-013
	,-1.261366298e-013
	,-8.826550681e-014
	,-6.181358171e-014
	,-4.327003463e-014
	,-3.026841972e-014
	,-2.120141267e-014
	,-1.484490515e-014
	,-1.038416514e-014
	,-7.314208125e-015
	,-5.110572900e-015
	,-3.619325604e-015
	,-2.491713105e-015
	,-1.778071983e-015
	,-1.234447361e-015
	,-8.135834226e-016
	,-5.746413159e-016
	,-3.929805665e-016
	,-2.498554977e-016
	,-1.867781234e-016
	,-8.025672965e-017
	,-5.555838689e-017
	,-1.227101659e-017
	,-1.932022647e-017
	,1.618537689e-018
	,1.321057171e-017
	,4.965759761e-017
	,5.832551494e-017
	,8.589575802e-017
	,5.477480181e-017
	,8.338937228e-017
	,7.247615106e-017
	,6.594910488e-017
	,7.075301087e-017
	,6.949981800e-017
	,6.845549061e-017
	,8.694008540e-017
	,5.681124021e-017
	,1.155546559e-016
	,8.996863482e-017
	,8.459034877e-017
	,1.018217507e-016
	,1.206718601e-016
	,1.049025165e-016
	,9.153512590e-017
	,9.430259348e-017
	,1.072000367e-016
	,9.649568100e-017
	,8.965533659e-017
	,8.803662914e-017
	,9.096074583e-017
	,1.343003325e-016
	,9.404151162e-017
	,1.135182174e-016
	,1.146669776e-016
	,1.026049962e-016
	,1.153980067e-016
	,1.080354986e-016
	,1.356579581e-016
	,8.892430740e-017
	,1.190531526e-016
	,1.119517263e-016
	,1.211940237e-016
	,1.100719370e-016
	,1.306451866e-016
	,1.294442101e-016
	,1.270422571e-016
	,1.596774880e-016
	,1.413495423e-016
	,1.497041615e-016
	,1.408273786e-016
	,1.416106242e-016
	,1.355535253e-016
	,1.306974030e-016
	,1.648991250e-016
	,1.496519451e-016
	,1.358146072e-016
	,1.502263251e-016
	,1.620794410e-016
	,1.587375934e-016
	,1.537770383e-016
	,1.419761388e-016
	,1.402007822e-016
	,1.452657700e-016
	,1.625493883e-016
	,2.045313494e-016
	,1.676665925e-016
	,2.089697408e-016
	,1.732537441e-016
	,1.712173057e-016
	,1.887097894e-016
	,1.794674920e-016
	,1.707995747e-016
	,1.499130269e-016
	,2.051057294e-016
	,1.933570463e-016
	,2.091263899e-016
	,1.740369896e-016
	,1.957067829e-016
	,1.496519450e-016
	,1.863078364e-016
	,1.504874069e-016
	,2.043224839e-016
	,2.287075284e-016
	,1.829137724e-016
	,2.144524596e-016
	,2.328848380e-016
	,2.105884482e-016
	,2.282375811e-016
	,1.928870990e-016
	,2.514216491e-016
	,2.323104579e-016
	,2.369054984e-016
	,2.687052674e-016
	,2.969021070e-016
	,3.154911345e-016
	,3.623292179e-016
	,4.004471676e-016
	,4.496349877e-016
	,5.268107818e-016
	,5.689493919e-016
	,7.245019566e-016
	,8.621965229e-016
	,1.015503784e-015
	,1.224786993e-015
	,1.533699034e-015
	,1.905949532e-015
	,2.360962976e-015
	,2.914143194e-015
	,3.633267035e-015
	,4.542092946e-015
	,5.754818127e-015
	,7.205702169e-015
	,9.180525263e-015
	,1.161631447e-014
	,1.484072750e-014
	,1.889694730e-014
	,2.414349145e-014
	,3.080786669e-014
	,3.936706954e-014
	,5.034629225e-014
	,6.434471767e-014
	,8.232704320e-014
	,1.055507435e-013
	,1.353363705e-013
	,1.737392649e-013
	,2.231467592e-013
	,2.868940696e-013
	,3.691191866e-013
	,4.752273400e-013
	,6.122953099e-013
	,7.894279080e-013
	,1.018463577e-012
	,1.314880607e-012
	,1.697398567e-012
	,2.192465412e-012
	,2.833931032e-012
	,3.665687200e-012
	,4.744794555e-012
	,6.145829196e-012
	,7.965975603e-012
	,1.033210488e-011
	,1.340995481e-011
	,1.741526245e-011
	,2.263148378e-011
	,2.942939841e-011
	,3.829436429e-011
	,4.986262086e-011
	,6.496852994e-011
	,8.470779308e-011
	,1.105197615e-010
	,1.442355261e-010
	,1.883082777e-010
	,2.460510294e-010
	,3.217763491e-010
	,4.211927383e-010
	,5.518728672e-010
	,7.238976756e-010
	,9.468866422e-010
	,1.218631523e-009
	,1.574308394e-009
	,2.039926157e-009
	,2.649688992e-009
	,3.448561138e-009
	,-7.707739537e-011
	,-5.457484201e-011
	,-3.857153787e-011
	,-2.718607958e-011
	,-1.910025827e-011
	,-1.338336107e-011
	,-9.361738897e-012
	,-6.543191696e-012
	,-4.571857700e-012
	,-3.194452532e-012
	,-2.232453387e-012
	,-1.560538314e-012
	,-1.091150696e-012
	,-7.631983727e-013
	,-5.339420892e-013
	,-3.736964217e-013
	,-2.615847956e-013
	,-1.831543466e-013
	,-1.282628281e-013
	,-8.980166019e-014
	,-6.294631141e-014
	,-4.407797852e-014
	,-3.090013335e-014
	,-2.159961470e-014
	,-1.519747007e-014
	,-1.060477930e-014
	,-7.432008254e-015
	,-5.222890311e-015
	,-3.657025823e-015
	,-2.561839689e-015
	,-1.775461165e-015
	,-1.257004832e-015
	,-8.751987386e-016
	,-6.018460444e-016
	,-3.887510405e-016
	,-2.772690917e-016
	,-1.767525804e-016
	,-1.304366607e-016
	,-2.381083424e-017
	,-3.984125967e-017
	,-9.869063595e-018
	,2.005091612e-017
	,5.608021105e-017
	,4.981424672e-017
	,2.255730185e-017
	,4.495812435e-017
	,8.083077018e-017
	,4.192957492e-017
	,6.939538526e-017
	,7.503475316e-017
	,6.182401168e-017
	,3.106857006e-017
	,5.482701817e-017
	,1.046414347e-016
	,7.712340794e-017
	,1.023961308e-016
	,1.109073990e-016
	,1.013518034e-016
	,1.058946275e-016
	,7.681010971e-017
	,1.294442101e-016
	,9.492918992e-017
	,8.432926691e-017
	,8.135293385e-017
	,9.205728959e-017
	,8.380710321e-017
	,1.396264022e-016
	,1.078788495e-016
	,9.190064047e-017
	,7.675789332e-017
	,1.243792223e-016
	,1.348747126e-016
	,1.286087482e-016
	,1.003074760e-016
	,1.286087482e-016
	,1.092364751e-016
	,1.133093519e-016
	,1.178521761e-016
	,1.368067182e-016
	,1.317939467e-016
	,1.468844775e-016
	,1.446391736e-016
	,1.468322611e-016
	,1.313239994e-016
	,1.511140034e-016
	,1.511140034e-016
	,1.414539751e-016
	,1.583720788e-016
	,1.533070909e-016
	,1.358668235e-016
	,1.628626866e-016
	,1.600430026e-016
	,1.665178324e-016
	,1.609306809e-016
	,1.617139264e-016
	,1.332037887e-016
	,1.744547206e-016
	,1.935659118e-016
	,1.884487076e-016
	,1.995707943e-016
	,1.629671193e-016
	,1.535159564e-016
	,1.839058834e-016
	,1.619227919e-016
	,1.980043032e-016
	,1.739847732e-016
	,1.832792870e-016
	,1.936703445e-016
	,1.927826662e-016
	,1.856812400e-016
	,2.082387116e-016
	,1.837492343e-016
	,1.860467546e-016
	,2.009284199e-016
	,1.948191046e-016
	,1.767000244e-016
	,2.205095584e-016
	,2.066722205e-016
	,2.175854417e-016
	,1.768566735e-016
	,1.901718477e-016
	,2.262533591e-016
	,2.291774757e-016
	,2.272976864e-016
	,2.309006159e-016
	,2.032259401e-016
	,2.501684563e-016
	,2.283942302e-016
	,2.468266086e-016
	,2.136169976e-016
	,2.439547083e-016
	,2.384197731e-016
	,2.566432861e-016
	,2.673998582e-016
	,2.682353201e-016
	,2.854667220e-016
	,2.775820502e-016
	,3.036902350e-016
	,2.973198379e-016
	,3.081286264e-016
	,3.565854173e-016
	,3.862965315e-016
	,3.907349229e-016
	,4.722446756e-016
	,5.344343717e-016
	,5.893659924e-016
	,6.500414137e-016
	,7.579204331e-016
	,9.348294929e-016
	,1.085317070e-015
	,1.322536036e-015
	,1.604243350e-015
	,1.946573868e-015
	,2.389107599e-015
	,2.977690516e-015
	,3.672742610e-015
	,4.636656791e-015
	,5.813457110e-015
	,7.287890735e-015
	,9.270755149e-015
	,1.174936178e-014
	,1.495857984e-014
	,1.898414863e-014
	,2.417268040e-014
	,3.081350606e-014
	,3.930284341e-014
	,5.016181182e-014
	,6.413110050e-014
	,8.208893656e-014
	,1.051175565e-013
	,1.347428792e-013
	,1.728678781e-013
	,2.218217689e-013
	,2.848423318e-013
	,3.661065632e-013
	,4.708996995e-013
	,6.060880367e-013
	,7.805884076e-013
	,1.005991489e-012
	,1.297367759e-012
	,1.674204264e-012
	,2.161913458e-012
	,2.793541879e-012
	,3.611961307e-012
	,4.673056156e-012
	,6.046999117e-012
	,7.828268974e-012
	,1.014120131e-011
	,1.314632716e-011
	,1.705359193e-011
	,2.213722837e-011
	,2.875598473e-011
	,3.737799280e-011
	,4.861823580e-011
	,6.328345052e-011
	,8.243208062e-011
	,1.074550342e-010
	,1.401829510e-010
	,1.830281379e-010
	,2.391766306e-010
	,3.128448435e-010
	,-7.807546564e-011
	,-5.527340910e-011
	,-3.904537333e-011
	,-2.749776238e-011
	,-1.930413750e-011
	,-1.351994891e-011
	,-9.456206873e-012
	,-6.610002070e-012
	,-4.619837442e-012
	,-3.229180804e-012
	,-2.257644652e-012
	,-1.578910383e-012
	,-1.104555056e-012
	,-7.729082677e-013
	,-5.410183994e-013
	,-3.788676698e-013
	,-2.653137232e-013
	,-1.858627575e-013
	,-1.302659003e-013
	,-9.128794693e-014
	,-6.400327517e-014
	,-4.485850881e-014
	,-3.144751755e-014
	,-2.206277390e-014
	,-1.546022285e-014
	,-1.080831870e-014
	,-7.606672010e-015
	,-5.362777964e-015
	,-3.774878169e-015
	,-2.596824657e-015
	,-1.805903308e-015
	,-1.309534500e-015
	,-8.640244355e-016
	,-6.211661011e-016
	,-4.057213606e-016
	,-2.817074831e-016
	,-1.626541607e-016
	,-9.926348814e-017
	,-6.641939174e-017
	,-3.656843481e-019
	,-2.809257654e-017
	,3.388825403e-017
	,6.140628074e-017
	,2.897991529e-017
	,5.889989500e-017
	,5.796000035e-017
	,4.819553926e-017
	,6.923873616e-017
	,9.158734229e-017
	,9.247502057e-017
	,5.498366728e-017
	,8.083077017e-017
	,8.913317292e-017
	,6.976089984e-017
	,1.050069492e-016
	,1.007774233e-016
	,7.728005704e-017
	,1.007774233e-016
	,7.973422640e-017
	,9.059523125e-017
	,9.054301488e-017
	,8.991641845e-017
	,1.323161105e-016
	,1.074611186e-016
	,1.028138617e-016
	,1.005685578e-016
	,1.109596153e-016
	,1.220294857e-016
	,8.741003270e-017
	,9.931536494e-017
	,1.418717061e-016
	,1.171733633e-016
	,1.092364751e-016
	,1.254757660e-016
	,1.626538211e-016
	,1.137792993e-016
	,1.380076947e-016
	,1.134660011e-016
	,1.412973260e-016
	,1.224994330e-016
	,1.475632903e-016
	,1.298619411e-016
	,1.250580351e-016
	,1.404096477e-016
	,1.552913130e-016
	,1.526282782e-016
	,1.747680188e-016
	,1.366500691e-016
	,1.722616331e-016
	,1.497041615e-016
	,1.786842465e-016
	,1.609306809e-016
	,1.795197084e-016
	,1.622360901e-016
	,1.656823705e-016
	,1.786842465e-016
	,1.752379661e-016
	,1.827571233e-016
	,1.773788373e-016
	,2.157578688e-016
	,2.031737238e-016
	,2.025471273e-016
	,2.001973907e-016
	,1.864122692e-016
	,2.140869450e-016
	,2.000407416e-016
	,2.300651541e-016
	,1.934092627e-016
	,1.887620058e-016
	,1.920516371e-016
	,1.804073867e-016
	,1.879265439e-016
	,2.297518558e-016
	,2.368532821e-016
	,2.429103809e-016
	,2.604028647e-016
	,2.201440438e-016
	,2.265144409e-016
	,2.275587683e-016
	,2.512127837e-016
	,2.330937035e-016
	,2.357567383e-016
	,2.470354741e-016
	,2.478709360e-016
	,2.248435171e-016
	,2.600895665e-016
	,2.384719895e-016
	,2.540846840e-016
	,2.636924960e-016
	,2.567999352e-016
	,2.725170624e-016
	,2.529881402e-016
	,2.446857375e-016
	,2.452079012e-016
	,2.712116532e-016
	,2.967976742e-016
	,2.946045867e-016
	,2.984163817e-016
	,2.855711548e-016
	,2.974242706e-016
	,2.930380956e-016
	,3.212871515e-016
	,3.313649108e-016
	,3.005572528e-016
	,3.081808427e-016
	,2.954400486e-016
	,3.578908265e-016
	,3.588829375e-016
	,4.082796230e-016
	,3.884896190e-016
	,4.209682008e-016
	,4.744377631e-016
	,4.719313774e-016
	,5.705680994e-016
	,6.268051293e-016
	,7.408978966e-016
	,8.798456558e-016
	,1.003337370e-015
	,1.157323443e-015
	,1.359296360e-015
	,1.674683232e-015
	,2.053774074e-015
	,2.489310812e-015
	,3.068912513e-015
	,3.794772266e-015
	,4.739836337e-015
	,5.944885712e-015
	,7.531950046e-015
	,9.422495919e-015
	,1.193519983e-014
	,1.511820529e-014
	,1.914001450e-014
	,2.435277466e-014
	,3.100357364e-014
	,3.953692939e-014
	,5.039537564e-014
	,6.436455989e-014
	,8.231184824e-014
	,1.053216703e-013
	,1.348375475e-013
	,1.727952974e-013
	,2.216356697e-013
	,2.844082571e-013
	,3.652971572e-013
	,4.695130416e-013
	,6.038351615e-013
	,7.767522276e-013
	,1.000005038e-012
	,1.288127185e-012
	,1.660470994e-012
	,2.141736844e-012
	,2.764419922e-012
	,3.570121531e-012
	,4.613801542e-012
	,5.966351039e-012
	,7.720441388e-012
	,9.996564839e-012
	,1.295199297e-011
	,1.679246298e-011
	,2.178116960e-011
	,2.826293453e-011
	,-7.900748956e-011
	,-5.591923662e-011
	,-3.947794444e-011
	,-2.778020171e-011
	,-1.948974826e-011
	,-1.364567695e-011
	,-9.543914082e-012
	,-6.672512897e-012
	,-4.664834741e-012
	,-3.261764915e-012
	,-2.281384198e-012
	,-1.596136876e-012
	,-1.117048449e-012
	,-7.820454013e-013
	,-5.476778663e-013
	,-3.836341889e-013
	,-2.687849630e-013
	,-1.883816752e-013
	,-1.320930032e-013
	,-9.258447938e-014
	,-6.497825922e-014
	,-4.557930357e-014
	,-3.201161099e-014
	,-2.245873063e-014
	,-1.575592415e-014
	,-1.104851400e-014
	,-7.746820746e-015
	,-5.434575472e-015
	,-3.805529177e-015
	,-2.674783696e-015
	,-1.864751157e-015
	,-1.350367701e-015
	,-8.709692127e-016
	,-6.305128312e-016
	,-4.565278881e-016
	,-2.943438445e-016
	,-1.760215513e-016
	,-1.406188528e-016
	,-6.057115836e-017
	,-3.864181103e-018
	,1.462041369e-017
	,-1.932175436e-018
	,2.396714382e-017
	,7.070079451e-017
	,3.002424268e-017
	,6.782889418e-017
	,8.881987471e-017
	,5.728118754e-017
	,4.866548658e-017
	,4.751672645e-017
	,6.668013405e-017
	,7.748892253e-017
	,1.007252069e-016
	,9.179620776e-017
	,8.135293386e-017
	,9.195285687e-017
	,1.017695343e-016
	,1.098630716e-016
	,7.931649545e-017
	,1.170689306e-016
	,1.108029662e-016
	,1.079832823e-016
	,9.435480985e-017
	,8.955090386e-017
	,8.845436009e-017
	,1.196797490e-016
	,1.090276097e-016
	,1.190531526e-016
	,1.143536794e-016
	,9.378042977e-017
	,1.065212239e-016
	,1.480332377e-016
	,1.209329419e-016
	,1.269900408e-016
	,1.219250529e-016
	,1.287131809e-016
	,1.309062685e-016
	,1.559701258e-016
	,1.601474354e-016
	,1.633848503e-016
	,1.392608876e-016
	,1.512184362e-016
	,1.540903365e-016
	,1.586331606e-016
	,1.730448786e-016
	,1.775877028e-016
	,1.428638171e-016
	,1.618183592e-016
	,1.543514183e-016
	,1.648991250e-016
	,1.754990480e-016
	,1.509051379e-016
	,1.834359361e-016
	,2.098052027e-016
	,1.692330836e-016
	,1.967511103e-016
	,1.711128729e-016
	,1.899107659e-016
	,2.213450204e-016
	,2.347646273e-016
	,1.818172287e-016
	,2.111628283e-016
	,1.744025042e-016
	,2.424404336e-016
	,2.069333024e-016
	,2.086564426e-016
	,2.502206727e-016
	,2.038525366e-016
	,2.042702675e-016
	,2.449468193e-016
	,2.748667991e-016
	,2.472443396e-016
	,2.221804823e-016
	,2.526226257e-016
	,2.341902472e-016
	,2.445290884e-016
	,2.571654498e-016
	,2.704806240e-016
	,2.510039182e-016
	,2.365922002e-016
	,2.530925730e-016
	,2.733003080e-016
	,2.608205956e-016
	,2.911060899e-016
	,2.484975324e-016
	,2.497507253e-016
	,2.745535008e-016
	,2.773731848e-016
	,3.053089424e-016
	,3.109483103e-016
	,2.795140559e-016
	,3.080241936e-016
	,2.994607090e-016
	,2.935602593e-016
	,2.945523703e-016
	,3.206605551e-016
	,2.793574068e-016
	,2.981030834e-016
	,3.007661183e-016
	,3.287018759e-016
	,3.054133752e-016
	,3.116793395e-016
	,2.812894125e-016
	,3.162743800e-016
	,3.051522933e-016
	,3.447845177e-016
	,3.701094569e-016
	,3.586218556e-016
	,3.532957860e-016
	,3.652011182e-016
	,3.656710655e-016
	,4.030579861e-016
	,3.898994610e-016
	,3.831113329e-016
	,4.261898377e-016
	,4.154854820e-016
	,4.292183872e-016
	,4.662920095e-016
	,4.603915597e-016
	,4.861864463e-016
	,5.417968798e-016
	,5.731267014e-016
	,6.821544809e-016
	,7.439786624e-016
	,8.683580545e-016
	,9.338895982e-016
	,1.073255088e-015
	,1.254080376e-015
	,1.527641936e-015
	,1.798853759e-015
	,2.146666996e-015
	,2.610713871e-015
	,3.217468085e-015
	,4.007031808e-015
	,4.941391523e-015
	,6.146336465e-015
	,7.699355726e-015
	,9.691410222e-015
	,1.218928469e-014
	,1.540341110e-014
	,1.952307378e-014
	,2.470627948e-014
	,3.146782938e-014
	,4.004645672e-014
	,5.094881694e-014
	,6.504525248e-014
	,8.313759791e-014
	,1.061709695e-013
	,1.358518505e-013
	,1.738916323e-013
	,2.228210335e-013
	,2.856597268e-013
	,3.664990736e-013
	,4.704133562e-013
	,6.043900126e-013
	,7.768687223e-013
	,9.993161479e-013
	,1.286230530e-012
	,1.656593719e-012
	,2.134918117e-012
	,2.752497410e-012
	,-1.303087814e-008
	,-1.204018130e-008
	,-1.113427403e-008
	,-1.030415672e-008
	,-9.548001564e-009
	,-8.859437733e-009
	,-8.236222512e-009
	,-7.665271199e-009
	,-7.142583010e-009
	,-6.658704661e-009
	,-6.215956910e-009
	,-5.797423762e-009
	,-5.400675935e-009
	,-5.036365908e-009
	,-4.699479805e-009
	,-4.390623147e-009
	,-4.106956640e-009
	,-3.837830879e-009
	,-3.577621310e-009
	,-3.332575833e-009
	,-3.107251466e-009
	,-2.899526650e-009
	,-2.707150125e-009
	,-2.529257490e-009
	,-2.364395797e-009
	,-2.203665337e-009
	,-2.053983408e-009
	,-1.914389037e-009
	,-1.782192534e-009
	,-1.656085606e-009
	,-1.536320730e-009
	,-1.416847888e-009
	,-1.299755194e-009
	,-1.184094412e-009
	,-1.066455852e-009
	,-9.433881312e-010
	,-8.092069639e-010
	,-6.579920930e-010
	,-4.814855915e-010
	,-2.669033344e-010
	,2.005091614e-017
	,3.400507833e-010
	,7.831191286e-010
	,1.369848703e-009
	,2.152990992e-009
	,3.209513043e-009
	,4.643653915e-009
	,6.598530532e-009
	,9.260804998e-009
	,1.274703517e-008
	,1.745279824e-008
	,2.380688538e-008
	,3.238569934e-008
	,4.395702832e-008
	,5.944316552e-008
	,8.026562371e-008
	,1.082236442e-007
	,1.456931672e-007
	,1.957708334e-007
	,2.625451042e-007
	,3.512173674e-007
	,4.685170418e-007
	,6.229360447e-007
	,8.240463774e-007
	,1.085150108e-006
	,1.421670337e-006
	,1.851624957e-006
	,2.395630436e-006
	,3.076609922e-006
	,3.919053082e-006
	,4.948552985e-006
	,6.185066343e-006
	,7.656197296e-006
	,9.376983469e-006
	,1.136484243e-005
	,1.364005847e-005
	,1.621509022e-005
	,1.909917425e-005
	,2.229865258e-005
	,2.581735024e-005
	,2.965666109e-005
	,3.381583096e-005
	,3.829285176e-005
	,4.308389526e-005
	,4.818517851e-005
	,5.359580179e-005
	,5.931292461e-005
	,6.533272721e-005
	,7.165171936e-005
	,7.826639964e-005
	,8.517328224e-005
	,9.236871247e-005
	,9.978154494e-005
	,1.074228215e-004
	,1.153240813e-004
	,1.234810501e-004
	,1.318893924e-004
	,1.405453816e-004
	,1.494439642e-004
	,1.585824758e-004
	,1.679570090e-004
	,1.775636276e-004
	,1.873983727e-004
	,1.974572531e-004
	,2.077354029e-004
	,2.179962769e-004
	,2.283615633e-004
	,2.387873142e-004
	,2.493957305e-004
	,2.601823613e-004
	,2.711429479e-004
	,2.822734126e-004
	,2.935698486e-004
	,3.050285001e-004
	,3.166456417e-004
	,3.284164234e-004
	,3.403389962e-004
	,3.524087425e-004
	,3.646018176e-004
	,3.769361777e-004
	,3.894092934e-004
	,4.020179754e-004
	,4.147603266e-004
	,4.276339784e-004
	,4.406366619e-004
	,4.537650912e-004
	,4.670089102e-004
	,4.803756313e-004
	,4.938635287e-004
	,5.074712274e-004
	,5.211632830e-004
	,5.349528379e-004
	,5.488524965e-004
	,5.628610299e-004
	,5.764286526e-004
	,5.900679218e-004
	,6.038114515e-004
	,6.176594445e-004
	,6.316125236e-004
	,6.456689558e-004
	,6.598285742e-004
	,6.740912965e-004
	,6.884571192e-004
	,7.029261120e-004
	,7.174984100e-004
	,7.321742062e-004
	,7.469537425e-004
	,7.618373002e-004
	,7.768251895e-004
	,7.919177394e-004
	,8.071152865e-004
	,8.224181648e-004
	,8.378266946e-004
	,8.533411735e-004
	,8.689618672e-004
	,8.846890575e-004
	,9.005229148e-004
	,9.164635272e-004
	,9.325109683e-004
	,9.486652548e-004
	,9.649175702e-004
	,9.812407350e-004
	,9.976695945e-004
	,1.014203945e-003
	,1.030843533e-003
	,1.047588063e-003
	,1.064441854e-003
	,1.081409285e-003
	,1.098482014e-003
	,1.115507721e-003
	,1.132081767e-003
	,1.148795379e-003
	,1.165632319e-003
	,1.182582991e-003
	,1.199641252e-003
	,1.216802857e-003
	,1.234064741e-003
	,1.251424599e-003
	,1.268880638e-003
	,1.286431419e-003
	,1.304075757e-003
	,1.321812652e-003
	,1.339641237e-003
	,1.357560716e-003
	,1.375570322e-003
	,1.393669530e-003
	,1.411857698e-003
	,1.430134295e-003
	,1.448489246e-003
	,1.466917715e-003
	,1.485423901e-003
	,1.503903470e-003
	,1.522471794e-003
	,1.541128317e-003
	,1.559872624e-003
	,1.578704086e-003
	,1.597622163e-003
	,1.616626603e-003
	,1.635716165e-003
	,1.654891112e-003
	,1.674151253e-003
	,-2.377555912e-009
	,-2.129970130e-009
	,-1.916181829e-009
	,-1.727044090e-009
	,-1.564915178e-009
	,-1.424348809e-009
	,-1.301268376e-009
	,-1.192562526e-009
	,-1.095813834e-009
	,-1.009124217e-009
	,-9.301765184e-010
	,-8.575926344e-010
	,-7.903312334e-010
	,-7.291431582e-010
	,-6.684672152e-010
	,-6.136008187e-010
	,-5.640680973e-010
	,-5.192452249e-010
	,-4.785940411e-010
	,-4.405778330e-010
	,-4.040028044e-010
	,-3.707125282e-010
	,-3.403748219e-010
	,-3.125257997e-010
	,-2.862421418e-010
	,-2.618533683e-010
	,-2.397235700e-010
	,-2.195129305e-010
	,-2.008670298e-010
	,-1.836883414e-010
	,-1.676625652e-010
	,-1.526150266e-010
	,-1.383143283e-010
	,-1.244898496e-010
	,-1.108148152e-010
	,-9.688312953e-011
	,-8.221448389e-011
	,-6.617135395e-011
	,-4.792022967e-011
	,-2.635325773e-011
	,2.453999620e-018
	,3.310191196e-011
	,7.563873800e-011
	,1.312567617e-010
	,2.049151874e-010
	,3.024333162e-010
	,4.308688880e-010
	,6.033710552e-010
	,8.360681078e-010
	,1.150929505e-009
	,1.577859160e-009
	,2.157346572e-009
	,2.945173314e-009
	,4.017167715e-009
	,5.476639878e-009
	,7.361905440e-009
	,9.839618914e-009
	,1.314649069e-008
	,1.755898782e-008
	,2.344504598e-008
	,3.129424555e-008
	,4.175545827e-008
	,5.568768675e-008
	,7.422534678e-008
	,9.886207339e-008
	,1.315572531e-007
	,1.748697820e-007
	,2.321234488e-007
	,3.075178791e-007
	,4.065024504e-007
	,5.360668224e-007
	,7.048949302e-007
	,9.237253059e-007
	,1.205634544e-006
	,1.566262430e-006
	,2.023932898e-006
	,2.599617051e-006
	,3.316685021e-006
	,4.200452944e-006
	,5.277461266e-006
	,6.574581704e-006
	,8.117992613e-006
	,9.932295457e-006
	,1.203954433e-005
	,1.445869035e-005
	,1.720522101e-005
	,2.029099420e-005
	,2.372439769e-005
	,2.751066667e-005
	,3.165229419e-005
	,3.614949617e-005
	,4.100066528e-005
	,4.620279093e-005
	,5.175184388e-005
	,5.764311510e-005
	,6.387142272e-005
	,7.043131534e-005
	,7.731722110e-005
	,8.452354340e-005
	,9.204470814e-005
	,9.987546549e-005
	,1.080104809e-004
	,1.164421840e-004
	,1.251408820e-004
	,1.341210926e-004
	,1.433770460e-004
	,1.529029158e-004
	,1.626928934e-004
	,1.727412679e-004
	,1.830423385e-004
	,1.934920164e-004
	,2.038904964e-004
	,2.145119862e-004
	,2.253493711e-004
	,2.363959150e-004
	,2.476452199e-004
	,2.590912053e-004
	,2.707282686e-004
	,2.825507145e-004
	,2.945530974e-004
	,3.067294205e-004
	,3.190665545e-004
	,3.315614921e-004
	,3.442161052e-004
	,3.570262750e-004
	,3.699873639e-004
	,3.830961626e-004
	,3.963492565e-004
	,4.097426831e-004
	,4.232735839e-004
	,4.369312630e-004
	,4.507200041e-004
	,4.646376723e-004
	,4.786727154e-004
	,4.928002628e-004
	,5.070448293e-004
	,5.212943994e-004
	,5.349563461e-004
	,5.487289094e-004
	,5.626111622e-004
	,5.766030166e-004
	,5.907035069e-004
	,6.049113416e-004
	,6.192259319e-004
	,6.336467954e-004
	,6.481735671e-004
	,6.628059456e-004
	,6.775437322e-004
	,6.923868137e-004
	,7.073351498e-004
	,7.223887657e-004
	,7.375477427e-004
	,7.528122079e-004
	,7.681823234e-004
	,7.836582752e-004
	,7.992402621e-004
	,8.149284847e-004
	,8.307231351e-004
	,8.466243871e-004
	,8.626323875e-004
	,8.787472488e-004
	,8.949690431e-004
	,9.112977975e-004
	,9.277334910e-004
	,9.442760529e-004
	,9.609253628e-004
	,9.776812513e-004
	,9.945435023e-004
	,1.011513618e-003
	,1.028590676e-003
	,1.045779300e-003
	,1.063076901e-003
	,1.080480547e-003
	,1.097703993e-003
	,1.114701403e-003
	,1.131827760e-003
	,1.149071022e-003
	,1.166423665e-003
	,1.183880787e-003
	,1.201438950e-003
	,1.219095652e-003
	,1.236849001e-003
	,1.254697491e-003
	,1.272639898e-003
	,1.290675200e-003
	,1.308802521e-003
	,1.327021093e-003
	,1.345330227e-003
	,1.363729295e-003
	,1.382217625e-003
	,1.400794720e-003
	,1.419460090e-003
	,1.438213228e-003
	,1.457053578e-003
	,1.475932848e-003
	,1.494835968e-003
	,1.513802676e-003
	,1.532857043e-003
	,1.551998647e-003
	,1.571227056e-003
	,1.590541544e-003
	,-4.910077511e-010
	,-3.828058981e-010
	,-3.045322278e-010
	,-2.469655987e-010
	,-2.031100768e-010
	,-1.690010247e-010
	,-1.429201359e-010
	,-1.223299663e-010
	,-1.060541435e-010
	,-9.300513152e-011
	,-8.235156778e-011
	,-7.350443719e-011
	,-6.604208408e-011
	,-5.965965808e-011
	,-5.413430623e-011
	,-4.930065952e-011
	,-4.480171331e-011
	,-4.066797675e-011
	,-3.700865530e-011
	,-3.375110038e-011
	,-3.083736326e-011
	,-2.821774011e-011
	,-2.568189745e-011
	,-2.339392282e-011
	,-2.132472381e-011
	,-1.944890326e-011
	,-1.774398695e-011
	,-1.618953127e-011
	,-1.476705946e-011
	,-1.345864214e-011
	,-1.220140349e-011
	,-1.100585473e-011
	,-9.892050643e-012
	,-8.835139004e-012
	,-7.808447066e-012
	,-6.781498642e-012
	,-5.718591050e-012
	,-4.575266697e-012
	,-3.294585097e-012
	,-1.802294204e-012
	,-1.341977670e-017
	,2.243609414e-012
	,5.105197629e-012
	,8.818581611e-012
	,1.370513196e-011
	,2.020175653e-011
	,2.890129912e-011
	,4.061038653e-011
	,5.642712321e-011
	,7.784790216e-011
	,1.069124985e-010
	,1.462035921e-010
	,1.976849061e-010
	,2.673029232e-010
	,3.615745289e-010
	,4.893711996e-010
	,6.627799877e-010
	,8.982724161e-010
	,1.218294593e-009
	,1.653440582e-009
	,2.245410858e-009
	,3.028723341e-009
	,4.034368740e-009
	,5.374431757e-009
	,7.160093516e-009
	,9.539363058e-009
	,1.270915041e-008
	,1.693122644e-008
	,2.255325808e-008
	,3.003644618e-008
	,3.999170013e-008
	,5.322676058e-008
	,7.080721537e-008
	,9.413490884e-008
	,1.250479787e-007
	,1.659466736e-007
	,2.198707610e-007
	,2.907963691e-007
	,3.839176960e-007
	,5.057489159e-007
	,6.644747443e-007
	,8.702519746e-007
	,1.135503653e-006
	,1.475173825e-006
	,1.906896663e-006
	,2.451032259e-006
	,3.130518921e-006
	,3.970505402e-006
	,4.997752624e-006
	,6.239831359e-006
	,7.724182719e-006
	,9.477143612e-006
	,1.152303749e-005
	,1.388344820e-005
	,1.657673001e-005
	,1.961778275e-005
	,2.301807261e-005
	,2.678585004e-005
	,3.092650209e-005
	,3.544298826e-005
	,4.033629851e-005
	,4.560591405e-005
	,5.125003440e-005
	,5.726606880e-005
	,6.365085009e-005
	,7.040084742e-005
	,7.751232481e-005
	,8.498145457e-005
	,9.280438776e-005
	,1.009774990e-004
	,1.094969946e-004
	,1.183591377e-004
	,1.275603819e-004
	,1.370970072e-004
	,1.469654543e-004
	,1.571615721e-004
	,1.676820706e-004
	,1.781797551e-004
	,1.888602744e-004
	,1.998297625e-004
	,2.110814391e-004
	,2.225970867e-004
	,2.342848649e-004
	,2.462178553e-004
	,2.583891882e-004
	,2.707893058e-004
	,2.834090130e-004
	,2.962466635e-004
	,3.092712586e-004
	,3.224370392e-004
	,3.357956803e-004
	,3.493420565e-004
	,3.630711770e-004
	,3.769777896e-004
	,3.910583290e-004
	,4.053040494e-004
	,4.197147384e-004
	,4.342878104e-004
	,4.489950689e-004
	,4.638552029e-004
	,4.783184893e-004
	,4.923199056e-004
	,5.064578018e-004
	,5.207314003e-004
	,5.351403998e-004
	,5.496833540e-004
	,5.643597508e-004
	,5.790532623e-004
	,5.937814368e-004
	,6.086220505e-004
	,6.235741963e-004
	,6.386370886e-004
	,6.538100567e-004
	,6.690925379e-004
	,6.844840698e-004
	,6.999842806e-004
	,7.155928805e-004
	,7.313096502e-004
	,7.471344322e-004
	,7.630671153e-004
	,7.791076297e-004
	,7.952559230e-004
	,8.115119580e-004
	,8.278757015e-004
	,8.443471138e-004
	,8.609261395e-004
	,8.776127009e-004
	,8.944066920e-004
	,9.113079738e-004
	,9.283163718e-004
	,9.454316741e-004
	,9.626555795e-004
	,9.799861707e-004
	,9.974229252e-004
	,1.014969368e-003
	,1.032625422e-003
	,1.050387630e-003
	,1.068215970e-003
	,1.085651368e-003
	,1.103213869e-003
	,1.120888870e-003
	,1.138670840e-003
	,1.156554962e-003
	,1.174537925e-003
	,1.192617325e-003
	,1.210791340e-003
	,1.229058536e-003
	,1.247417727e-003
	,1.265867946e-003
	,1.284408354e-003
	,1.303038213e-003
	,1.321756856e-003
	,1.340563670e-003
	,1.359458084e-003
	,1.378439558e-003
	,1.397507553e-003
	,1.416661495e-003
	,1.435900985e-003
	,1.455201830e-003
	,1.474510093e-003
	,1.493904792e-003
	,-3.458800337e-010
	,-2.425018965e-010
	,-1.708639045e-010
	,-1.211487820e-010
	,-8.658110332e-011
	,-6.248285556e-011
	,-4.562834074e-011
	,-3.374375589e-011
	,-2.527148107e-011
	,-1.920060868e-011
	,-1.479251217e-011
	,-1.160753519e-011
	,-9.280941950e-012
	,-7.559645935e-012
	,-6.264236655e-012
	,-5.263666531e-012
	,-4.491476708e-012
	,-3.884729178e-012
	,-3.394446501e-012
	,-2.970698340e-012
	,-2.620987142e-012
	,-2.328365511e-012
	,-2.080337652e-012
	,-1.867738651e-012
	,-1.676321847e-012
	,-1.505793054e-012
	,-1.355292005e-012
	,-1.221528391e-012
	,-1.101801791e-012
	,-9.938420974e-013
	,-8.957108821e-013
	,-8.056048006e-013
	,-7.217191509e-013
	,-6.424109969e-013
	,-5.656671888e-013
	,-4.894866909e-013
	,-4.090765105e-013
	,-3.232827701e-013
	,-2.301416122e-013
	,-1.245786499e-013
	,-5.117373959e-018
	,1.522197503e-013
	,3.435067963e-013
	,5.889981412e-013
	,9.091759170e-013
	,1.331663627e-012
	,1.893727156e-012
	,2.645821195e-012
	,3.656520564e-012
	,5.018794315e-012
	,6.858984027e-012
	,9.348774199e-012
	,1.272178598e-011
	,1.729576811e-011
	,2.350348378e-011
	,3.193406915e-011
	,4.339044479e-011
	,5.896695300e-011
	,7.922486254e-011
	,1.064568175e-010
	,1.432680857e-010
	,1.930822533e-010
	,2.605584906e-010
	,3.520402187e-010
	,4.761667552e-010
	,6.447075497e-010
	,8.736998096e-010
	,1.184806312e-009
	,1.576019567e-009
	,2.096861200e-009
	,2.790361102e-009
	,3.713827240e-009
	,4.943565041e-009
	,6.581143343e-009
	,8.761701806e-009
	,1.166495129e-008
	,1.552970914e-008
	,2.067306621e-008
	,2.751558759e-008
	,3.661433311e-008
	,4.870593614e-008
	,6.476251426e-008
	,8.606374895e-008
	,1.142890899e-007
	,1.515693226e-007
	,2.007066545e-007
	,2.654318750e-007
	,3.504566621e-007
	,4.617812843e-007
	,6.069721413e-007
	,7.954603753e-007
	,1.038842758e-006
	,1.351155849e-006
	,1.749083950e-006
	,2.252053206e-006
	,2.882162082e-006
	,3.663906687e-006
	,4.623679845e-006
	,5.789053791e-006
	,7.187902577e-006
	,8.847446545e-006
	,1.079332860e-005
	,1.304882600e-005
	,1.563427827e-005
	,1.856677113e-005
	,2.186007271e-005
	,2.552478520e-005
	,2.956865366e-005
	,3.399700437e-005
	,3.881317677e-005
	,4.401890043e-005
	,4.961479926e-005
	,5.560073757e-005
	,6.196442358e-005
	,6.869941751e-005
	,7.581200547e-005
	,8.329927317e-005
	,9.115840016e-005
	,9.938627390e-005
	,1.079798897e-004
	,1.169361493e-004
	,1.262522009e-004
	,1.359249741e-004
	,1.459514011e-004
	,1.562159072e-004
	,1.664524218e-004
	,1.770065270e-004
	,1.878704807e-004
	,1.990371820e-004
	,2.104988245e-004
	,2.222462287e-004
	,2.342749164e-004
	,2.465781236e-004
	,2.591497267e-004
	,2.719835603e-004
	,2.850736411e-004
	,2.984141748e-004
	,3.119994387e-004
	,3.258239879e-004
	,3.398827802e-004
	,3.541702404e-004
	,3.686804266e-004
	,3.834077973e-004
	,3.983403689e-004
	,4.134824372e-004
	,4.288296616e-004
	,4.434521438e-004
	,4.577261872e-004
	,4.721672900e-004
	,4.867738403e-004
	,5.015445455e-004
	,5.164783013e-004
	,5.315741858e-004
	,5.468314590e-004
	,5.622495623e-004
	,5.778281180e-004
	,5.935640550e-004
	,6.093206113e-004
	,6.252301424e-004
	,6.412928399e-004
	,6.575090803e-004
	,6.738793968e-004
	,6.902510772e-004
	,7.065282369e-004
	,7.229318204e-004
	,7.394616924e-004
	,7.561178759e-004
	,7.729004425e-004
	,7.898095241e-004
	,8.068453053e-004
	,8.240080157e-004
	,8.412979243e-004
	,8.587153350e-004
	,8.762605840e-004
	,8.939348495e-004
	,9.117383786e-004
	,9.296710523e-004
	,9.477333381e-004
	,9.659257386e-004
	,9.842516268e-004
	,1.002711918e-003
	,1.021305081e-003
	,1.039727887e-003
	,1.057867490e-003
	,1.076081127e-003
	,1.094405846e-003
	,1.112833070e-003
	,1.131359611e-003
	,1.149983337e-003
	,1.168702058e-003
	,1.187514073e-003
	,1.206418000e-003
	,1.225412679e-003
	,1.244497110e-003
	,1.263670406e-003
	,1.282931767e-003
	,1.302280442e-003
	,1.321715758e-003
	,1.341237070e-003
	,1.360843756e-003
	,1.380535219e-003
	,-3.866754652e-010
	,-2.668990549e-010
	,-1.843029188e-010
	,-1.273431709e-010
	,-8.805819314e-011
	,-6.095822190e-011
	,-4.225796233e-011
	,-2.934907110e-011
	,-2.043183820e-011
	,-1.426813727e-011
	,-9.995017668e-012
	,-7.031111164e-012
	,-4.974361788e-012
	,-3.544697851e-012
	,-2.548347958e-012
	,-1.846846568e-012
	,-1.352007804e-012
	,-1.003213630e-012
	,-7.557761813e-013
	,-5.790976568e-013
	,-4.518489752e-013
	,-3.575845387e-013
	,-2.869494715e-013
	,-2.339169079e-013
	,-1.938089924e-013
	,-1.630785624e-013
	,-1.386964420e-013
	,-1.189431460e-013
	,-1.028716263e-013
	,-8.952992620e-014
	,-7.832324898e-014
	,-6.864473603e-014
	,-6.014552979e-014
	,-5.254632489e-014
	,-4.551022132e-014
	,-3.880600499e-014
	,-3.215374395e-014
	,-2.531376506e-014
	,-1.797172578e-014
	,-9.655798998e-015
	,-5.169590330e-018
	,1.171850190e-014
	,2.622885660e-014
	,4.427676590e-014
	,6.736392037e-014
	,9.741835723e-014
	,1.369249491e-013
	,1.891755725e-013
	,2.587235993e-013
	,3.517470093e-013
	,4.763696775e-013
	,6.437750448e-013
	,8.690959371e-013
	,1.172661440e-012
	,1.582096416e-012
	,2.134938951e-012
	,2.881987114e-012
	,3.892209904e-012
	,5.259271844e-012
	,7.110485633e-012
	,9.618707556e-012
	,1.301922599e-011
	,1.763184540e-011
	,2.389225919e-011
	,3.206041344e-011
	,4.287257354e-011
	,5.744000616e-011
	,7.709224832e-011
	,1.036354766e-010
	,1.395247777e-010
	,1.880994333e-010
	,2.539027804e-010
	,3.431188594e-010
	,4.641677836e-010
	,6.204041412e-010
	,8.238345121e-010
	,1.094301407e-009
	,1.453968177e-009
	,1.932336213e-009
	,2.568672427e-009
	,3.415235248e-009
	,4.541560066e-009
	,6.040146834e-009
	,8.033999940e-009
	,1.068661142e-008
	,1.421515627e-008
	,1.890789941e-008
	,2.514709943e-008
	,3.343905377e-008
	,4.445336112e-008
	,5.907399381e-008
	,7.846536010e-008
	,1.041037041e-007
	,1.379346047e-007
	,1.826006102e-007
	,2.414492031e-007
	,3.187884021e-007
	,4.201197539e-007
	,5.524046405e-007
	,7.243561815e-007
	,9.467413168e-007
	,1.232668014e-006
	,1.597822030e-006
	,2.060608410e-006
	,2.642148648e-006
	,3.366086579e-006
	,4.258175335e-006
	,5.345642885e-006
	,6.656372837e-006
	,8.217973381e-006
	,1.005683713e-005
	,1.219729608e-005
	,1.466096305e-005
	,1.746631507e-005
	,2.062854054e-005
	,2.415959793e-005
	,2.806843767e-005
	,3.236140046e-005
	,3.704263195e-005
	,4.211451622e-005
	,4.757808557e-005
	,5.343339174e-005
	,5.967983455e-005
	,6.631639078e-005
	,7.334182672e-005
	,8.075496575e-005
	,8.855467472e-005
	,9.673996569e-005
	,1.053100980e-004
	,1.142645948e-004
	,1.236032331e-004
	,1.333262709e-004
	,1.432559018e-004
	,1.532382419e-004
	,1.635725524e-004
	,1.742545642e-004
	,1.852801172e-004
	,1.966455726e-004
	,2.083476211e-004
	,2.202718220e-004
	,2.324485954e-004
	,2.449148979e-004
	,2.576643659e-004
	,2.706907137e-004
	,2.839877579e-004
	,2.975494288e-004
	,3.113689812e-004
	,3.254385469e-004
	,3.397489565e-004
	,3.542996920e-004
	,3.690854986e-004
	,3.841003232e-004
	,3.993396874e-004
	,4.139248928e-004
	,4.280187344e-004
	,4.422870835e-004
	,4.567276159e-004
	,4.713381768e-004
	,4.861167845e-004
	,5.010616149e-004
	,5.161709986e-004
	,5.314434186e-004
	,5.468775068e-004
	,5.624720402e-004
	,5.782259374e-004
	,5.941382536e-004
	,6.102081763e-004
	,6.264350217e-004
	,6.428182238e-004
	,6.593573334e-004
	,6.760520106e-004
	,6.929020187e-004
	,7.099072175e-004
	,7.270675567e-004
	,7.443830705e-004
	,7.618538709e-004
	,7.794804146e-004
	,7.972632516e-004
	,8.152021908e-004
	,8.332976122e-004
	,8.515499558e-004
	,8.699597216e-004
	,8.885274700e-004
	,9.070634576e-004
	,9.257419298e-004
	,9.445753397e-004
	,9.635613760e-004
	,9.827005627e-004
	,1.001993646e-003
	,1.021272165e-003
	,1.040661816e-003
	,1.060213819e-003
	,1.079926159e-003
	,1.099798369e-003
	,1.119827537e-003
	,1.140017918e-003
	,1.160371104e-003
	,1.180774566e-003
	,1.200642039e-003
	,1.220624353e-003
	,1.240719187e-003
	,-4.556647596e-010
	,-3.144923203e-010
	,-2.169992866e-010
	,-1.496989869e-010
	,-1.032563421e-010
	,-7.121590974e-011
	,-4.911599429e-011
	,-3.387507619e-011
	,-2.336553581e-011
	,-1.611900225e-011
	,-1.112271147e-011
	,-7.677955592e-012
	,-5.302807660e-012
	,-3.664002282e-012
	,-2.533763718e-012
	,-1.753976048e-012
	,-1.215898997e-012
	,-8.445637994e-013
	,-5.881000722e-013
	,-4.109237690e-013
	,-2.883907477e-013
	,-2.030194900e-013
	,-1.437230508e-013
	,-1.024687770e-013
	,-7.357824305e-014
	,-5.336178793e-014
	,-3.916039749e-014
	,-2.911125275e-014
	,-2.194847227e-014
	,-1.682688188e-014
	,-1.296903207e-014
	,-1.018804045e-014
	,-8.091814299e-015
	,-6.508875058e-015
	,-5.217877539e-015
	,-4.138617398e-015
	,-3.254803129e-015
	,-2.461166529e-015
	,-1.648262089e-015
	,-8.459053553e-016
	,3.653448327e-019
	,1.011483123e-015
	,2.203635055e-015
	,3.757959725e-015
	,5.655554809e-015
	,8.064974746e-015
	,1.131533931e-014
	,1.559535847e-014
	,2.103865391e-014
	,2.809120563e-014
	,3.732775923e-014
	,4.969917479e-014
	,6.610832554e-014
	,8.800505122e-014
	,1.172339473e-013
	,1.563829092e-013
	,2.088071521e-013
	,2.791914241e-013
	,3.736434739e-013
	,5.006788517e-013
	,6.715686173e-013
	,9.016551933e-013
	,1.211744975e-012
	,1.630019660e-012
	,2.194498770e-012
	,2.957011385e-012
	,3.987543418e-012
	,5.381326615e-012
	,7.267612207e-012
	,9.822110993e-012
	,1.317877676e-011
	,1.753258229e-011
	,2.337607260e-011
	,3.123084086e-011
	,4.180403947e-011
	,5.605497359e-011
	,7.528622759e-011
	,1.012671078e-010
	,1.364023848e-010
	,1.839615383e-010
	,2.469596463e-010
	,3.271760230e-010
	,4.336247460e-010
	,5.749276776e-010
	,7.625497434e-010
	,1.011738582e-009
	,1.342773385e-009
	,1.782626313e-009
	,2.367170039e-009
	,3.144111540e-009
	,4.176886736e-009
	,5.549829022e-009
	,7.375018970e-009
	,9.801354911e-009
	,1.302654408e-008
	,1.731292807e-008
	,2.300832290e-008
	,3.057339056e-008
	,4.061747303e-008
	,5.394532907e-008
	,7.157392907e-008
	,9.484166269e-008
	,1.256079383e-007
	,1.662259489e-007
	,2.197483076e-007
	,2.901114081e-007
	,3.823550317e-007
	,5.028765009e-007
	,6.597139534e-007
	,8.628464274e-007
	,1.124489496e-006
	,1.459354934e-006
	,1.884832734e-006
	,2.421047737e-006
	,3.090742895e-006
	,3.918952838e-006
	,4.932455321e-006
	,6.159022125e-006
	,7.626527091e-006
	,9.362007307e-006
	,1.139077818e-005
	,1.373570134e-005
	,1.641667423e-005
	,1.945036935e-005
	,2.285021167e-005
	,2.662655273e-005
	,3.078696644e-005
	,3.533669698e-005
	,4.027904160e-005
	,4.561577496e-005
	,5.134754067e-005
	,5.747418150e-005
	,6.399511140e-005
	,7.090933699e-005
	,7.821570363e-005
	,8.591309021e-005
	,9.399969783e-005
	,1.024750154e-004
	,1.113383526e-004
	,1.205890843e-004
	,1.300868232e-004
	,1.396126939e-004
	,1.494936461e-004
	,1.597235643e-004
	,1.702965900e-004
	,1.812076831e-004
	,1.924519241e-004
	,2.040246718e-004
	,2.159215452e-004
	,2.281384215e-004
	,2.406714451e-004
	,2.535173327e-004
	,2.666695814e-004
	,2.801262594e-004
	,2.938862047e-004
	,3.079472769e-004
	,3.223077782e-004
	,3.369669479e-004
	,3.519245113e-004
	,3.671805976e-004
	,3.824685521e-004
	,3.962883366e-004
	,4.102950192e-004
	,4.244852207e-004
	,4.388567152e-004
	,4.534073016e-004
	,4.681347009e-004
	,4.830367793e-004
	,4.981115453e-004
	,5.133571469e-004
	,5.287718676e-004
	,5.443541220e-004
	,5.601024516e-004
	,5.760155192e-004
	,5.920921036e-004
	,6.083310937e-004
	,6.247314819e-004
	,6.412926096e-004
	,6.580136588e-004
	,6.748936769e-004
	,6.919320066e-004
	,7.091280602e-004
	,7.264813128e-004
	,7.439912963e-004
	,7.616575927e-004
	,7.794798293e-004
	,7.974576737e-004
	,8.155908298e-004
	,8.338790365e-004
	,8.523220572e-004
	,8.709207265e-004
	,8.896757665e-004
	,9.085855247e-004
	,9.276498739e-004
	,9.468687111e-004
	,9.662131693e-004
	,9.855788212e-004
	,1.005102866e-003
	,1.024782000e-003
	,1.044614399e-003
	,1.064599014e-003
	,-5.284167736e-010
	,-3.661692640e-010
	,-2.534382506e-010
	,-1.752154325e-010
	,-1.210101677e-010
	,-8.349755005e-011
	,-5.756914324e-011
	,-3.966695386e-011
	,-2.731775250e-011
	,-1.880557279e-011
	,-1.294184127e-011
	,-8.904416915e-012
	,-6.125592951e-012
	,-4.213515658e-012
	,-2.898249380e-012
	,-1.993570389e-012
	,-1.371388536e-012
	,-9.435240018e-013
	,-6.492088894e-013
	,-4.468751049e-013
	,-3.077595745e-013
	,-2.120292157e-013
	,-1.461903787e-013
	,-1.008669355e-013
	,-6.968634817e-014
	,-4.821722234e-014
	,-3.339717236e-014
	,-2.313132969e-014
	,-1.603773589e-014
	,-1.116432991e-014
	,-7.779560409e-015
	,-5.430815894e-015
	,-3.818061106e-015
	,-2.667577837e-015
	,-1.822403681e-015
	,-1.272252012e-015
	,-8.830311940e-016
	,-5.689497316e-016
	,-3.512074709e-016
	,-1.626019443e-016
	,6.161361843e-018
	,1.215595384e-016
	,2.437458430e-016
	,4.316203404e-016
	,6.295725971e-016
	,8.400567824e-016
	,1.135079270e-015
	,1.496938710e-015
	,1.971481076e-015
	,2.583613576e-015
	,3.400016513e-015
	,4.476926917e-015
	,5.941230566e-015
	,7.831724223e-015
	,1.031111410e-014
	,1.336070672e-014
	,1.746940397e-014
	,2.286027417e-014
	,3.010686193e-014
	,3.966595604e-014
	,5.241369497e-014
	,6.939283962e-014
	,9.204315194e-014
	,1.223374186e-013
	,1.627547161e-013
	,2.170543099e-013
	,2.897920781e-013
	,3.873888066e-013
	,5.184792032e-013
	,6.947495001e-013
	,9.320063235e-013
	,1.251457300e-012
	,1.682082200e-012
	,2.262876993e-012
	,3.046874295e-012
	,4.106035415e-012
	,5.514148716e-012
	,7.294213524e-012
	,9.673083334e-012
	,1.285769637e-011
	,1.712804260e-011
	,2.286301053e-011
	,3.057598634e-011
	,4.096306075e-011
	,5.496858252e-011
	,7.387450974e-011
	,9.942250150e-011
	,1.315244667e-010
	,1.738655291e-010
	,2.299493919e-010
	,3.042626692e-010
	,4.027660352e-010
	,5.333788394e-010
	,7.066213988e-010
	,9.364728373e-010
	,1.241509691e-009
	,1.646419750e-009
	,2.184012508e-009
	,2.897889380e-009
	,3.845988317e-009
	,5.105285005e-009
	,6.778024544e-009
	,8.999972684e-009
	,1.195132735e-008
	,1.587112876e-008
	,2.107625338e-008
	,2.798638693e-008
	,3.715683083e-008
	,4.928542108e-008
	,6.528537402e-008
	,8.646040987e-008
	,1.144522047e-007
	,1.514029294e-007
	,2.000951535e-007
	,2.641234400e-007
	,3.481005230e-007
	,4.578986262e-007
	,6.009224849e-007
	,7.864045793e-007
	,1.025704888e-006
	,1.332587587e-006
	,1.723436890e-006
	,2.217366090e-006
	,2.836171527e-006
	,3.604089958e-006
	,4.547336868e-006
	,5.693434026e-006
	,7.070371401e-006
	,8.705683458e-006
	,1.062554219e-005
	,1.285396769e-005
	,1.541222146e-005
	,1.831846018e-005
	,2.158761933e-005
	,2.523151162e-005
	,2.925908502e-005
	,3.367678763e-005
	,3.848883463e-005
	,4.369798852e-005
	,4.930563305e-005
	,5.531222573e-005
	,6.171757804e-005
	,6.852109972e-005
	,7.572198636e-005
	,8.331935913e-005
	,9.131236227e-005
	,9.970018312e-005
	,1.084821872e-004
	,1.175567202e-004
	,1.266344866e-004
	,1.360744450e-004
	,1.458703691e-004
	,1.560161593e-004
	,1.665058914e-004
	,1.773340213e-004
	,1.884952079e-004
	,1.999828136e-004
	,2.117910850e-004
	,2.239167145e-004
	,2.363549734e-004
	,2.491013089e-004
	,2.621513593e-004
	,2.755009727e-004
	,2.891462281e-004
	,3.030834541e-004
	,3.173089704e-004
	,3.318199363e-004
	,3.466135974e-004
	,3.616875531e-004
	,3.756205042e-004
	,3.894960101e-004
	,4.035808247e-004
	,4.178733931e-004
	,4.323723368e-004
	,4.470778659e-004
	,4.619898383e-004
	,4.771086276e-004
	,4.924345251e-004
	,5.079684386e-004
	,5.237117058e-004
	,5.396661463e-004
	,5.557284978e-004
	,5.717332463e-004
	,5.879079922e-004
	,6.042515908e-004
	,6.207629508e-004
	,6.374410731e-004
	,6.542850331e-004
	,6.712939732e-004
	,6.884670965e-004
	,7.058036593e-004
	,7.233029655e-004
	,7.409643601e-004
	,7.587872241e-004
	,7.767709696e-004
	,7.949150355e-004
	,8.132207401e-004
	,8.316863540e-004
	,8.503110895e-004
	,8.690944647e-004
	,8.880360104e-004
	,-5.799497228e-010
	,-4.033347903e-010
	,-2.801922483e-010
	,-1.944573152e-010
	,-1.348384601e-010
	,-9.342287156e-011
	,-6.467845354e-011
	,-4.474504033e-011
	,-3.093273197e-011
	,-2.136921690e-011
	,-1.475267129e-011
	,-1.017842949e-011
	,-7.018548689e-012
	,-4.837143696e-012
	,-3.332359097e-012
	,-2.294818582e-012
	,-1.579842131e-012
	,-1.087330338e-012
	,-7.482286706e-013
	,-5.147668285e-013
	,-3.541566907e-013
	,-2.436373506e-013
	,-1.675605023e-013
	,-1.152323897e-013
	,-7.921181494e-014
	,-5.449336887e-014
	,-3.743663070e-014
	,-2.575896183e-014
	,-1.765242269e-014
	,-1.209388572e-014
	,-8.307833419e-015
	,-5.654824119e-015
	,-3.827303404e-015
	,-2.610035398e-015
	,-1.723192579e-015
	,-1.125993961e-015
	,-7.406371545e-016
	,-4.009174546e-016
	,-2.361225925e-016
	,-1.013521429e-016
	,-1.362864219e-017
	,7.237171834e-017
	,1.482943196e-016
	,1.674577272e-016
	,1.784231647e-016
	,2.264622247e-016
	,2.821770909e-016
	,3.324092383e-016
	,3.725114101e-016
	,4.474941167e-016
	,5.263930510e-016
	,6.100958912e-016
	,7.536909073e-016
	,9.298167216e-016
	,1.157480092e-015
	,1.461170497e-015
	,1.829295902e-015
	,2.343418276e-015
	,3.064421906e-015
	,3.937427387e-015
	,5.077206300e-015
	,6.476030622e-015
	,8.347308655e-015
	,1.079844947e-014
	,1.404186926e-014
	,1.832126182e-014
	,2.397629464e-014
	,3.152605063e-014
	,4.149436443e-014
	,5.482379372e-014
	,7.254602952e-014
	,9.617795737e-014
	,1.277754402e-013
	,1.700086142e-013
	,2.264961783e-013
	,3.021817694e-013
	,4.037264732e-013
	,5.400329717e-013
	,7.232251228e-013
	,9.696901986e-013
	,1.301445179e-012
	,1.748252455e-012
	,2.350837034e-012
	,3.092918376e-012
	,4.077499848e-012
	,5.389715802e-012
	,7.141822973e-012
	,9.485446212e-012
	,1.262552140e-011
	,1.683926075e-011
	,2.250215401e-011
	,3.012281310e-011
	,4.039011815e-011
	,5.363026846e-011
	,7.068206775e-011
	,9.321160094e-011
	,1.229920109e-010
	,1.623739688e-010
	,2.144762934e-010
	,2.834356237e-010
	,3.747404720e-010
	,4.956748176e-010
	,6.559076060e-010
	,8.682752235e-010
	,1.149821423e-009
	,1.523178453e-009
	,2.018400213e-009
	,2.675399171e-009
	,3.547174632e-009
	,4.704098100e-009
	,6.239591834e-009
	,8.277649613e-009
	,1.098278758e-008
	,1.457319673e-008
	,1.933807546e-008
	,2.566053558e-008
	,3.401833949e-008
	,4.502981768e-008
	,5.960846476e-008
	,7.889386272e-008
	,1.043793160e-007
	,1.380149172e-007
	,1.823366307e-007
	,2.406255694e-007
	,3.171008737e-007
	,4.171477763e-007
	,5.475791123e-007
	,7.169232893e-007
	,9.357243428e-007
	,1.216830385e-006
	,1.575636450e-006
	,2.030238641e-006
	,2.601452318e-006
	,3.312648133e-006
	,4.189377380e-006
	,5.258781239e-006
	,6.548815269e-006
	,8.087356576e-006
	,9.901287831e-006
	,1.201565857e-005
	,1.445301345e-005
	,1.723294501e-005
	,2.037188782e-005
	,2.388313612e-005
	,2.777704046e-005
	,3.206132962e-005
	,3.674150573e-005
	,4.182124867e-005
	,4.730280731e-005
	,5.318740371e-005
	,5.947551665e-005
	,6.616706399e-005
	,7.326171224e-005
	,8.075899566e-005
	,8.865842607e-005
	,9.695930987e-005
	,1.056091356e-004
	,1.142278240e-004
	,1.232177744e-004
	,1.325720926e-004
	,1.422831075e-004
	,1.523453144e-004
	,1.627531795e-004
	,1.735010217e-004
	,1.845832712e-004
	,1.959944771e-004
	,2.077292989e-004
	,2.197825068e-004
	,2.321489871e-004
	,2.448237533e-004
	,2.578019604e-004
	,2.710791275e-004
	,2.846505493e-004
	,2.985119008e-004
	,3.126588494e-004
	,3.270876096e-004
	,3.417946077e-004
	,3.556682264e-004
	,3.692166370e-004
	,3.829711074e-004
	,3.969299853e-004
	,4.110915342e-004
	,4.254536337e-004
	,4.400151344e-004
	,4.547752240e-004
	,4.697329847e-004
	,4.848877091e-004
	,5.002389022e-004
	,5.157862846e-004
	,5.315297956e-004
	,5.474695981e-004
	,5.636060853e-004
	,5.799398886e-004
	,5.964718895e-004
	,6.132032344e-004
	,6.301353548e-004
	,6.472699934e-004
	,6.646092391e-004
	,6.821555736e-004
	,6.999119251e-004
	,7.178817523e-004
	,-6.120803595e-010
	,-4.267250072e-010
	,-2.973300440e-010
	,-2.070721338e-010
	,-1.441508406e-010
	,-1.003077792e-010
	,-6.977069869e-011
	,-4.850947542e-011
	,-3.371203006e-011
	,-2.341726975e-011
	,-1.625793717e-011
	,-1.128129566e-011
	,-7.823511228e-012
	,-5.422221119e-012
	,-3.755572458e-012
	,-2.599470238e-012
	,-1.798001444e-012
	,-1.242830842e-012
	,-8.584993041e-013
	,-5.926500500e-013
	,-4.088345921e-013
	,-2.818815595e-013
	,-1.942204052e-013
	,-1.337532227e-013
	,-9.205986152e-014
	,-6.335297250e-014
	,-4.355262963e-014
	,-2.991146861e-014
	,-2.056291090e-014
	,-1.405043309e-014
	,-9.596637851e-015
	,-6.557018551e-015
	,-4.394582042e-015
	,-3.006775374e-015
	,-1.978165111e-015
	,-1.287081461e-015
	,-8.352009996e-016
	,-4.813828800e-016
	,-2.757026006e-016
	,-1.073570254e-016
	,-7.780408810e-018
	,7.999530828e-017
	,1.337259525e-016
	,1.394697531e-016
	,1.956023503e-016
	,2.336158673e-016
	,2.482364507e-016
	,2.133559159e-016
	,2.558600407e-016
	,2.682353202e-016
	,3.064054863e-016
	,2.829603364e-016
	,3.474475527e-016
	,3.593006686e-016
	,3.429569450e-016
	,4.007604660e-016
	,4.211770664e-016
	,4.844110899e-016
	,5.831000282e-016
	,6.275883750e-016
	,7.385481601e-016
	,8.948839704e-016
	,1.087092426e-015
	,1.341020631e-015
	,1.686170833e-015
	,2.154186153e-015
	,2.654523405e-015
	,3.331717501e-015
	,4.216106151e-015
	,5.321422260e-015
	,6.810998632e-015
	,8.772036605e-015
	,1.137611917e-014
	,1.476266403e-014
	,1.928360951e-014
	,2.523251605e-014
	,3.314402706e-014
	,4.368421454e-014
	,5.770524964e-014
	,7.637359384e-014
	,1.012346950e-013
	,1.343645716e-013
	,1.787049894e-013
	,2.379425808e-013
	,3.173965229e-013
	,4.239150970e-013
	,5.669115046e-013
	,7.590786053e-013
	,1.017519662e-012
	,1.338878833e-012
	,1.754119434e-012
	,2.304509940e-012
	,3.035940605e-012
	,4.010030450e-012
	,5.309680326e-012
	,7.046937998e-012
	,9.373036274e-012
	,1.249253806e-011
	,1.668233908e-011
	,2.222300932e-011
	,2.918821627e-011
	,3.836451657e-011
	,5.046082433e-011
	,6.641484003e-011
	,8.746766459e-011
	,1.152624160e-010
	,1.519753638e-010
	,2.004896996e-010
	,2.646262324e-010
	,3.494498155e-010
	,4.616758457e-010
	,6.102101469e-010
	,8.068619203e-010
	,1.067282280e-009
	,1.412274021e-009
	,1.869423035e-009
	,2.475336424e-009
	,3.278593247e-009
	,4.343643900e-009
	,5.756030525e-009
	,7.629236433e-009
	,1.011379327e-008
	,1.340933244e-008
	,1.778052940e-008
	,2.355412556e-008
	,3.114537565e-008
	,4.119558629e-008
	,5.449353360e-008
	,7.207587306e-008
	,9.530150787e-008
	,1.259461372e-007
	,1.663211408e-007
	,2.194210793e-007
	,2.891035642e-007
	,3.803038953e-007
	,4.992841459e-007
	,6.539119085e-007
	,8.539573406e-007
	,1.111388187e-006
	,1.440633215e-006
	,1.858776689e-006
	,2.385630516e-006
	,3.043645117e-006
	,3.857618631e-006
	,4.854191169e-006
	,6.061139951e-006
	,7.506530258e-006
	,9.217807477e-006
	,1.122092749e-005
	,1.353962103e-005
	,1.619486141e-005
	,1.920456779e-005
	,2.258353850e-005
	,2.634357986e-005
	,3.049377530e-005
	,3.504086700e-005
	,3.998966175e-005
	,4.534335244e-005
	,5.110396951e-005
	,5.727268954e-005
	,6.384997774e-005
	,7.083610678e-005
	,7.823109404e-005
	,8.603403650e-005
	,9.424535929e-005
	,1.023967528e-004
	,1.109193975e-004
	,1.198152767e-004
	,1.290778260e-004
	,1.387008191e-004
	,1.486782870e-004
	,1.590043645e-004
	,1.696732978e-004
	,1.806794229e-004
	,1.920171542e-004
	,2.036809819e-004
	,2.156654758e-004
	,2.279652941e-004
	,2.405751953e-004
	,2.534900535e-004
	,2.667048739e-004
	,2.802148103e-004
	,2.940151815e-004
	,3.081013489e-004
	,3.224689638e-004
	,3.362587482e-004
	,3.495035959e-004
	,3.629561172e-004
	,3.766131432e-004
	,3.904732128e-004
	,4.045342800e-004
	,4.187943882e-004
	,4.332510780e-004
	,4.479036005e-004
	,4.627506191e-004
	,4.777909699e-004
	,4.930236605e-004
	,5.084478672e-004
	,5.240629314e-004
	,5.398683560e-004
	,5.558638021e-004
	,-6.349692598e-010
	,-4.434526443e-010
	,-3.096085599e-010
	,-2.161099271e-010
	,-1.508154598e-010
	,-1.052278792e-010
	,-7.340541229e-011
	,-5.119554729e-011
	,-3.569740576e-011
	,-2.488455887e-011
	,-1.734203004e-011
	,-1.208175642e-011
	,-8.414100977e-012
	,-5.857584707e-012
	,-4.076215743e-012
	,-2.835403533e-012
	,-1.971399005e-012
	,-1.369958434e-012
	,-9.515313298e-013
	,-6.605285106e-013
	,-4.582333662e-013
	,-3.176906580e-013
	,-2.200905355e-013
	,-1.523688284e-013
	,-1.054163911e-013
	,-7.280967031e-014
	,-5.025663709e-014
	,-3.465992082e-014
	,-2.387008688e-014
	,-1.640742779e-014
	,-1.122359549e-014
	,-7.655807614e-015
	,-5.196103313e-015
	,-3.520114502e-015
	,-2.338458061e-015
	,-1.517564516e-015
	,-9.743576242e-016
	,-6.295729366e-016
	,-2.756503842e-016
	,-1.074092418e-016
	,-8.929168940e-018
	,6.735894687e-017
	,1.553435294e-016
	,1.788931121e-016
	,2.427537319e-016
	,2.361222530e-016
	,2.593063211e-016
	,3.241068356e-016
	,2.779997813e-016
	,2.930380957e-016
	,2.859366695e-016
	,3.130891816e-016
	,3.109483105e-016
	,2.994084928e-016
	,3.546011954e-016
	,3.478652837e-016
	,3.490140438e-016
	,3.671853404e-016
	,3.601883469e-016
	,3.928757942e-016
	,4.024313898e-016
	,4.522980226e-016
	,4.438911872e-016
	,4.526113209e-016
	,4.904681887e-016
	,5.670696028e-016
	,6.189204576e-016
	,6.920755913e-016
	,8.164027670e-016
	,9.317487272e-016
	,1.116072511e-015
	,1.332091632e-015
	,1.551452600e-015
	,1.886942774e-015
	,2.335846903e-015
	,2.872422315e-015
	,3.572852695e-015
	,4.514366054e-015
	,5.697693419e-015
	,7.277760759e-015
	,9.356337779e-015
	,1.207701949e-014
	,1.567702487e-014
	,2.043910555e-014
	,2.678224568e-014
	,3.513984113e-014
	,4.629122122e-014
	,6.103686288e-014
	,8.080932221e-014
	,1.070695088e-013
	,1.421755661e-013
	,1.891536938e-013
	,2.519999585e-013
	,3.362652213e-013
	,4.493360098e-013
	,5.922300734e-013
	,7.706709526e-013
	,1.005889876e-012
	,1.317002576e-012
	,1.729350599e-012
	,2.277100054e-012
	,3.006299721e-012
	,3.978930955e-012
	,5.278640357e-012
	,7.018435327e-012
	,9.350955694e-012
	,1.226998223e-011
	,1.606796639e-011
	,2.105715648e-011
	,2.761750631e-011
	,3.624904006e-011
	,4.761241955e-011
	,6.258036927e-011
	,8.230687396e-011
	,1.083180994e-010
	,1.426331178e-010
	,1.879241335e-010
	,2.477287444e-010
	,3.267315768e-010
	,4.311247254e-010
	,5.691335300e-010
	,7.516524329e-010
	,9.931201273e-010
	,1.312678739e-009
	,1.735710015e-009
	,2.295873027e-009
	,3.037807855e-009
	,4.020722006e-009
	,5.323147292e-009
	,7.049249116e-009
	,9.337196090e-009
	,1.237026942e-008
	,1.637202630e-008
	,2.161842645e-008
	,2.856169233e-008
	,3.774717878e-008
	,4.989296892e-008
	,6.594281502e-008
	,8.713410648e-008
	,1.150844718e-007
	,1.519011234e-007
	,2.003173751e-007
	,2.638596979e-007
	,3.470490462e-007
	,4.556369384e-007
	,5.968734610e-007
	,7.797985505e-007
	,1.015540051e-006
	,1.317592475e-006
	,1.702040408e-006
	,2.187682390e-006
	,2.796008869e-006
	,3.550991108e-006
	,4.478660710e-006
	,5.606482142e-006
	,6.962559118e-006
	,8.574747919e-006
	,1.046977263e-005
	,1.267243826e-005
	,1.520502176e-005
	,1.808689866e-005
	,2.133437792e-005
	,2.496074629e-005
	,2.897649284e-005
	,3.338948342e-005
	,3.820573509e-005
	,4.342947032e-005
	,4.906358495e-005
	,5.511001115e-005
	,6.156999436e-005
	,6.844432850e-005
	,7.573354844e-005
	,8.343808089e-005
	,9.117022055e-005
	,9.920982334e-005
	,1.076318602e-004
	,1.164298523e-004
	,1.255975644e-004
	,1.351288676e-004
	,1.450179144e-004
	,1.552588643e-004
	,1.658459390e-004
	,1.767734108e-004
	,1.880355985e-004
	,1.996268708e-004
	,2.115416533e-004
	,2.237744408e-004
	,2.363198110e-004
	,2.491724418e-004
	,2.623271277e-004
	,2.757787980e-004
	,2.895225335e-004
	,3.035535209e-004
	,3.172644951e-004
	,3.302091895e-004
	,3.433645410e-004
	,3.567280136e-004
	,3.702963047e-004
	,3.840672710e-004
	,3.980389750e-004
	,4.122093550e-004
	,-6.530136950e-010
	,-4.566390468e-010
	,-3.192661075e-010
	,-2.231923503e-010
	,-1.560130076e-010
	,-1.090434888e-010
	,-7.620704817e-011
	,-5.325278405e-011
	,-3.720805713e-011
	,-2.599365805e-011
	,-1.815608940e-011
	,-1.267931517e-011
	,-8.852874398e-012
	,-6.179955205e-012
	,-4.313030973e-012
	,-3.009342317e-012
	,-2.099197787e-012
	,-1.463834851e-012
	,-1.020516621e-012
	,-7.112110764e-013
	,-4.954474506e-013
	,-3.450522445e-013
	,-2.401745699e-013
	,-1.670766654e-013
	,-1.161671150e-013
	,-8.067376885e-014
	,-5.599291857e-014
	,-3.880751927e-014
	,-2.689247478e-014
	,-1.859153409e-014
	,-1.275870454e-014
	,-8.779764967e-015
	,-5.991149755e-015
	,-4.040816138e-015
	,-2.710551909e-015
	,-1.790447263e-015
	,-1.145783965e-015
	,-6.489974260e-016
	,-3.897431516e-016
	,-1.379036016e-016
	,8.041151140e-018
	,1.177999598e-016
	,1.789453284e-016
	,2.286553122e-016
	,2.884952716e-016
	,3.138202108e-016
	,2.951267505e-016
	,3.279186306e-016
	,3.454111143e-016
	,3.176842221e-016
	,3.734513047e-016
	,3.832679822e-016
	,4.065564830e-016
	,3.902127593e-016
	,3.849389060e-016
	,4.029535535e-016
	,4.013870624e-016
	,4.023269571e-016
	,4.196627917e-016
	,4.347533225e-016
	,4.376252228e-016
	,4.480684967e-016
	,4.698427228e-016
	,4.602349108e-016
	,4.705215356e-016
	,4.536034319e-016
	,4.924001944e-016
	,4.763175526e-016
	,5.192916247e-016
	,5.086917017e-016
	,5.294216003e-016
	,5.965718515e-016
	,6.474305954e-016
	,6.759407331e-016
	,7.431954170e-016
	,7.744208059e-016
	,8.848062110e-016
	,1.016548111e-015
	,1.133408346e-015
	,1.312719359e-015
	,1.521793702e-015
	,1.831123475e-015
	,2.126093746e-015
	,2.542780375e-015
	,3.120345638e-015
	,3.875812071e-015
	,4.856644355e-015
	,6.130201607e-015
	,7.805511605e-015
	,1.004825689e-014
	,1.292856405e-014
	,1.681048560e-014
	,2.190617667e-014
	,2.863754551e-014
	,3.754816453e-014
	,4.947213801e-014
	,6.528320247e-014
	,8.639036443e-014
	,1.145568662e-013
	,1.521510858e-013
	,2.024010912e-013
	,2.672672939e-013
	,3.454093519e-013
	,4.479363501e-013
	,5.828299259e-013
	,7.607651418e-013
	,9.960832758e-013
	,1.308061202e-012
	,1.722543360e-012
	,2.274375456e-012
	,3.010472279e-012
	,3.994332800e-012
	,5.256741386e-012
	,6.853997781e-012
	,8.946101974e-012
	,1.168812964e-011
	,1.528455339e-011
	,2.000464600e-011
	,2.620347674e-011
	,3.434934390e-011
	,4.505999208e-011
	,5.915106996e-011
	,7.769957994e-011
	,1.021268427e-010
	,1.343001479e-010
	,1.767043470e-010
	,2.326274565e-010
	,3.064130988e-010
	,4.038093134e-010
	,5.324248610e-010
	,7.023344298e-010
	,9.268809175e-010
	,1.223740312e-009
	,1.616333874e-009
	,2.135701753e-009
	,2.822989832e-009
	,3.732750472e-009
	,4.937326164e-009
	,6.532603372e-009
	,8.645900960e-009
	,1.143038436e-008
	,1.506730820e-008
	,1.987755329e-008
	,2.623815973e-008
	,3.464623450e-008
	,4.575621621e-008
	,6.042812801e-008
	,7.978968936e-008
	,1.053156786e-007
	,1.389284186e-007
	,1.831235655e-007
	,2.411253311e-007
	,3.170745968e-007
	,4.162507242e-007
	,5.453282159e-007
	,7.126627745e-007
	,9.285847512e-007
	,1.205688940e-006
	,1.559082692e-006
	,2.006551796e-006
	,2.568598297e-006
	,3.268306825e-006
	,4.131006773e-006
	,5.183725841e-006
	,6.454460125e-006
	,7.971323333e-006
	,9.761661251e-006
	,1.185122569e-005
	,1.426349938e-005
	,1.701922668e-005
	,2.013617308e-005
	,2.362910234e-005
	,2.750997613e-005
	,3.178812105e-005
	,3.647069017e-005
	,4.156301508e-005
	,4.706898288e-005
	,5.299140275e-005
	,5.933235927e-005
	,6.609353696e-005
	,7.327599164e-005
	,8.058307412e-005
	,8.812310492e-005
	,9.605442112e-005
	,1.043707209e-004
	,1.130659143e-004
	,1.221340228e-004
	,1.315690516e-004
	,1.413651944e-004
	,1.515166479e-004
	,1.620177727e-004
	,1.728631165e-004
	,1.840465443e-004
	,1.955623250e-004
	,2.074047666e-004
	,2.195682305e-004
	,2.320471488e-004
	,2.448360416e-004
	,2.579295368e-004
	,2.713223877e-004
	,2.850094919e-004
	,-6.680540035e-010
	,-4.676287021e-010
	,-3.273051617e-010
	,-2.290755312e-010
	,-1.603185503e-010
	,-1.121937011e-010
	,-7.851108879e-011
	,-5.493721354e-011
	,-3.843869331e-011
	,-2.689213003e-011
	,-1.881190376e-011
	,-1.315811349e-011
	,-9.202420436e-012
	,-6.435134671e-012
	,-4.499341381e-012
	,-3.145447417e-012
	,-2.198580994e-012
	,-1.536577475e-012
	,-1.073728756e-012
	,-7.501533138e-013
	,-5.239790493e-013
	,-3.659027630e-013
	,-2.554808587e-013
	,-1.782855357e-013
	,-1.243592368e-013
	,-8.667964345e-014
	,-6.042065784e-014
	,-4.201825161e-014
	,-2.922571103e-014
	,-2.022867392e-014
	,-1.403941543e-014
	,-9.627288860e-015
	,-6.594979851e-015
	,-4.536714999e-015
	,-3.062229158e-015
	,-2.007667360e-015
	,-1.285776052e-015
	,-7.896161090e-016
	,-4.200808622e-016
	,-1.633329735e-016
	,-3.258318432e-017
	,1.052680311e-016
	,2.227548624e-016
	,2.742402027e-016
	,3.113660414e-016
	,3.169531930e-016
	,3.615981889e-016
	,4.156421313e-016
	,4.200805227e-016
	,4.036323663e-016
	,4.540211629e-016
	,4.699993719e-016
	,4.510448298e-016
	,4.543866774e-016
	,4.767352836e-016
	,4.817480550e-016
	,4.577285251e-016
	,4.665008751e-016
	,5.130256604e-016
	,4.985617260e-016
	,5.021124391e-016
	,5.283772730e-016
	,5.170985372e-016
	,5.213802795e-016
	,5.082217543e-016
	,5.489505225e-016
	,5.394993597e-016
	,5.369929739e-016
	,5.447732130e-016
	,5.645110006e-016
	,5.678006319e-016
	,6.111402186e-016
	,5.922901092e-016
	,6.032033304e-016
	,6.259174511e-016
	,6.120801132e-016
	,6.301991934e-016
	,6.488926537e-016
	,6.810579373e-016
	,7.287314826e-016
	,7.154685248e-016
	,7.170872322e-016
	,8.327987070e-016
	,8.803156032e-016
	,9.643317417e-016
	,1.049339991e-015
	,1.167035688e-015
	,1.255072487e-015
	,1.476939841e-015
	,1.683403366e-015
	,1.960254557e-015
	,2.292820614e-015
	,2.787361849e-015
	,3.380539807e-015
	,4.212033274e-015
	,5.250982378e-015
	,6.628867936e-015
	,8.437120811e-015
	,1.077338561e-014
	,1.397158603e-014
	,1.816194968e-014
	,2.375118987e-014
	,3.099887417e-014
	,4.073278868e-014
	,5.366004749e-014
	,7.079364816e-014
	,9.361585677e-014
	,1.240134596e-013
	,1.589995237e-013
	,2.046052486e-013
	,2.642840683e-013
	,3.424228367e-013
	,4.453462093e-013
	,5.811176989e-013
	,7.609352627e-013
	,9.996496539e-013
	,1.317415399e-012
	,1.741759923e-012
	,2.299040850e-012
	,2.982779119e-012
	,3.875344852e-012
	,5.041262758e-012
	,6.565403912e-012
	,8.559285876e-012
	,1.116934747e-011
	,1.458846266e-011
	,1.907025354e-011
	,2.494872908e-011
	,3.266390904e-011
	,4.278665996e-011
	,5.608349203e-011
	,7.356267755e-011
	,9.655248953e-011
	,1.268065058e-010
	,1.666402973e-010
	,2.191134736e-010
	,2.882696420e-010
	,3.794549565e-010
	,4.997400374e-010
	,6.584795319e-010
	,8.680535714e-010
	,1.144754220e-009
	,1.510300069e-009
	,1.993432608e-009
	,2.632214132e-009
	,3.477101775e-009
	,4.595016765e-009
	,6.074773181e-009
	,8.021565207e-009
	,1.055215514e-008
	,1.389623046e-008
	,1.831479712e-008
	,2.415219643e-008
	,3.186220250e-008
	,4.204199745e-008
	,5.547620505e-008
	,7.319364800e-008
	,9.653970192e-008
	,1.272688597e-007
	,1.676611444e-007
	,2.206650678e-007
	,2.900732383e-007
	,3.807318024e-007
	,4.987840022e-007
	,6.519436534e-007
	,8.497881685e-007
	,1.104052445e-006
	,1.428895182e-006
	,1.841100042e-006
	,2.360166699e-006
	,3.008246601e-006
	,3.809886963e-006
	,4.791566830e-006
	,5.981031429e-006
	,7.406504884e-006
	,9.095811393e-006
	,1.107552152e-005
	,1.337022491e-005
	,1.600198445e-005
	,1.899001130e-005
	,2.235056075e-005
	,2.609711196e-005
	,3.024037177e-005
	,3.478880111e-005
	,3.974892648e-005
	,4.512571940e-005
	,5.092295849e-005
	,5.714356114e-005
	,6.378984398e-005
	,7.066532647e-005
	,7.769001603e-005
	,8.511436604e-005
	,9.293231168e-005
	,1.011380008e-004
	,1.097256792e-004
	,1.186901433e-004
	,1.280252770e-004
	,1.377251337e-004
	,1.477839626e-004
	,1.581959376e-004
	,1.689552261e-004
	,-6.809873921e-010
	,-4.770810851e-010
	,-3.342163542e-010
	,-2.341288372e-010
	,-1.640122796e-010
	,-1.148923086e-010
	,-8.048141679e-011
	,-5.637461286e-011
	,-3.948620000e-011
	,-2.765499845e-011
	,-1.936735315e-011
	,-1.356235998e-011
	,-9.496508563e-012
	,-6.648937363e-012
	,-4.654949974e-012
	,-3.258638460e-012
	,-2.281032416e-012
	,-1.596603482e-012
	,-1.117409368e-012
	,-7.819559547e-013
	,-5.471553371e-013
	,-3.827696947e-013
	,-2.677410534e-013
	,-1.872389721e-013
	,-1.309408490e-013
	,-9.146522150e-014
	,-6.387111553e-014
	,-4.454620270e-014
	,-3.101819456e-014
	,-2.158619510e-014
	,-1.500536605e-014
	,-1.035215650e-014
	,-7.146854660e-015
	,-4.849752134e-015
	,-3.310779077e-015
	,-2.161183486e-015
	,-1.396370322e-015
	,-8.162464575e-016
	,-4.555357771e-016
	,-1.988401047e-016
	,-1.033901092e-017
	,1.368067183e-016
	,2.315794289e-016
	,3.292762562e-016
	,3.499017221e-016
	,3.988284603e-016
	,4.379907374e-016
	,4.508359643e-016
	,4.796071839e-016
	,4.998149189e-016
	,4.885361831e-016
	,5.030523338e-016
	,5.178295664e-016
	,5.283772730e-016
	,5.217980104e-016
	,5.252965072e-016
	,5.460264059e-016
	,5.561041652e-016
	,5.632578078e-016
	,5.705158831e-016
	,5.710902632e-016
	,5.686883102e-016
	,6.173017502e-016
	,6.182416448e-016
	,5.821079172e-016
	,6.173539666e-016
	,6.217401416e-016
	,6.274317259e-016
	,6.345331521e-016
	,6.395981400e-016
	,6.422611748e-016
	,6.803791245e-016
	,6.441931805e-016
	,6.578216529e-016
	,6.904568838e-016
	,6.585004657e-016
	,6.492581683e-016
	,6.656541083e-016
	,6.715545581e-016
	,6.823111302e-016
	,7.330654413e-016
	,7.304546228e-016
	,7.296713773e-016
	,7.688336544e-016
	,7.644996957e-016
	,7.622543918e-016
	,8.111289137e-016
	,8.385425076e-016
	,8.687757856e-016
	,9.424008665e-016
	,9.433929776e-016
	,9.877246752e-016
	,1.021665315e-015
	,1.098841109e-015
	,1.213090526e-015
	,1.307758804e-015
	,1.490411664e-015
	,1.647008556e-015
	,1.896968317e-015
	,2.212459621e-015
	,2.602411469e-015
	,3.105307323e-015
	,3.756549883e-015
	,4.635769113e-015
	,5.770221956e-015
	,7.273687882e-015
	,9.217912184e-015
	,1.173129491e-014
	,1.519277026e-014
	,1.969282920e-014
	,2.571551747e-014
	,3.371235002e-014
	,4.436438497e-014
	,5.861872280e-014
	,7.539563345e-014
	,9.658247759e-014
	,1.235667486e-013
	,1.587265887e-013
	,2.046493714e-013
	,2.647856065e-013
	,3.438375348e-013
	,4.480483542e-013
	,5.859459377e-013
	,7.690996576e-013
	,1.013131503e-012
	,1.316769900e-012
	,1.705638101e-012
	,2.211887970e-012
	,2.871559087e-012
	,3.731784194e-012
	,4.854382199e-012
	,6.320023684e-012
	,8.226212798e-012
	,1.071720604e-011
	,1.397541695e-011
	,1.824004047e-011
	,2.382563424e-011
	,3.114605056e-011
	,4.074603307e-011
	,5.334309519e-011
	,6.988238621e-011
	,9.161006839e-011
	,1.201693018e-010
	,1.577280610e-010
	,2.071473178e-010
	,2.721924065e-010
	,3.578203901e-010
	,4.706431479e-010
	,6.193681094e-010
	,8.155105852e-010
	,1.074306577e-009
	,1.415923452e-009
	,1.867070192e-009
	,2.463139761e-009
	,3.251067093e-009
	,4.293152062e-009
	,5.661981883e-009
	,7.430707438e-009
	,9.764999529e-009
	,1.284618249e-008
	,1.691318388e-008
	,2.228098261e-008
	,2.936440437e-008
	,3.870913592e-008
	,5.103192516e-008
	,6.727245785e-008
	,8.865988837e-008
	,1.167975094e-007
	,1.537694757e-007
	,2.022737209e-007
	,2.657850183e-007
	,3.487512350e-007
	,4.568238549e-007
	,5.971203398e-007
	,7.785104836e-007
	,1.011911472e-006
	,1.310566067e-006
	,1.690271952e-006
	,2.169524241e-006
	,2.769508998e-006
	,3.513925993e-006
	,4.428608481e-006
	,5.540941599e-006
	,6.879115485e-006
	,8.471280386e-006
	,1.034469783e-005
	,1.252495206e-005
	,1.503534872e-005
	,1.789650597e-005
	,2.112616871e-005
	,2.473922457e-005
	,2.874793971e-005
	,3.316213396e-005
	,3.798960315e-005
	,4.323649473e-005
	,4.890765652e-005
	,5.500699485e-005
	,6.144578764e-005
	,6.794173783e-005
	,7.484481973e-005
	,8.214939058e-005
	,-6.923351018e-010
	,-4.853714415e-010
	,-3.402760153e-010
	,-2.385572466e-010
	,-1.672472537e-010
	,-1.172541292e-010
	,-8.220446231e-011
	,-5.763030491e-011
	,-4.040039109e-011
	,-2.832035118e-011
	,-1.985138782e-011
	,-1.391417367e-011
	,-9.752112391e-012
	,-6.834733805e-012
	,-4.789904016e-012
	,-3.356715893e-012
	,-2.352246459e-012
	,-1.648315650e-012
	,-1.154962807e-012
	,-8.092449082e-013
	,-5.669248201e-013
	,-3.971472109e-013
	,-2.781662082e-013
	,-1.947645519e-013
	,-1.363751633e-013
	,-9.542160360e-014
	,-6.676990729e-014
	,-4.666441195e-014
	,-3.255873411e-014
	,-2.272790602e-014
	,-1.578751505e-014
	,-1.094987728e-014
	,-7.558058570e-015
	,-5.130832851e-015
	,-3.488993546e-015
	,-2.321853255e-015
	,-1.498871056e-015
	,-9.015157888e-016
	,-5.039403516e-016
	,-2.052105018e-016
	,-2.506555496e-018
	,1.540903366e-016
	,2.611861104e-016
	,3.570031484e-016
	,3.855132861e-016
	,4.200283063e-016
	,4.731845705e-016
	,4.965252876e-016
	,5.009636790e-016
	,5.437811020e-016
	,5.432067219e-016
	,5.566785452e-016
	,5.591849310e-016
	,5.724478888e-016
	,5.915068637e-016
	,5.801236951e-016
	,6.234632818e-016
	,6.270662113e-016
	,6.055530671e-016
	,6.301991935e-016
	,6.310346554e-016
	,6.718678563e-016
	,6.775594406e-016
	,6.580305184e-016
	,6.860184924e-016
	,6.954696553e-016
	,6.841909195e-016
	,6.943731115e-016
	,7.074272039e-016
	,6.975060937e-016
	,6.992814503e-016
	,7.284181844e-016
	,7.230398984e-016
	,7.497746795e-016
	,7.311856520e-016
	,7.684681398e-016
	,7.584948132e-016
	,7.604268189e-016
	,7.484170539e-016
	,7.710789583e-016
	,7.847074307e-016
	,7.777626536e-016
	,7.837675361e-016
	,8.536852548e-016
	,8.163505506e-016
	,8.640763123e-016
	,8.365060692e-016
	,8.654339379e-016
	,8.774959193e-016
	,8.753550481e-016
	,8.814643633e-016
	,9.221409152e-016
	,9.481968835e-016
	,9.363959840e-016
	,9.810409799e-016
	,1.010647661e-015
	,1.013989509e-015
	,1.050436535e-015
	,1.068242317e-015
	,1.186825692e-015
	,1.176434635e-015
	,1.235856863e-015
	,1.336321158e-015
	,1.435375611e-015
	,1.560068301e-015
	,1.735933033e-015
	,1.907620456e-015
	,2.183792835e-015
	,2.481687222e-015
	,2.940564677e-015
	,3.470560828e-015
	,4.205976175e-015
	,5.149317106e-015
	,6.383764297e-015
	,7.952082955e-015
	,1.008929896e-014
	,1.282742094e-014
	,1.653086695e-014
	,2.153810348e-014
	,2.805313990e-014
	,3.600548411e-014
	,4.574853649e-014
	,5.823822212e-014
	,7.449469221e-014
	,9.553266748e-014
	,1.229733095e-013
	,1.588236590e-013
	,2.057648175e-013
	,2.675697311e-013
	,3.492127923e-013
	,4.563469451e-013
	,5.937852335e-013
	,7.651643709e-013
	,9.875087214e-013
	,1.276159611e-012
	,1.651079880e-012
	,2.138358288e-012
	,2.772412420e-012
	,3.598129452e-012
	,4.674212383e-012
	,6.077478543e-012
	,7.908971671e-012
	,1.030086304e-011
	,1.342676347e-011
	,1.751462028e-011
	,2.286329407e-011
	,2.984483325e-011
	,3.898792864e-011
	,5.096659548e-011
	,6.666937546e-011
	,8.726996694e-011
	,1.143118470e-010
	,1.498289903e-010
	,1.965035361e-010
	,2.578737342e-010
	,3.386093387e-010
	,4.448767728e-010
	,5.848228660e-010
	,7.692165817e-010
	,1.012301332e-009
	,1.332929024e-009
	,1.756069957e-009
	,2.314664117e-009
	,3.052666365e-009
	,4.020450503e-009
	,5.261710149e-009
	,6.898184680e-009
	,9.055837999e-009
	,1.190086002e-008
	,1.565236823e-008
	,2.059904665e-008
	,2.712088666e-008
	,3.571750508e-008
	,4.704489081e-008
	,6.196285364e-008
	,8.159258552e-008
	,1.074027824e-007
	,1.413005256e-007
	,1.857561615e-007
	,2.439549577e-007
	,3.199801510e-007
	,4.190304071e-007
	,5.476701296e-007
	,7.141071884e-007
	,9.284857893e-007
	,1.203173724e-006
	,1.553013624e-006
	,1.995498994e-006
	,2.550830530e-006
	,3.241809972e-006
	,4.093540445e-006
	,5.132924901e-006
	,6.387984650e-006
	,7.887053407e-006
	,9.657928130e-006
	,1.172708664e-005
	,1.411898596e-005
	,1.685560976e-005
	,1.995618775e-005
	,2.343711928e-005
	,2.731212251e-005
	,-7.024268247e-010
	,-4.927429669e-010
	,-3.456611133e-010
	,-2.424904539e-010
	,-1.701187324e-010
	,-1.193493459e-010
	,-8.373191540e-011
	,-5.874278374e-011
	,-4.121016819e-011
	,-2.890952132e-011
	,-2.027977948e-011
	,-1.422551853e-011
	,-9.978319135e-012
	,-6.999152710e-012
	,-4.909322540e-012
	,-3.443547799e-012
	,-2.415295166e-012
	,-1.694030768e-012
	,-1.188146675e-012
	,-8.333029738e-013
	,-5.843978794e-013
	,-4.097663410e-013
	,-2.873086679e-013
	,-2.014032889e-013
	,-1.411539532e-013
	,-9.890365220e-014
	,-6.928428213e-014
	,-4.843172719e-014
	,-3.388795401e-014
	,-2.364743628e-014
	,-1.647557015e-014
	,-1.142071229e-014
	,-7.867962723e-015
	,-5.376406437e-015
	,-3.654206139e-015
	,-2.398506885e-015
	,-1.565603576e-015
	,-9.828166761e-016
	,-5.371499626e-016
	,-2.100666242e-016
	,-4.490777536e-018
	,1.627582539e-016
	,2.402995626e-016
	,3.566376338e-016
	,4.384084684e-016
	,4.629501620e-016
	,5.045666085e-016
	,5.404914707e-016
	,5.362097284e-016
	,5.545376741e-016
	,5.679050647e-016
	,5.880605833e-016
	,5.840399229e-016
	,6.049786870e-016
	,6.084771838e-016
	,6.324444974e-016
	,6.567251092e-016
	,6.495714665e-016
	,6.779771715e-016
	,7.161995540e-016
	,6.767761950e-016
	,6.803269082e-016
	,7.292014300e-016
	,7.311334357e-016
	,7.331698741e-016
	,7.369294527e-016
	,7.832975888e-016
	,7.814700158e-016
	,7.816266649e-016
	,8.100845863e-016
	,8.235564096e-016
	,8.164027670e-016
	,8.333730871e-016
	,8.528497929e-016
	,8.489335652e-016
	,8.718043350e-016
	,8.787491122e-016
	,8.852761583e-016
	,9.003144727e-016
	,8.876781113e-016
	,9.421920011e-016
	,9.239162717e-016
	,9.223497807e-016
	,9.476747199e-016
	,9.613031923e-016
	,9.871502952e-016
	,9.839128803e-016
	,9.527397077e-016
	,9.925807976e-016
	,9.943561542e-016
	,1.038061255e-015
	,1.037278010e-015
	,1.027409116e-015
	,1.047407986e-015
	,1.058268990e-015
	,1.083123982e-015
	,1.108240056e-015
	,1.130745311e-015
	,1.097640133e-015
	,1.104219396e-015
	,1.117586786e-015
	,1.162075133e-015
	,1.154764841e-015
	,1.160926373e-015
	,1.182596166e-015
	,1.239042062e-015
	,1.262121697e-015
	,1.274131462e-015
	,1.375535651e-015
	,1.415272309e-015
	,1.481169367e-015
	,1.526284310e-015
	,1.652595708e-015
	,1.815406348e-015
	,1.979835695e-015
	,2.183114022e-015
	,2.387749974e-015
	,2.763498968e-015
	,3.265924876e-015
	,3.824170082e-015
	,4.570550867e-015
	,5.625321531e-015
	,6.931044066e-015
	,8.650320247e-015
	,1.106981794e-014
	,1.409528661e-014
	,1.800958231e-014
	,2.251648160e-014
	,2.835385397e-014
	,3.584914830e-014
	,4.556896439e-014
	,5.810783785e-014
	,7.438352356e-014
	,9.556284854e-014
	,1.231413940e-013
	,1.593502088e-013
	,2.069186426e-013
	,2.694985516e-013
	,3.468840466e-013
	,4.470174986e-013
	,5.767086009e-013
	,7.447194692e-013
	,9.626451660e-013
	,1.245159640e-012
	,1.608681232e-012
	,2.080447515e-012
	,2.693515992e-012
	,3.490665501e-012
	,4.528104454e-012
	,5.879091272e-012
	,7.639842968e-012
	,9.936137132e-012
	,1.293245569e-011
	,1.684536161e-011
	,2.195867768e-011
	,2.864489356e-011
	,3.739333146e-011
	,4.884705414e-011
	,6.385153141e-011
	,8.351927248e-011
	,1.092508440e-010
	,1.430039239e-010
	,1.873071844e-010
	,2.454922207e-010
	,3.219472763e-010
	,4.224556695e-010
	,5.546826209e-010
	,7.287430815e-010
	,9.580153618e-010
	,1.260212679e-009
	,1.658816611e-009
	,2.185008102e-009
	,2.873967051e-009
	,3.749700868e-009
	,4.902657304e-009
	,6.420768773e-009
	,8.419999767e-009
	,1.105320407e-008
	,1.452161288e-008
	,1.908942619e-008
	,2.510578800e-008
	,3.302869095e-008
	,4.345917825e-008
	,5.718477510e-008
	,7.523532517e-008
	,9.895431157e-008
	,1.300892154e-007
	,1.709048426e-007
	,2.243236600e-007
	,2.940968376e-007
	,3.850085395e-007
	,5.031117025e-007
	,6.559855319e-007
	,8.530569175e-007
	,1.105859756e-006
	,1.428311899e-006
	,1.836922904e-006
	,2.350901222e-006
	,2.992114045e-006
	,3.784866180e-006
	,4.755479844e-006
	,-7.115234392e-010
	,-4.993826106e-010
	,-3.505072644e-010
	,-2.460266001e-010
	,-1.726979208e-010
	,-1.212293334e-010
	,-8.510106416e-011
	,-5.973905129e-011
	,-4.193489041e-011
	,-2.943660328e-011
	,-2.066286921e-011
	,-1.450388499e-011
	,-1.018082659e-011
	,-7.146293217e-012
	,-5.016338788e-012
	,-3.521213852e-012
	,-2.471738816e-012
	,-1.735067091e-012
	,-1.217917003e-012
	,-8.549244148e-013
	,-6.000481696e-013
	,-4.210972931e-013
	,-2.955713862e-013
	,-2.073697924e-013
	,-1.454843611e-013
	,-1.020214394e-013
	,-7.149199023e-014
	,-5.008004133e-014
	,-3.502820288e-014
	,-2.449459466e-014
	,-1.708618837e-014
	,-1.185353377e-014
	,-8.173167403e-015
	,-5.637436068e-015
	,-3.764278246e-015
	,-2.545965913e-015
	,-1.603460444e-015
	,-9.879860967e-016
	,-5.061856555e-016
	,-2.257315350e-016
	,1.952875242e-017
	,1.567533714e-016
	,2.727259280e-016
	,3.465076581e-016
	,3.983062966e-016
	,4.957942584e-016
	,5.312491733e-016
	,5.326590153e-016
	,5.731267016e-016
	,5.644065679e-016
	,6.024723013e-016
	,6.187638086e-016
	,6.346375849e-016
	,6.464907007e-016
	,6.493103847e-016
	,6.880549308e-016
	,6.730688328e-016
	,6.605369041e-016
	,7.199069162e-016
	,7.358329089e-016
	,7.529598781e-016
	,7.584948133e-016
	,7.992757978e-016
	,8.019910490e-016
	,8.114944283e-016
	,8.211022403e-016
	,8.229298132e-016
	,8.690368674e-016
	,8.600034355e-016
	,8.886702224e-016
	,8.890879533e-016
	,8.947795376e-016
	,9.274669849e-016
	,9.288768269e-016
	,9.693445132e-016
	,9.651149873e-016
	,9.696578114e-016
	,1.000152171e-015
	,9.984290310e-016
	,1.035763735e-015
	,1.026103707e-015
	,1.031951940e-015
	,1.048922260e-015
	,1.042134132e-015
	,1.057433529e-015
	,1.097483484e-015
	,1.089076648e-015
	,1.080095433e-015
	,1.106569132e-015
	,1.090904221e-015
	,1.110328711e-015
	,1.108657787e-015
	,1.135340352e-015
	,1.159203233e-015
	,1.170899699e-015
	,1.172622840e-015
	,1.194344849e-015
	,1.206772345e-015
	,1.189332078e-015
	,1.224473694e-015
	,1.218677677e-015
	,1.217789999e-015
	,1.252774967e-015
	,1.263479322e-015
	,1.254445891e-015
	,1.302119436e-015
	,1.301283974e-015
	,1.285671279e-015
	,1.313345955e-015
	,1.329794112e-015
	,1.372298236e-015
	,1.326608913e-015
	,1.385508978e-015
	,1.407544286e-015
	,1.463102503e-015
	,1.499915043e-015
	,1.507851932e-015
	,1.579231709e-015
	,1.591920286e-015
	,1.718022819e-015
	,1.782614468e-015
	,1.901041194e-015
	,2.030537790e-015
	,2.184680513e-015
	,2.449417506e-015
	,2.748304005e-015
	,3.079669086e-015
	,3.582094993e-015
	,4.267173760e-015
	,5.103523350e-015
	,6.171661404e-015
	,7.601188952e-015
	,9.486565404e-015
	,1.164064729e-014
	,1.438085793e-014
	,1.794410299e-014
	,2.253841247e-014
	,2.843358837e-014
	,3.600245556e-014
	,4.580425135e-014
	,5.855256466e-014
	,7.497012226e-014
	,9.639888483e-014
	,1.244274310e-013
	,1.598465777e-013
	,2.049747838e-013
	,2.631779167e-013
	,3.384279711e-013
	,4.356671219e-013
	,5.614726475e-013
	,7.243025032e-013
	,9.352249928e-013
	,1.208791513e-012
	,1.563704767e-012
	,2.024522791e-012
	,2.622744536e-012
	,3.400294160e-012
	,4.411657773e-012
	,5.719854738e-012
	,7.421290152e-012
	,9.636970701e-012
	,1.252451348e-011
	,1.629006329e-011
	,2.120405517e-011
	,2.762094607e-011
	,3.600581559e-011
	,4.696925914e-011
	,6.131294169e-011
	,8.008931796e-011
	,1.046852883e-010
	,1.369244135e-010
	,1.792077855e-010
	,2.346987284e-010
	,3.075681632e-010
	,4.031411114e-010
	,5.287486638e-010
	,6.939715428e-010
	,9.114718220e-010
	,1.198034038e-009
	,1.575953399e-009
	,2.070063815e-009
	,2.691202419e-009
	,3.507656752e-009
	,4.581011510e-009
	,5.992432145e-009
	,7.848842568e-009
	,1.029104282e-008
	,1.350435299e-008
	,1.773254585e-008
	,2.329604189e-008
	,3.061560980e-008
	,4.024313719e-008
	,5.290142189e-008
	,6.953537577e-008
	,9.137751530e-008
	,1.200286000e-007
	,1.575661090e-007
	,2.066745538e-007
	,2.708012771e-007
	,3.543493054e-007
	,4.629022716e-007
	,-7.198265603e-010
	,-5.054383827e-010
	,-3.549231896e-010
	,-2.492454920e-010
	,-1.750430598e-010
	,-1.229366794e-010
	,-8.634295783e-011
	,-6.064181843e-011
	,-4.259105603e-011
	,-2.991320652e-011
	,-2.100899523e-011
	,-1.475544131e-011
	,-1.036358931e-011
	,-7.279171137e-012
	,-5.112921005e-012
	,-3.591433695e-012
	,-2.522687842e-012
	,-1.772012261e-012
	,-1.244749115e-012
	,-8.743690598e-013
	,-6.141764571e-013
	,-4.314066320e-013
	,-3.029946742e-013
	,-2.127468775e-013
	,-1.493180870e-013
	,-1.048318811e-013
	,-7.350414802e-014
	,-5.154815677e-014
	,-3.610140592e-014
	,-2.524515275e-014
	,-1.760448806e-014
	,-1.219711748e-014
	,-8.460096353e-015
	,-5.818783519e-015
	,-3.956643351e-015
	,-2.601315265e-015
	,-1.682933758e-015
	,-1.053987588e-015
	,-5.599685161e-016
	,-2.255226695e-016
	,1.738788128e-017
	,1.584765116e-016
	,2.656767181e-016
	,3.599794814e-016
	,4.429512925e-016
	,5.062897487e-016
	,5.397604415e-016
	,5.610125039e-016
	,5.543810250e-016
	,6.139599026e-016
	,6.058141489e-016
	,6.348464504e-016
	,6.496236829e-016
	,6.730166164e-016
	,6.845042177e-016
	,6.982893393e-016
	,7.212645418e-016
	,7.179226942e-016
	,7.466416974e-016
	,7.382870783e-016
	,7.731153967e-016
	,7.785458991e-016
	,8.253839826e-016
	,8.297179412e-016
	,8.490902143e-016
	,8.700811948e-016
	,9.062149225e-016
	,9.143084598e-016
	,9.174936583e-016
	,9.502855384e-016
	,9.526352750e-016
	,9.908054411e-016
	,9.987423292e-016
	,1.014355024e-015
	,1.012892965e-015
	,1.032004157e-015
	,1.062080785e-015
	,1.022500777e-015
	,1.065788148e-015
	,1.084951555e-015
	,1.086779128e-015
	,1.134922621e-015
	,1.117847868e-015
	,1.125836973e-015
	,1.180664160e-015
	,1.172883921e-015
	,1.204004878e-015
	,1.185572499e-015
	,1.211001871e-015
	,1.195963557e-015
	,1.243010506e-015
	,1.208338836e-015
	,1.256169031e-015
	,1.260502989e-015
	,1.257631089e-015
	,1.295487957e-015
	,1.327757673e-015
	,1.291780595e-015
	,1.325773451e-015
	,1.360653986e-015
	,1.315695692e-015
	,1.354805753e-015
	,1.321961656e-015
	,1.382950376e-015
	,1.372089371e-015
	,1.366241138e-015
	,1.435114529e-015
	,1.396004468e-015
	,1.395534521e-015
	,1.454539018e-015
	,1.438143078e-015
	,1.442633686e-015
	,1.486443220e-015
	,1.493179132e-015
	,1.464094614e-015
	,1.519287317e-015
	,1.515632171e-015
	,1.554533366e-015
	,1.567274160e-015
	,1.602572426e-015
	,1.591972503e-015
	,1.654162199e-015
	,1.656877450e-015
	,1.687998406e-015
	,1.721834614e-015
	,1.721051368e-015
	,1.794467584e-015
	,1.895976206e-015
	,1.974300760e-015
	,2.077062575e-015
	,2.178310116e-015
	,2.342739463e-015
	,2.540743936e-015
	,2.747572976e-015
	,3.063325362e-015
	,3.488314393e-015
	,4.041599044e-015
	,4.677594424e-015
	,5.597594638e-015
	,6.670223300e-015
	,8.006074681e-015
	,9.691566871e-015
	,1.181891398e-014
	,1.457118660e-014
	,1.816852894e-014
	,2.274430162e-014
	,2.859937534e-014
	,3.623419181e-014
	,4.611556535e-014
	,5.893656385e-014
	,7.541620670e-014
	,9.623455992e-014
	,1.230017675e-013
	,1.575191896e-013
	,2.020241935e-013
	,2.590993483e-013
	,3.326950837e-013
	,4.277623468e-013
	,5.505983797e-013
	,7.093702402e-013
	,9.149438938e-013
	,1.181097987e-012
	,1.526041151e-012
	,1.973378789e-012
	,2.553842269e-012
	,3.307638353e-012
	,4.286974325e-012
	,5.559845924e-012
	,7.215551913e-012
	,9.370780788e-012
	,1.217806805e-011
	,1.583692514e-011
	,2.058883642e-011
	,2.677971320e-011
	,3.485809911e-011
	,4.540679947e-011
	,5.919053029e-011
	,7.721323741e-011
	,1.007943148e-010
	,1.316687213e-010
	,1.721195764e-010
	,2.251538156e-010
	,2.947355894e-010
	,3.860951085e-010
	,5.061386153e-010
	,6.640159213e-010
	,8.718525339e-010
	,1.145765590e-009
	,1.503079621e-009
	,1.946354429e-009
	,2.528007665e-009
	,3.291375004e-009
	,4.293522183e-009
	,5.609567029e-009
	,7.338360355e-009
	,9.609941009e-009
	,1.259530572e-008
	,1.651892028e-008
	,2.167598153e-008
	,2.845378350e-008
	,3.735990217e-008
	,-7.274836378e-010
	,-5.110195967e-010
	,-3.589898373e-010
	,-2.522072791e-010
	,-1.771988185e-010
	,-1.245044489e-010
	,-8.748197657e-011
	,-6.146907005e-011
	,-4.319158391e-011
	,-3.034899885e-011
	,-2.132533771e-011
	,-1.498517611e-011
	,-1.053046056e-011
	,-7.400348673e-012
	,-5.200910600e-012
	,-3.655345069e-012
	,-2.569099997e-012
	,-1.805736673e-012
	,-1.269248775e-012
	,-8.921098324e-013
	,-6.270655458e-013
	,-4.407290816e-013
	,-3.097833244e-013
	,-2.176699412e-013
	,-1.529104166e-013
	,-1.073650016e-013
	,-7.536414732e-014
	,-5.284604685e-014
	,-3.704808870e-014
	,-2.589221801e-014
	,-1.812033357e-014
	,-1.256560840e-014
	,-8.724937779e-015
	,-5.959872149e-015
	,-4.029015239e-015
	,-2.681885123e-015
	,-1.704394686e-015
	,-1.084690813e-015
	,-5.685320007e-016
	,-2.459392700e-016
	,-7.780408814e-018
	,1.567533714e-016
	,2.722559807e-016
	,3.878108064e-016
	,4.494783387e-016
	,5.311447406e-016
	,5.436766693e-016
	,5.762074674e-016
	,5.879561506e-016
	,6.308780063e-016
	,6.150042300e-016
	,6.414779293e-016
	,6.976105265e-016
	,6.764106805e-016
	,6.943731116e-016
	,7.229354657e-016
	,7.542652873e-016
	,7.472160775e-016
	,7.609489826e-016
	,7.906078805e-016
	,8.273682046e-016
	,8.522754129e-016
	,8.471582086e-016
	,8.758249955e-016
	,9.025597767e-016
	,9.164493309e-016
	,9.377536097e-016
	,9.607810286e-016
	,9.581179938e-016
	,1.000622119e-015
	,9.890300845e-016
	,1.036546981e-015
	,1.056754716e-015
	,1.074769363e-015
	,1.047877933e-015
	,1.099102191e-015
	,1.088084537e-015
	,1.133303913e-015
	,1.140823071e-015
	,1.164842601e-015
	,1.162806162e-015
	,1.200506381e-015
	,1.204944772e-015
	,1.207921105e-015
	,1.242279476e-015
	,1.236170161e-015
	,1.244576997e-015
	,1.272408322e-015
	,1.291206215e-015
	,1.321857224e-015
	,1.333397041e-015
	,1.359087495e-015
	,1.347129946e-015
	,1.363055939e-015
	,1.389581855e-015
	,1.402479298e-015
	,1.385404545e-015
	,1.429161863e-015
	,1.412974788e-015
	,1.473806859e-015
	,1.473754642e-015
	,1.473806859e-015
	,1.498348552e-015
	,1.492343670e-015
	,1.530409403e-015
	,1.520906024e-015
	,1.558919541e-015
	,1.566804213e-015
	,1.566647564e-015
	,1.559546137e-015
	,1.588682872e-015
	,1.627949581e-015
	,1.623511190e-015
	,1.631343645e-015
	,1.631395862e-015
	,1.669357162e-015
	,1.667477373e-015
	,1.696666324e-015
	,1.709093820e-015
	,1.748099448e-015
	,1.744078787e-015
	,1.774990878e-015
	,1.779742567e-015
	,1.780003649e-015
	,1.804701992e-015
	,1.810550225e-015
	,1.852114456e-015
	,1.829191469e-015
	,1.898900323e-015
	,1.921196712e-015
	,1.971585509e-015
	,1.953100914e-015
	,2.020877762e-015
	,2.031686550e-015
	,2.114031765e-015
	,2.138886757e-015
	,2.211363078e-015
	,2.304517081e-015
	,2.380596331e-015
	,2.503879179e-015
	,2.690291618e-015
	,2.882656724e-015
	,3.176791533e-015
	,3.503091626e-015
	,3.922232424e-015
	,4.447372451e-015
	,5.119397127e-015
	,5.927288795e-015
	,6.983051570e-015
	,8.299478461e-015
	,1.002178319e-014
	,1.220484517e-014
	,1.498708998e-014
	,1.856135269e-014
	,2.314438344e-014
	,2.911454204e-014
	,3.682042499e-014
	,4.647157656e-014
	,5.886925695e-014
	,7.479164671e-014
	,9.525571185e-014
	,1.215728143e-013
	,1.554665119e-013
	,1.991231042e-013
	,2.553683321e-013
	,3.279686668e-013
	,4.217184065e-013
	,5.427631046e-013
	,6.992251218e-013
	,9.008160240e-013
	,1.161368293e-012
	,1.498619307e-012
	,1.935467720e-012
	,2.501595718e-012
	,3.235823196e-012
	,4.188693040e-012
	,5.426074478e-012
	,7.034097731e-012
	,9.124936982e-012
	,1.184452920e-011
	,1.538485226e-011
	,1.999669089e-011
	,2.600799881e-011
	,3.384855174e-011
	,4.408156671e-011
	,5.744560887e-011
	,7.486323223e-011
	,9.760101292e-011
	,1.273403546e-010
	,1.662660270e-010
	,2.172568340e-010
	,2.841091525e-010
	,3.718363133e-010
	,4.870715847e-010
	,6.386117295e-010
	,8.381577767e-010
	,1.098655995e-009
	,1.416994225e-009
	,1.834070157e-009
	,2.380598133e-009
	,3.096977775e-009
	,-7.346040229e-010
	,-5.162066134e-010
	,-3.627671407e-010
	,-2.549563590e-010
	,-1.791981855e-010
	,-1.259571374e-010
	,-8.853648182e-011
	,-6.223435201e-011
	,-4.374658283e-011
	,-3.075142655e-011
	,-2.161726184e-011
	,-1.519703693e-011
	,-1.068424106e-011
	,-7.511959544e-012
	,-5.281914324e-012
	,-3.714081070e-012
	,-2.611776592e-012
	,-1.836676177e-012
	,-1.291635185e-012
	,-9.083729862e-013
	,-6.389014825e-013
	,-4.492416030e-013
	,-3.159727395e-013
	,-2.221302635e-013
	,-1.561618777e-013
	,-1.097490444e-013
	,-7.706593102e-014
	,-5.411156278e-014
	,-3.793158967e-014
	,-2.655964764e-014
	,-1.853033651e-014
	,-1.291227288e-014
	,-8.936361859e-015
	,-6.142733875e-015
	,-4.159817244e-015
	,-2.769974138e-015
	,-1.786635468e-015
	,-1.095499601e-015
	,-6.092607689e-016
	,-2.495421995e-016
	,8.354449355e-018
	,1.981087360e-016
	,2.923592830e-016
	,4.149633185e-016
	,4.679107171e-016
	,5.130778767e-016
	,5.598115274e-016
	,5.817424026e-016
	,5.876950687e-016
	,6.140121189e-016
	,6.661240557e-016
	,6.693092542e-016
	,6.999602631e-016
	,7.229354657e-016
	,7.296191610e-016
	,7.349452306e-016
	,7.707134437e-016
	,7.743685896e-016
	,8.018866163e-016
	,8.327987070e-016
	,8.562438569e-016
	,8.705511422e-016
	,8.678358910e-016
	,9.192167985e-016
	,9.325319727e-016
	,9.393723171e-016
	,9.379102588e-016
	,9.728430100e-016
	,1.000726551e-015
	,1.029184473e-015
	,1.038426770e-015
	,1.085003772e-015
	,1.078946673e-015
	,1.107822325e-015
	,1.117273488e-015
	,1.106621349e-015
	,1.147924497e-015
	,1.183692710e-015
	,1.162231782e-015
	,1.213664906e-015
	,1.223794882e-015
	,1.248493224e-015
	,1.253975943e-015
	,1.271416211e-015
	,1.311727248e-015
	,1.312406061e-015
	,1.335642345e-015
	,1.352560449e-015
	,1.370000716e-015
	,1.404306871e-015
	,1.398719719e-015
	,1.416212203e-015
	,1.440440599e-015
	,1.472240368e-015
	,1.507173119e-015
	,1.469472900e-015
	,1.512185890e-015
	,1.533751251e-015
	,1.571555902e-015
	,1.568214055e-015
	,1.597455222e-015
	,1.615417653e-015
	,1.636251984e-015
	,1.652439059e-015
	,1.660428163e-015
	,1.667895104e-015
	,1.672907876e-015
	,1.685857535e-015
	,1.733165566e-015
	,1.740841372e-015
	,1.784859772e-015
	,1.759900347e-015
	,1.782718901e-015
	,1.849921368e-015
	,1.825484107e-015
	,1.872269974e-015
	,1.871121214e-015
	,1.882347733e-015
	,1.879475833e-015
	,1.893678686e-015
	,1.905584018e-015
	,1.910962304e-015
	,1.927932624e-015
	,1.969862369e-015
	,1.960097908e-015
	,2.008398049e-015
	,2.027404808e-015
	,2.069595634e-015
	,2.037378134e-015
	,2.057951384e-015
	,2.083328540e-015
	,2.112830788e-015
	,2.138051295e-015
	,2.153350691e-015
	,2.190006582e-015
	,2.212094107e-015
	,2.209953236e-015
	,2.217994556e-015
	,2.266712429e-015
	,2.296266894e-015
	,2.359605350e-015
	,2.369630893e-015
	,2.451715026e-015
	,2.492757093e-015
	,2.523460318e-015
	,2.619956169e-015
	,2.695878770e-015
	,2.830544787e-015
	,2.958944839e-015
	,3.119510176e-015
	,3.362211861e-015
	,3.622562679e-015
	,3.948914988e-015
	,4.348004700e-015
	,4.865364489e-015
	,5.524230639e-015
	,6.341573471e-015
	,7.418431658e-015
	,8.735328497e-015
	,1.043925307e-014
	,1.265364486e-014
	,1.547614850e-014
	,1.910294087e-014
	,2.374476725e-014
	,2.957263625e-014
	,3.706845274e-014
	,4.665125308e-014
	,5.897410742e-014
	,7.479780824e-014
	,9.509049926e-014
	,1.210988985e-013
	,1.546231654e-013
	,1.977541476e-013
	,2.532469376e-013
	,3.247974622e-013
	,4.170493754e-013
	,5.361321478e-013
	,6.898108237e-013
	,8.884274815e-013
	,1.145142474e-012
	,1.477393249e-012
	,1.907268374e-012
	,2.464254017e-012
	,3.184394510e-012
	,4.116831306e-012
	,5.326195058e-012
	,6.895870192e-012
	,8.934504718e-012
	,1.158386415e-011
	,1.502916699e-011
	,1.951254254e-011
	,2.534925349e-011
	,3.295390200e-011
	,4.286912841e-011
	,5.580580026e-011
	,7.269688503e-011
	,9.476726569e-011
	,1.236273918e-010
	,1.613968985e-010
	,2.108697894e-010
	,2.756309703e-010
	,-7.412687477e-010
	,-5.210602950e-010
	,-3.663000957e-010
	,-2.575263636e-010
	,-1.810660907e-010
	,-1.273132819e-010
	,-8.952030887e-011
	,-6.294766146e-011
	,-4.426353768e-011
	,-3.112607592e-011
	,-2.188897034e-011
	,-1.539405811e-011
	,-1.082712515e-011
	,-7.615592015e-012
	,-5.357043393e-012
	,-3.768593028e-012
	,-2.651224023e-012
	,-1.865320615e-012
	,-1.312437404e-012
	,-9.234485309e-013
	,-6.497682833e-013
	,-4.572366080e-013
	,-3.216811897e-013
	,-2.262915949e-013
	,-1.591664076e-013
	,-1.119074080e-013
	,-7.862673052e-014
	,-5.520058738e-014
	,-3.870684611e-014
	,-2.713267008e-014
	,-1.892577107e-014
	,-1.321846967e-014
	,-9.143765278e-015
	,-6.265703425e-015
	,-4.284405502e-015
	,-2.843129272e-015
	,-1.796034414e-015
	,-1.108031530e-015
	,-6.175109552e-016
	,-2.299610609e-016
	,-1.357642583e-017
	,1.827571234e-016
	,3.185719004e-016
	,3.949122326e-016
	,4.766308508e-016
	,5.152709643e-016
	,5.844054374e-016
	,6.001225647e-016
	,6.439320987e-016
	,6.335932575e-016
	,6.763062477e-016
	,7.095680751e-016
	,7.366161545e-016
	,7.110301334e-016
	,7.439786626e-016
	,7.767183262e-016
	,7.894069040e-016
	,8.379159113e-016
	,8.241830061e-016
	,8.437119283e-016
	,8.930563974e-016
	,8.791668431e-016
	,9.243862191e-016
	,9.443850886e-016
	,9.530007896e-016
	,9.453249833e-016
	,1.010334363e-015
	,1.026260356e-015
	,1.048086798e-015
	,1.059208885e-015
	,1.081139760e-015
	,1.082184088e-015
	,1.095029315e-015
	,1.104167179e-015
	,1.171212998e-015
	,1.162806162e-015
	,1.194292633e-015
	,1.212150631e-015
	,1.236640109e-015
	,1.248336575e-015
	,1.278726502e-015
	,1.311413950e-015
	,1.310787353e-015
	,1.332039416e-015
	,1.372193804e-015
	,1.366293354e-015
	,1.381488317e-015
	,1.391043913e-015
	,1.444774557e-015
	,1.469681766e-015
	,1.477409788e-015
	,1.503204675e-015
	,1.510776048e-015
	,1.531140432e-015
	,1.548267402e-015
	,1.586280919e-015
	,1.640324861e-015
	,1.609151688e-015
	,1.634424411e-015
	,1.686223050e-015
	,1.692227932e-015
	,1.708623872e-015
	,1.718492766e-015
	,1.755984119e-015
	,1.824126482e-015
	,1.834517539e-015
	,1.812743313e-015
	,1.811072389e-015
	,1.901981088e-015
	,1.898117077e-015
	,1.953727511e-015
	,1.927097162e-015
	,1.991532162e-015
	,1.999469050e-015
	,2.033931854e-015
	,2.054296238e-015
	,2.014872879e-015
	,2.068029143e-015
	,2.078785715e-015
	,2.116590367e-015
	,2.114136198e-015
	,2.143847312e-015
	,2.171991935e-015
	,2.167971275e-015
	,2.208125663e-015
	,2.221336404e-015
	,2.241648572e-015
	,2.255538126e-015
	,2.263892745e-015
	,2.320025342e-015
	,2.311670723e-015
	,2.329163207e-015
	,2.334802575e-015
	,2.373912636e-015
	,2.399968604e-015
	,2.396887838e-015
	,2.438295419e-015
	,2.486961076e-015
	,2.456466716e-015
	,2.512181582e-015
	,2.543511404e-015
	,2.525079025e-015
	,2.558393069e-015
	,2.603508012e-015
	,2.641103798e-015
	,2.666324305e-015
	,2.729767194e-015
	,2.705434366e-015
	,2.759269442e-015
	,2.787884013e-015
	,2.826576343e-015
	,2.853154475e-015
	,2.970745739e-015
	,3.010377963e-015
	,3.102278774e-015
	,3.179193486e-015
	,3.290988733e-015
	,3.497556691e-015
	,3.644702420e-015
	,3.850539348e-015
	,4.143682046e-015
	,4.443247358e-015
	,4.862231507e-015
	,5.371341109e-015
	,6.062894707e-015
	,6.916214617e-015
	,7.989574308e-015
	,9.362290445e-015
	,1.110276647e-014
	,1.334948020e-014
	,1.612619008e-014
	,1.968531004e-014
	,2.430833853e-014
	,3.016043592e-014
	,3.763442597e-014
	,4.721952383e-014
	,5.951256262e-014
	,7.520164964e-014
	,9.544123661e-014
	,1.213872373e-013
	,1.547176248e-013
	,1.976211525e-013
	,2.528191811e-013
	,3.239047190e-013
	,4.152842532e-013
	,5.331228663e-013
	,6.850575153e-013
	,8.811425147e-013
	,1.134417754e-012
	,1.461679150e-012
	,1.884745731e-012
	,2.432248725e-012
	,3.140956339e-012
	,4.059087520e-012
	,5.249212151e-012
	,6.792759833e-012
	,8.796117032e-012
	,1.139472283e-011
	,1.476611951e-011
	,1.914854437e-011
	,2.484936201e-011
	,-7.475413262e-010
	,-5.256274710e-010
	,-3.696235829e-010
	,-2.599430528e-010
	,-1.828217235e-010
	,-1.285871937e-010
	,-9.044399504e-011
	,-6.361700863e-011
	,-4.474835607e-011
	,-3.147741763e-011
	,-2.214360457e-011
	,-1.557866919e-011
	,-1.096092223e-011
	,-7.712563453e-012
	,-5.427291224e-012
	,-3.819459813e-012
	,-2.688148881e-012
	,-1.892073986e-012
	,-1.331760228e-012
	,-9.374806880e-013
	,-6.599536606e-013
	,-4.645638700e-013
	,-3.269604213e-013
	,-2.301198902e-013
	,-1.619290190e-013
	,-1.138809257e-013
	,-8.009949322e-014
	,-5.627300718e-014
	,-3.947740307e-014
	,-2.766715684e-014
	,-1.933190999e-014
	,-1.348425099e-014
	,-9.314147292e-015
	,-6.369248486e-015
	,-4.355524197e-015
	,-2.902081553e-015
	,-1.839843948e-015
	,-1.118892535e-015
	,-5.867555136e-016
	,-2.480801412e-016
	,4.229356166e-018
	,1.609828973e-016
	,3.243679174e-016
	,3.940245543e-016
	,4.874918557e-016
	,5.372018394e-016
	,5.673306846e-016
	,6.139076862e-016
	,6.259696675e-016
	,6.665940030e-016
	,6.579260857e-016
	,7.059651456e-016
	,6.945297607e-016
	,7.441875280e-016
	,7.599046553e-016
	,7.749429697e-016
	,8.161416852e-016
	,8.259583626e-016
	,8.381247767e-016
	,8.768171065e-016
	,8.841273982e-016
	,8.988001981e-016
	,9.316965108e-016
	,9.721119808e-016
	,9.876724589e-016
	,9.923197158e-016
	,1.029706636e-015
	,1.045058249e-015
	,1.053882815e-015
	,1.074612714e-015
	,1.112208500e-015
	,1.122547341e-015
	,1.120719768e-015
	,1.154608192e-015
	,1.173092787e-015
	,1.202177305e-015
	,1.206302398e-015
	,1.236640109e-015
	,1.236901190e-015
	,1.272878269e-015
	,1.303738143e-015
	,1.323684796e-015
	,1.339976304e-015
	,1.371984938e-015
	,1.421903787e-015
	,1.373864728e-015
	,1.427804237e-015
	,1.459812872e-015
	,1.476261028e-015
	,1.515579954e-015
	,1.505136680e-015
	,1.575785428e-015
	,1.599804958e-015
	,1.609987150e-015
	,1.650350404e-015
	,1.661159192e-015
	,1.683925529e-015
	,1.689094950e-015
	,1.719798175e-015
	,1.777445047e-015
	,1.820523552e-015
	,1.810498009e-015
	,1.818800412e-015
	,1.859424747e-015
	,1.915035181e-015
	,1.926157268e-015
	,1.936913840e-015
	,1.984169654e-015
	,2.018475809e-015
	,2.023593013e-015
	,2.044061830e-015
	,2.107609151e-015
	,2.106564824e-015
	,2.156640322e-015
	,2.136380371e-015
	,2.179302227e-015
	,2.247496805e-015
	,2.246400262e-015
	,2.252352928e-015
	,2.290157579e-015
	,2.340755241e-015
	,2.341956218e-015
	,2.357307830e-015
	,2.399185359e-015
	,2.443830354e-015
	,2.498239811e-015
	,2.486021181e-015
	,2.477562129e-015
	,2.517768734e-015
	,2.498030946e-015
	,2.573431384e-015
	,2.621835958e-015
	,2.605648883e-015
	,2.619590654e-015
	,2.679900561e-015
	,2.688777344e-015
	,2.742873502e-015
	,2.751332554e-015
	,2.739113924e-015
	,2.764647729e-015
	,2.783080107e-015
	,2.814462145e-015
	,2.836288587e-015
	,2.875137566e-015
	,2.890854694e-015
	,2.937536128e-015
	,3.000822368e-015
	,2.978734843e-015
	,2.987716059e-015
	,3.040141294e-015
	,3.052673223e-015
	,3.102122124e-015
	,3.140501156e-015
	,3.145983875e-015
	,3.225718271e-015
	,3.207755840e-015
	,3.283208494e-015
	,3.307802404e-015
	,3.342160775e-015
	,3.384351602e-015
	,3.492596135e-015
	,3.546901160e-015
	,3.616244498e-015
	,3.720050641e-015
	,3.847824097e-015
	,3.905523185e-015
	,4.071936755e-015
	,4.264667375e-015
	,4.475621507e-015
	,4.758947528e-015
	,5.146340773e-015
	,5.553054075e-015
	,6.125710999e-015
	,6.750009913e-015
	,7.630430118e-015
	,8.750053513e-015
	,1.011765245e-014
	,1.192157136e-014
	,1.406233808e-014
	,1.690583269e-014
	,2.057178735e-014
	,2.513288722e-014
	,3.101072728e-014
	,3.853719478e-014
	,4.810485238e-014
	,6.051506469e-014
	,7.627046651e-014
	,9.654315866e-014
	,1.225341176e-013
	,1.558374048e-013
	,1.986680907e-013
	,2.537240908e-013
	,3.245491734e-013
	,4.155813122e-013
	,5.330090346e-013
	,6.841958930e-013
	,8.792482092e-013
	,1.130832734e-012
	,1.455351988e-012
	,1.874309768e-012
	,2.415761876e-012
	,-5.013440738e-009
	,-4.526996041e-009
	,-4.110013346e-009
	,-3.750121790e-009
	,-3.433492835e-009
	,-3.153087934e-009
	,-2.906114912e-009
	,-2.685559272e-009
	,-2.487257988e-009
	,-2.309511095e-009
	,-2.149086030e-009
	,-2.003479507e-009
	,-1.870594150e-009
	,-1.747190300e-009
	,-1.633070180e-009
	,-1.527966145e-009
	,-1.429276817e-009
	,-1.338061376e-009
	,-1.251112605e-009
	,-1.169531870e-009
	,-1.092986853e-009
	,-1.020916213e-009
	,-9.534329350e-010
	,-8.910902218e-010
	,-8.335632586e-010
	,-7.803345450e-010
	,-7.279166999e-010
	,-6.781177898e-010
	,-6.308830471e-010
	,-5.849694364e-010
	,-5.414293381e-010
	,-5.000391465e-010
	,-4.600190061e-010
	,-4.204024769e-010
	,-3.797947682e-010
	,-3.369906857e-010
	,-2.903133552e-010
	,-2.372872348e-010
	,-1.744862005e-010
	,-9.744664066e-011
	,9.973156829e-018
	,1.263666364e-010
	,2.930302708e-010
	,5.161718319e-010
	,8.183542215e-010
	,1.230866401e-009
	,1.797186989e-009
	,2.576762047e-009
	,3.653280907e-009
	,5.143313465e-009
	,7.208753749e-009
	,1.001307065e-008
	,1.385217685e-008
	,1.911680841e-008
	,2.634138703e-008
	,3.625744151e-008
	,4.985073700e-008
	,6.845861534e-008
	,9.389991653e-008
	,1.286140849e-007
	,1.758607500e-007
	,2.399362177e-007
	,3.263015551e-007
	,4.408818040e-007
	,5.927070637e-007
	,7.933046335e-007
	,1.056230498e-006
	,1.397690484e-006
	,1.836560291e-006
	,2.394212875e-006
	,3.094001254e-006
	,3.950154130e-006
	,4.985914513e-006
	,6.231400726e-006
	,7.710490734e-006
	,9.445228395e-006
	,1.143510950e-005
	,1.371643267e-005
	,1.625424354e-005
	,1.910006971e-005
	,2.226699664e-005
	,2.576682938e-005
	,2.961091472e-005
	,3.376243668e-005
	,3.814668996e-005
	,4.288618630e-005
	,4.800123427e-005
	,5.330294429e-005
	,5.891731885e-005
	,6.486853511e-005
	,7.115594738e-005
	,7.762086288e-005
	,8.425305364e-005
	,9.115900768e-005
	,9.813202640e-005
	,1.052646977e-004
	,1.126610840e-004
	,1.203160349e-004
	,1.282274379e-004
	,1.363924776e-004
	,1.448015297e-004
	,1.534601733e-004
	,1.623657075e-004
	,1.715092432e-004
	,1.808910421e-004
	,1.905123350e-004
	,2.003702880e-004
	,2.104585805e-004
	,2.207321907e-004
	,2.310013994e-004
	,2.414799975e-004
	,2.521585834e-004
	,2.627047454e-004
	,2.733923362e-004
	,2.842531387e-004
	,2.952842873e-004
	,3.064855940e-004
	,3.178513604e-004
	,3.293786582e-004
	,3.410646122e-004
	,3.529072821e-004
	,3.649075443e-004
	,3.770604169e-004
	,3.893635992e-004
	,4.018004159e-004
	,4.143698280e-004
	,4.270802523e-004
	,4.399287943e-004
	,4.529124190e-004
	,4.660292501e-004
	,4.792775353e-004
	,4.926556448e-004
	,5.061620710e-004
	,5.197954269e-004
	,5.335544453e-004
	,5.474456313e-004
	,5.614622424e-004
	,5.756023768e-004
	,5.898208959e-004
	,6.036918274e-004
	,6.176776775e-004
	,6.317791880e-004
	,6.459958367e-004
	,6.598969241e-004
	,6.738965933e-004
	,6.880004998e-004
	,7.022088627e-004
	,7.165218709e-004
	,7.309397573e-004
	,7.454627095e-004
	,7.600910707e-004
	,7.748251385e-004
	,7.896652026e-004
	,8.046115379e-004
	,8.196643935e-004
	,8.348239838e-004
	,8.500904801e-004
	,8.654640238e-004
	,8.809502580e-004
	,8.965472491e-004
	,9.122516712e-004
	,9.280633747e-004
	,9.439350028e-004
	,9.595388959e-004
	,9.752471947e-004
	,9.910558423e-004
	,1.006962375e-003
	,1.022965016e-003
	,1.039062451e-003
	,1.055253684e-003
	,1.071537953e-003
	,1.087914660e-003
	,1.104382749e-003
	,1.120940717e-003
	,1.137589853e-003
	,1.154329935e-003
	,1.171160651e-003
	,1.188081860e-003
	,1.205093422e-003
	,1.222195169e-003
	,1.239386935e-003
	,1.256668550e-003
	,1.274039836e-003
	,1.291500603e-003
	,1.309050650e-003
	,1.326689759e-003
	,1.344422976e-003
	,1.362252328e-003
	,1.380173065e-003
	,1.398182721e-003
	,1.416266190e-003
	,1.434428899e-003
	,1.452678892e-003
	,1.471015811e-003
	,1.489439286e-003
	,1.507948929e-003
	,1.526544340e-003
	,1.545225105e-003
	,1.563990801e-003
	,1.582840995e-003
	,1.601775218e-003
	,-2.491098376e-009
	,-1.986258731e-009
	,-1.608172128e-009
	,-1.323606607e-009
	,-1.108383006e-009
	,-9.437741789e-010
	,-8.157305644e-010
	,-7.126963661e-010
	,-6.295861524e-010
	,-5.614136335e-010
	,-5.045642772e-010
	,-4.569590461e-010
	,-4.165282658e-010
	,-3.814403742e-010
	,-3.503010809e-010
	,-3.227446130e-010
	,-2.982824213e-010
	,-2.764046715e-010
	,-2.563512813e-010
	,-2.374316447e-010
	,-2.202753751e-010
	,-2.045112222e-010
	,-1.901393592e-010
	,-1.769587404e-010
	,-1.644027185e-010
	,-1.524189941e-010
	,-1.409187519e-010
	,-1.297702203e-010
	,-1.194649950e-010
	,-1.098670776e-010
	,-1.006438781e-010
	,-9.192402130e-011
	,-8.348608611e-011
	,-7.531919142e-011
	,-6.722823181e-011
	,-5.896225343e-011
	,-5.020725992e-011
	,-4.055959019e-011
	,-2.948884006e-011
	,-1.628689182e-011
	,1.937210333e-017
	,2.066584298e-011
	,4.747379866e-011
	,8.283543563e-011
	,1.300544043e-010
	,1.936575639e-010
	,2.798647833e-010
	,3.968093605e-010
	,5.535645175e-010
	,7.671315498e-010
	,1.058785682e-009
	,1.457689332e-009
	,2.002248511e-009
	,2.745680716e-009
	,3.763570746e-009
	,5.157905646e-009
	,7.067869472e-009
	,9.593215585e-009
	,1.293759803e-008
	,1.743682115e-008
	,2.345727657e-008
	,3.154208552e-008
	,4.238627719e-008
	,5.691505070e-008
	,7.636641829e-008
	,1.023714273e-007
	,1.370782273e-007
	,1.833008188e-007
	,2.447052204e-007
	,3.259602741e-007
	,4.330928065e-007
	,5.737929828e-007
	,7.575986920e-007
	,9.963655052e-007
	,1.304393137e-006
	,1.698648890e-006
	,2.197069878e-006
	,2.822948930e-006
	,3.599379669e-006
	,4.551537167e-006
	,5.706278401e-006
	,7.089680420e-006
	,8.719334291e-006
	,1.062082252e-005
	,1.281310055e-005
	,1.531133988e-005
	,1.812779106e-005
	,2.127112914e-005
	,2.474663279e-005
	,2.855661189e-005
	,3.270269942e-005
	,3.718253648e-005
	,4.199375742e-005
	,4.713098235e-005
	,5.259325585e-005
	,5.837749416e-005
	,6.447957505e-005
	,7.089531974e-005
	,7.762052646e-005
	,8.465078814e-005
	,9.193013389e-005
	,9.946317152e-005
	,1.072708198e-004
	,1.153497762e-004
	,1.236952683e-004
	,1.323010504e-004
	,1.410892603e-004
	,1.501087115e-004
	,1.593658907e-004
	,1.688554417e-004
	,1.785731086e-004
	,1.885164896e-004
	,1.986797499e-004
	,2.088490734e-004
	,2.190915219e-004
	,2.295292114e-004
	,2.401569003e-004
	,2.509695154e-004
	,2.619642701e-004
	,2.731361680e-004
	,2.844795885e-004
	,2.959903040e-004
	,3.076642580e-004
	,3.194975093e-004
	,3.314902715e-004
	,3.436370484e-004
	,3.559344100e-004
	,3.683687138e-004
	,3.809405066e-004
	,3.936526960e-004
	,4.064995172e-004
	,4.194787874e-004
	,4.325879053e-004
	,4.458244184e-004
	,4.591860204e-004
	,4.726705496e-004
	,4.862759859e-004
	,5.000004491e-004
	,5.138480306e-004
	,5.278137533e-004
	,5.418945144e-004
	,5.557182035e-004
	,5.693678709e-004
	,5.831196655e-004
	,5.969794591e-004
	,6.109466021e-004
	,6.250206100e-004
	,6.392008592e-004
	,6.534869918e-004
	,6.678799514e-004
	,6.823797256e-004
	,6.969863591e-004
	,7.116999480e-004
	,7.265205611e-004
	,7.414483935e-004
	,7.564836489e-004
	,7.716265105e-004
	,7.868771548e-004
	,8.022357401e-004
	,8.177023975e-004
	,8.332772226e-004
	,8.489676738e-004
	,8.647668241e-004
	,8.806745419e-004
	,8.966912220e-004
	,9.128163632e-004
	,9.288267008e-004
	,9.447893778e-004
	,9.608537992e-004
	,9.770173605e-004
	,9.932781746e-004
	,1.009634856e-003
	,1.026086356e-003
	,1.042631857e-003
	,1.059270720e-003
	,1.076002439e-003
	,1.092826602e-003
	,1.109741532e-003
	,1.126747255e-003
	,1.143844426e-003
	,1.161032780e-003
	,1.178312147e-003
	,1.195682344e-003
	,1.213143242e-003
	,1.230664203e-003
	,1.248241699e-003
	,1.265908155e-003
	,1.283663365e-003
	,1.301507106e-003
	,1.319444779e-003
	,1.337478735e-003
	,1.355601345e-003
	,1.373812336e-003
	,1.392111414e-003
	,1.410498266e-003
	,1.428972041e-003
	,1.447532185e-003
	,1.466171008e-003
	,1.484879877e-003
	,1.503673968e-003
	,1.522552869e-003
	,-3.412857025e-009
	,-2.418835799e-009
	,-1.719631753e-009
	,-1.227808254e-009
	,-8.814369204e-010
	,-6.374984373e-010
	,-4.647325271e-010
	,-3.424542514e-010
	,-2.554268773e-010
	,-1.931100526e-010
	,-1.482845816e-010
	,-1.159138740e-010
	,-9.233940607e-011
	,-7.498487324e-011
	,-6.202450278e-011
	,-5.221017140e-011
	,-4.467268160e-011
	,-3.877074603e-011
	,-3.407396432e-011
	,-3.025675566e-011
	,-2.710563300e-011
	,-2.428615437e-011
	,-2.187036717e-011
	,-1.979223023e-011
	,-1.798295375e-011
	,-1.639090343e-011
	,-1.495102556e-011
	,-1.358141358e-011
	,-1.234535421e-011
	,-1.122101395e-011
	,-1.018894603e-011
	,-9.231104767e-012
	,-8.316081504e-012
	,-7.414663739e-012
	,-6.543202556e-012
	,-5.675761669e-012
	,-4.780801189e-012
	,-3.821674205e-012
	,-2.749624936e-012
	,-1.501868210e-012
	,9.450993129e-018
	,1.864712138e-012
	,4.238124919e-012
	,7.317116720e-012
	,1.136809467e-011
	,1.675261562e-011
	,2.395866525e-011
	,3.365115339e-011
	,4.674013982e-011
	,6.446214843e-011
	,8.850268430e-011
	,1.211600446e-010
	,1.655687550e-010
	,2.260055415e-010
	,3.055031888e-010
	,4.129954380e-010
	,5.587707070e-010
	,7.566281236e-010
	,1.025385205e-009
	,1.390693391e-009
	,1.887464328e-009
	,2.563405750e-009
	,3.483476941e-009
	,4.713491393e-009
	,6.285099518e-009
	,8.381205426e-009
	,1.117654573e-008
	,1.490344319e-008
	,1.987103826e-008
	,2.649029392e-008
	,3.530612978e-008
	,4.704017973e-008
	,6.264606860e-008
	,8.338074769e-008
	,1.108955474e-007
	,1.473519464e-007
	,1.955659351e-007
	,2.591100803e-007
	,3.426135587e-007
	,4.520970002e-007
	,5.950725715e-007
	,7.809100379e-007
	,1.021136042e-006
	,1.329701016e-006
	,1.723188457e-006
	,2.220890080e-006
	,2.844710248e-006
	,3.618883206e-006
	,4.569411770e-006
	,5.723323350e-006
	,7.107719911e-006
	,8.748893240e-006
	,1.067127158e-005
	,1.289663939e-005
	,1.544357595e-005
	,1.832715432e-005
	,2.155889973e-005
	,2.514696490e-005
	,2.909645897e-005
	,3.340987746e-005
	,3.808755502e-005
	,4.312810098e-005
	,4.852880377e-005
	,5.428603935e-005
	,6.039547212e-005
	,6.685232703e-005
	,7.365155982e-005
	,8.078809588e-005
	,8.825671680e-005
	,9.605208684e-005
	,1.041535753e-004
	,1.125681618e-004
	,1.212904386e-004
	,1.303150151e-004
	,1.396374738e-004
	,1.492522668e-004
	,1.591527723e-004
	,1.693332261e-004
	,1.797894523e-004
	,1.902018096e-004
	,2.007694388e-004
	,2.115815658e-004
	,2.226319508e-004
	,2.339131834e-004
	,2.454191993e-004
	,2.570798382e-004
	,2.689146773e-004
	,2.809420571e-004
	,2.931581909e-004
	,3.055566574e-004
	,3.181316760e-004
	,3.308694587e-004
	,3.437725834e-004
	,3.568352906e-004
	,3.700522476e-004
	,3.834195278e-004
	,3.969331826e-004
	,4.105888173e-004
	,4.243829526e-004
	,4.383123852e-004
	,4.523738816e-004
	,4.665644185e-004
	,4.808869300e-004
	,4.953337752e-004
	,5.094268805e-004
	,5.232038454e-004
	,5.370973933e-004
	,5.511023200e-004
	,5.652169561e-004
	,5.794439945e-004
	,5.937825414e-004
	,6.082318065e-004
	,6.227904993e-004
	,6.374592651e-004
	,6.522378210e-004
	,6.671258953e-004
	,6.821232917e-004
	,6.972298682e-004
	,7.124455008e-004
	,7.277701904e-004
	,7.432039236e-004
	,7.587467075e-004
	,7.743985498e-004
	,7.901594512e-004
	,8.060340640e-004
	,8.220197861e-004
	,8.381148312e-004
	,8.543190874e-004
	,8.706323858e-004
	,8.870545127e-004
	,9.034221393e-004
	,9.197328373e-004
	,9.361443230e-004
	,9.526541933e-004
	,9.692607042e-004
	,9.859625383e-004
	,1.002758700e-003
	,1.019648407e-003
	,1.036631023e-003
	,1.053706028e-003
	,1.070872991e-003
	,1.088131549e-003
	,1.105480599e-003
	,1.122918937e-003
	,1.140447928e-003
	,1.158067340e-003
	,1.175776956e-003
	,1.193576470e-003
	,1.211465642e-003
	,1.229444374e-003
	,1.247512435e-003
	,1.265669591e-003
	,1.283918104e-003
	,1.302263275e-003
	,1.320698925e-003
	,1.339223447e-003
	,1.357836550e-003
	,1.376537951e-003
	,1.395327284e-003
	,1.414204192e-003
	,1.433168128e-003
	,-4.305683078e-009
	,-2.969818852e-009
	,-2.048481566e-009
	,-1.413214151e-009
	,-9.752657642e-010
	,-6.733857226e-010
	,-4.653100181e-010
	,-3.218865501e-010
	,-2.230118536e-010
	,-1.548305223e-010
	,-1.077928910e-010
	,-7.531624485e-011
	,-5.278008153e-011
	,-3.717950418e-011
	,-2.636405466e-011
	,-1.885107324e-011
	,-1.361072174e-011
	,-9.954219035e-012
	,-7.392938387e-012
	,-5.588498142e-012
	,-4.307801921e-012
	,-3.390116824e-012
	,-2.724967687e-012
	,-2.229552768e-012
	,-1.852305999e-012
	,-1.565176276e-012
	,-1.342445525e-012
	,-1.165972106e-012
	,-1.023294897e-012
	,-9.002041007e-013
	,-7.954259504e-013
	,-7.045455002e-013
	,-6.239078131e-013
	,-5.504720687e-013
	,-4.814723659e-013
	,-4.145082139e-013
	,-3.468898430e-013
	,-2.756972616e-013
	,-1.968945621e-013
	,-1.063397854e-013
	,4.072707070e-018
	,1.294592614e-013
	,2.919589008e-013
	,5.001845193e-013
	,7.716634813e-013
	,1.129756555e-012
	,1.606129418e-012
	,2.243578606e-012
	,3.100345319e-012
	,4.255274081e-012
	,5.815514239e-012
	,7.926802256e-012
	,1.078744154e-011
	,1.466712641e-011
	,1.993311688e-011
	,2.708541916e-011
	,3.680546396e-011
	,5.002181265e-011
	,6.800055776e-011
	,9.246826943e-011
	,1.247112868e-010
	,1.678367660e-010
	,2.262091902e-010
	,3.052920782e-010
	,4.125331987e-010
	,5.580754093e-010
	,7.557384091e-010
	,1.024356192e-009
	,1.389599670e-009
	,1.886459648e-009
	,2.517218517e-009
	,3.351416786e-009
	,4.462669814e-009
	,5.942998317e-009
	,7.914893973e-009
	,1.054132683e-008
	,1.403734676e-008
	,1.868903128e-008
	,2.487921507e-008
	,3.311325612e-008
	,4.405990804e-008
	,5.860252194e-008
	,7.790509201e-008
	,1.034969862e-007
	,1.373806261e-007
	,1.821035179e-007
	,2.409820093e-007
	,3.184169997e-007
	,4.199414066e-007
	,5.525573351e-007
	,7.250290031e-007
	,9.481852682e-007
	,1.235205977e-006
	,1.601855918e-006
	,2.066620607e-006
	,2.650693408e-006
	,3.377767545e-006
	,4.273603034e-006
	,5.365368134e-006
	,6.680794020e-006
	,8.247220613e-006
	,1.009062993e-005
	,1.223479150e-005
	,1.470059797e-005
	,1.750565347e-005
	,2.066411765e-005
	,2.418679509e-005
	,2.808142408e-005
	,3.235294759e-005
	,3.700405126e-005
	,4.203557151e-005
	,4.744687906e-005
	,5.323644504e-005
	,5.940173554e-005
	,6.593977356e-005
	,7.284734075e-005
	,8.012117234e-005
	,8.775782522e-005
	,9.575355917e-005
	,1.041044355e-004
	,1.128069016e-004
	,1.218576896e-004
	,1.312532023e-004
	,1.409899911e-004
	,1.510648056e-004
	,1.614746963e-004
	,1.718226715e-004
	,1.824023071e-004
	,1.932791389e-004
	,2.044460225e-004
	,2.158961760e-004
	,2.276231302e-004
	,2.396208893e-004
	,2.518848787e-004
	,2.644086793e-004
	,2.771856983e-004
	,2.902099345e-004
	,3.034774710e-004
	,3.169834944e-004
	,3.306285481e-004
	,3.443927632e-004
	,3.583551505e-004
	,3.725095997e-004
	,3.868515465e-004
	,4.012821259e-004
	,4.158580494e-004
	,4.306004733e-004
	,4.455069388e-004
	,4.601874853e-004
	,4.741639069e-004
	,4.882808934e-004
	,5.025370717e-004
	,5.169310164e-004
	,5.314568993e-004
	,5.461173689e-004
	,5.609118551e-004
	,5.758395981e-004
	,5.908998106e-004
	,6.060925885e-004
	,6.214178387e-004
	,6.368755070e-004
	,6.524656804e-004
	,6.681885816e-004
	,6.840445359e-004
	,6.999517171e-004
	,7.158343562e-004
	,7.318303124e-004
	,7.479389667e-004
	,7.641634587e-004
	,7.805011381e-004
	,7.969509253e-004
	,8.135124995e-004
	,8.301855230e-004
	,8.469696425e-004
	,8.638644776e-004
	,8.806964852e-004
	,8.975485781e-004
	,9.145008890e-004
	,9.315514168e-004
	,9.486986383e-004
	,9.659413560e-004
	,9.832785890e-004
	,1.000709521e-003
	,1.018233458e-003
	,1.035849793e-003
	,1.053558005e-003
	,1.071357642e-003
	,1.089248287e-003
	,1.107228470e-003
	,1.125297276e-003
	,1.143455905e-003
	,1.161704035e-003
	,1.180041353e-003
	,1.198467548e-003
	,1.216982309e-003
	,1.235586714e-003
	,1.254280128e-003
	,1.273066033e-003
	,1.291942690e-003
	,1.310907082e-003
	,1.329958866e-003
	,-4.866105007e-009
	,-3.344563732e-009
	,-2.298575705e-009
	,-1.579634077e-009
	,-1.085539885e-009
	,-7.459997131e-010
	,-5.126839519e-010
	,-3.523697469e-010
	,-2.422178091e-010
	,-1.665310382e-010
	,-1.145235614e-010
	,-7.878510223e-011
	,-5.422431848e-011
	,-3.734305008e-011
	,-2.573667775e-011
	,-1.775235624e-011
	,-1.226061336e-011
	,-8.480624475e-012
	,-5.875691778e-012
	,-4.081366522e-012
	,-2.844409708e-012
	,-1.990775769e-012
	,-1.400899871e-012
	,-9.923048997e-013
	,-7.084965563e-013
	,-5.110312694e-013
	,-3.721383374e-013
	,-2.745341420e-013
	,-2.056097352e-013
	,-1.564726695e-013
	,-1.211652659e-013
	,-9.517754429e-014
	,-7.567483472e-014
	,-6.081823328e-014
	,-4.909471843e-014
	,-3.952570321e-014
	,-3.127744884e-014
	,-2.372905047e-014
	,-1.634884102e-014
	,-8.614343508e-015
	,-1.122668919e-017
	,1.014208971e-014
	,2.249930241e-014
	,3.810839395e-014
	,5.806768346e-014
	,8.346583001e-014
	,1.167386228e-013
	,1.607415662e-013
	,2.192687017e-013
	,2.975290298e-013
	,4.023352724e-013
	,5.431231887e-013
	,7.325783800e-013
	,9.877747115e-013
	,1.332122766e-012
	,1.797058364e-012
	,2.425343893e-012
	,3.275131157e-012
	,4.425123226e-012
	,5.982516391e-012
	,8.092812558e-012
	,1.095394874e-011
	,1.483513336e-011
	,2.010264934e-011
	,2.725544715e-011
	,3.697289695e-011
	,4.983927816e-011
	,6.678022747e-011
	,8.964052202e-011
	,1.205251736e-010
	,1.622962422e-010
	,2.188472632e-010
	,2.954772390e-010
	,3.994006367e-010
	,5.404427905e-010
	,7.319878062e-010
	,9.819942831e-010
	,1.305342269e-009
	,1.735596707e-009
	,2.308185834e-009
	,3.070281564e-009
	,4.084681411e-009
	,5.434963815e-009
	,7.232327397e-009
	,9.624653610e-009
	,1.280849543e-008
	,1.704490859e-008
	,2.268030428e-008
	,3.017383581e-008
	,4.013323825e-008
	,5.336152132e-008
	,7.091745641e-008
	,9.419342787e-008
	,1.249640792e-007
	,1.655425716e-007
	,2.190645324e-007
	,2.894902317e-007
	,3.818921041e-007
	,5.027107093e-007
	,6.600396550e-007
	,8.639268511e-007
	,1.126670452e-006
	,1.463077186e-006
	,1.890640918e-006
	,2.429592727e-006
	,3.102773795e-006
	,3.935294729e-006
	,4.953969302e-006
	,6.186545229e-006
	,7.660795715e-006
	,9.403569386e-006
	,1.143989673e-005
	,1.379225544e-005
	,1.648007964e-005
	,1.951952088e-005
	,2.292345093e-005
	,2.670166625e-005
	,3.086123944e-005
	,3.540685380e-005
	,4.034134596e-005
	,4.566604745e-005
	,5.138124730e-005
	,5.748661295e-005
	,6.398134230e-005
	,7.086444854e-005
	,7.813494632e-005
	,8.579206591e-005
	,9.383562400e-005
	,1.022457806e-004
	,1.109987367e-004
	,1.201190568e-004
	,1.296039675e-004
	,1.394506885e-004
	,1.495494887e-004
	,1.596207926e-004
	,1.700181112e-004
	,1.807337052e-004
	,1.917615138e-004
	,2.030938896e-004
	,2.147227146e-004
	,2.266408246e-004
	,2.388422810e-004
	,2.513205670e-004
	,2.640693655e-004
	,2.770824690e-004
	,2.903537810e-004
	,3.038774087e-004
	,3.176474028e-004
	,3.316584273e-004
	,3.459058077e-004
	,3.603840116e-004
	,3.750890409e-004
	,3.900160913e-004
	,4.051602298e-004
	,4.205167473e-004
	,4.348286220e-004
	,4.490731578e-004
	,4.634879311e-004
	,4.780709832e-004
	,4.928194563e-004
	,5.077319848e-004
	,5.228083544e-004
	,5.380475062e-004
	,5.534488768e-004
	,5.690117265e-004
	,5.847356962e-004
	,6.006202989e-004
	,6.166652657e-004
	,6.328705348e-004
	,6.492361855e-004
	,6.657624196e-004
	,6.824496073e-004
	,6.991611823e-004
	,7.160109381e-004
	,7.330158543e-004
	,7.501766162e-004
	,7.674940052e-004
	,7.849689039e-004
	,8.026022986e-004
	,8.200125083e-004
	,8.374901492e-004
	,8.549348333e-004
	,8.724876105e-004
	,8.901605512e-004
	,9.079526441e-004
	,9.258632179e-004
	,9.438918568e-004
	,9.620383453e-004
	,9.803026387e-004
	,9.986848441e-004
	,1.017185209e-003
	,1.035804115e-003
	,1.054542079e-003
	,1.073399750e-003
	,1.092377950e-003
	,1.111475731e-003
	,1.130694714e-003
	,1.149824688e-003
	,1.168894062e-003
	,1.188055030e-003
	,1.207307135e-003
	,-5.539982573e-009
	,-3.815188323e-009
	,-2.626414748e-009
	,-1.807519319e-009
	,-1.243654209e-009
	,-8.555255247e-010
	,-5.884384825e-010
	,-4.046856766e-010
	,-2.782883028e-010
	,-1.913562252e-010
	,-1.315739427e-010
	,-9.046585845e-011
	,-6.220081829e-011
	,-4.276729928e-011
	,-2.940637193e-011
	,-2.022082939e-011
	,-1.390578480e-011
	,-9.563870604e-012
	,-6.578592514e-012
	,-4.526076475e-012
	,-3.114764713e-012
	,-2.144275395e-012
	,-1.476829312e-012
	,-1.017624722e-012
	,-7.015061942e-013
	,-4.839884117e-013
	,-3.342549436e-013
	,-2.311207736e-013
	,-1.599957079e-013
	,-1.108786411e-013
	,-7.699648325e-014
	,-5.350172780e-014
	,-3.718635764e-014
	,-2.583211696e-014
	,-1.789966719e-014
	,-1.230750289e-014
	,-8.325430336e-015
	,-5.393011242e-015
	,-3.188070608e-015
	,-1.459969860e-015
	,-1.832811544e-017
	,1.307915453e-015
	,2.708828430e-015
	,4.153342075e-015
	,5.936374444e-015
	,8.075626885e-015
	,1.079724849e-014
	,1.434336658e-014
	,1.903244877e-014
	,2.526269712e-014
	,3.337304806e-014
	,4.376817846e-014
	,5.755283005e-014
	,7.597518294e-014
	,1.005415749e-013
	,1.333763246e-013
	,1.773908079e-013
	,2.364757708e-013
	,3.157235104e-013
	,4.222651641e-013
	,5.655534612e-013
	,7.585306467e-013
	,1.018558977e-012
	,1.369297427e-012
	,1.842593910e-012
	,2.481975522e-012
	,3.346044694e-012
	,4.514658113e-012
	,6.096083444e-012
	,8.237471535e-012
	,1.113886163e-011
	,1.507231834e-011
	,2.032423885e-011
	,2.709849539e-011
	,3.620646038e-011
	,4.846951078e-011
	,6.500208804e-011
	,8.731785499e-011
	,1.174734508e-010
	,1.582646811e-010
	,2.134944121e-010
	,2.883368763e-010
	,3.886023397e-010
	,5.154566812e-010
	,6.839659308e-010
	,9.078654925e-010
	,1.205431359e-009
	,1.600981383e-009
	,2.126872637e-009
	,2.826155482e-009
	,3.756100513e-009
	,4.992880289e-009
	,6.637779633e-009
	,8.825423282e-009
	,1.173466224e-008
	,1.560295224e-008
	,2.074530471e-008
	,2.757920023e-008
	,3.665723542e-008
	,4.870973980e-008
	,6.470014912e-008
	,8.585563499e-008
	,1.137711068e-007
	,1.506601550e-007
	,1.993196760e-007
	,2.633649343e-007
	,3.474374704e-007
	,4.574482374e-007
	,6.008523680e-007
	,7.869457847e-007
	,1.027165446e-006
	,1.335365217e-006
	,1.728028784e-006
	,2.224372930e-006
	,2.846292446e-006
	,3.618103422e-006
	,4.566064178e-006
	,5.717684899e-006
	,7.100867687e-006
	,8.742966498e-006
	,1.066986861e-005
	,1.290519948e-005
	,1.546973329e-005
	,1.838105124e-005
	,2.165344758e-005
	,2.529805022e-005
	,2.932313632e-005
	,3.373446899e-005
	,3.853570566e-005
	,4.372889027e-005
	,4.931480791e-005
	,5.529336087e-005
	,6.166385766e-005
	,6.842525677e-005
	,7.557635682e-005
	,8.311593987e-005
	,9.104287456e-005
	,9.935614724e-005
	,1.080552908e-004
	,1.171396372e-004
	,1.266087208e-004
	,1.363552400e-004
	,1.460939242e-004
	,1.561856393e-004
	,1.666253091e-004
	,1.774080482e-004
	,1.885294109e-004
	,1.999853911e-004
	,2.117724089e-004
	,2.238874273e-004
	,2.363281063e-004
	,2.490919178e-004
	,2.621161156e-004
	,2.752880087e-004
	,2.887320340e-004
	,3.024424835e-004
	,3.164145402e-004
	,3.306412767e-004
	,3.451171773e-004
	,3.598368506e-004
	,3.747941235e-004
	,3.899846358e-004
	,4.044302324e-004
	,4.184601597e-004
	,4.326688236e-004
	,4.470542664e-004
	,4.616126270e-004
	,4.763430316e-004
	,4.912436780e-004
	,5.063130468e-004
	,5.215494474e-004
	,5.369513507e-004
	,5.525174187e-004
	,5.682464478e-004
	,5.841373628e-004
	,6.001892174e-004
	,6.164018974e-004
	,6.327750323e-004
	,6.493070308e-004
	,6.659973581e-004
	,6.828455631e-004
	,6.998512716e-004
	,7.170141813e-004
	,7.343340892e-004
	,7.518107775e-004
	,7.694441157e-004
	,7.872340269e-004
	,8.051287829e-004
	,8.231373031e-004
	,8.412985729e-004
	,8.596121867e-004
	,8.780779675e-004
	,8.966959252e-004
	,9.154662249e-004
	,9.343891708e-004
	,9.534651961e-004
	,9.726948580e-004
	,9.919496440e-004
	,1.011255692e-003
	,1.030707565e-003
	,1.050306065e-003
	,-6.238537230e-009
	,-4.318842456e-009
	,-2.987211160e-009
	,-2.064420517e-009
	,-1.425577331e-009
	,-9.837303946e-010
	,-6.784061431e-010
	,-4.675930612e-010
	,-3.221424298e-010
	,-2.218518932e-010
	,-1.527365511e-010
	,-1.051265726e-010
	,-7.234234481e-011
	,-4.977374588e-011
	,-3.424127800e-011
	,-2.355329945e-011
	,-1.620001344e-011
	,-1.114155855e-011
	,-7.662155179e-012
	,-5.268967380e-012
	,-3.623152581e-012
	,-2.491203199e-012
	,-1.712779369e-012
	,-1.177447907e-012
	,-8.092889266e-013
	,-5.561381713e-013
	,-3.820610663e-013
	,-2.623172869e-013
	,-1.800149941e-013
	,-1.232984612e-013
	,-8.436248984e-014
	,-5.752975076e-014
	,-3.908745122e-014
	,-2.633725812e-014
	,-1.757749220e-014
	,-1.147689710e-014
	,-7.332849369e-015
	,-4.423509910e-015
	,-2.409315674e-015
	,-9.947742247e-016
	,9.189911274e-018
	,7.386003765e-016
	,1.293712600e-015
	,1.702096826e-015
	,2.069804500e-015
	,2.396835622e-015
	,2.766266436e-015
	,3.148594694e-015
	,3.611597242e-015
	,4.119766949e-015
	,4.856696572e-015
	,5.758421056e-015
	,6.979970804e-015
	,8.564111021e-015
	,1.069521771e-014
	,1.346775028e-014
	,1.711657796e-014
	,2.169047085e-014
	,2.777341681e-014
	,3.579677528e-014
	,4.651742253e-014
	,6.075891514e-014
	,7.974452600e-014
	,1.051150501e-013
	,1.390951658e-013
	,1.844818430e-013
	,2.453930735e-013
	,3.270503375e-013
	,4.367075853e-013
	,5.841638975e-013
	,7.824855850e-013
	,1.049465532e-012
	,1.409329524e-012
	,1.894611179e-012
	,2.549527474e-012
	,3.434105512e-012
	,4.629771136e-012
	,6.246879046e-012
	,8.434275136e-012
	,1.118360928e-011
	,1.486479941e-011
	,1.980194607e-011
	,2.643334093e-011
	,3.535361209e-011
	,4.736890590e-011
	,6.357313116e-011
	,8.545178105e-011
	,1.150228992e-010
	,1.550296703e-010
	,2.059163682e-010
	,2.725718683e-010
	,3.609621603e-010
	,4.782132635e-010
	,6.337967512e-010
	,8.403029105e-010
	,1.114469856e-009
	,1.478547945e-009
	,1.962125091e-009
	,2.604535775e-009
	,3.458069944e-009
	,4.592230239e-009
	,6.099376730e-009
	,8.102205844e-009
	,1.076364655e-008
	,1.429993608e-008
	,1.899786529e-008
	,2.523747444e-008
	,3.352184215e-008
	,4.451606595e-008
	,5.906510469e-008
	,7.825857692e-008
	,1.036516830e-007
	,1.372020448e-007
	,1.814574439e-007
	,2.397165489e-007
	,3.162234968e-007
	,4.163978264e-007
	,5.470978651e-007
	,7.169103043e-007
	,9.364511726e-007
	,1.218654122e-006
	,1.579011155e-006
	,2.035722168e-006
	,2.609704707e-006
	,3.324418409e-006
	,4.205473860e-006
	,5.280022838e-006
	,6.575962680e-006
	,8.121024223e-006
	,9.941842165e-006
	,1.206310968e-005
	,1.450690874e-005
	,1.729227330e-005
	,2.043500008e-005
	,2.394768655e-005
	,2.783994835e-005
	,3.211876108e-005
	,3.678890424e-005
	,4.185333118e-005
	,4.731354285e-005
	,5.317003823e-005
	,5.942258689e-005
	,6.607049126e-005
	,7.311284659e-005
	,8.054876782e-005
	,8.837700875e-005
	,9.659635678e-005
	,1.052061193e-004
	,1.142055729e-004
	,1.235231872e-004
	,1.328092153e-004
	,1.424535161e-004
	,1.524496937e-004
	,1.627918290e-004
	,1.734744087e-004
	,1.844921704e-004
	,1.958400985e-004
	,2.075134186e-004
	,2.195075760e-004
	,2.318190654e-004
	,2.444436901e-004
	,2.573770721e-004
	,2.706156476e-004
	,2.841561570e-004
	,2.979956796e-004
	,3.121315083e-004
	,3.265615598e-004
	,3.412842551e-004
	,3.562984641e-004
	,3.716029259e-004
	,3.857204103e-004
	,3.998039512e-004
	,4.141053981e-004
	,4.286188085e-004
	,4.430803462e-004
	,4.577230754e-004
	,4.725447879e-004
	,4.875433810e-004
	,5.027169748e-004
	,5.180638237e-004
	,5.335833033e-004
	,5.492732958e-004
	,5.651321471e-004
	,5.811585930e-004
	,5.973514580e-004
	,6.137096822e-004
	,6.302322848e-004
	,6.469183624e-004
	,6.637670827e-004
	,6.807776779e-004
	,6.979494380e-004
	,7.152817046e-004
	,7.327738656e-004
	,7.504253496e-004
	,7.681639163e-004
	,7.860568127e-004
	,8.041036739e-004
	,8.223036503e-004
	,8.406560337e-004
	,8.591602031e-004
	,8.778156356e-004
	,-6.745292169e-009
	,-4.697542552e-009
	,-3.269243979e-009
	,-2.273621752e-009
	,-1.580048495e-009
	,-1.097213520e-009
	,-7.613227967e-010
	,-5.278300231e-010
	,-3.656468548e-010
	,-2.530885728e-010
	,-1.750381767e-010
	,-1.209639714e-010
	,-8.353380853e-011
	,-5.764722343e-011
	,-3.975895158e-011
	,-2.740724525e-011
	,-1.888423090e-011
	,-1.300673045e-011
	,-8.955686341e-012
	,-6.164639569e-012
	,-4.242424102e-012
	,-2.918879233e-012
	,-2.007842637e-012
	,-1.380832650e-012
	,-9.493434117e-013
	,-6.523860988e-013
	,-4.481421873e-013
	,-3.076384848e-013
	,-2.109353872e-013
	,-1.444537144e-013
	,-9.867645877e-014
	,-6.719860368e-014
	,-4.551382425e-014
	,-3.062093243e-014
	,-2.039983918e-014
	,-1.332660977e-014
	,-8.390439716e-015
	,-5.048696502e-015
	,-2.730864077e-015
	,-1.097797122e-015
	,-1.143555467e-017
	,7.894069040e-016
	,1.340916198e-015
	,1.712957831e-015
	,2.028971299e-015
	,2.210945347e-015
	,2.394538102e-015
	,2.527846493e-015
	,2.644497863e-015
	,2.784333300e-015
	,2.908973774e-015
	,3.024110869e-015
	,3.182013170e-015
	,3.314747181e-015
	,3.555516861e-015
	,3.831375941e-015
	,4.183157622e-015
	,4.640938533e-015
	,5.238346016e-015
	,5.977364294e-015
	,6.983678166e-015
	,8.304961180e-015
	,1.002105216e-014
	,1.210276216e-014
	,1.488025529e-014
	,1.851038951e-014
	,2.329372226e-014
	,2.958652581e-014
	,3.800860847e-014
	,4.917633228e-014
	,6.404640555e-014
	,8.378017255e-014
	,1.101634853e-013
	,1.454653018e-013
	,1.926429483e-013
	,2.557959841e-013
	,3.405205421e-013
	,4.541245120e-013
	,6.067036677e-013
	,8.118276339e-013
	,1.087874954e-012
	,1.459639161e-012
	,1.960807593e-012
	,2.636925614e-012
	,3.549878968e-012
	,4.702672915e-012
	,6.214315455e-012
	,8.232585388e-012
	,1.093245575e-011
	,1.455020085e-011
	,1.940539084e-011
	,2.593045317e-011
	,3.471218167e-011
	,4.654605429e-011
	,6.251156997e-011
	,8.335529768e-011
	,1.100268834e-010
	,1.453126291e-010
	,1.920144562e-010
	,2.538507817e-010
	,3.357567377e-010
	,4.442854067e-010
	,5.881383539e-010
	,7.788722689e-010
	,1.031837820e-009
	,1.367426917e-009
	,1.812718405e-009
	,2.403704753e-009
	,3.188193669e-009
	,4.229686952e-009
	,5.612520047e-009
	,7.448670637e-009
	,9.886769281e-009
	,1.312401164e-008
	,1.742188354e-008
	,2.312688466e-008
	,3.069779175e-008
	,4.071492775e-008
	,5.391627635e-008
	,7.139248575e-008
	,9.450526172e-008
	,1.250356784e-007
	,1.653041509e-007
	,2.183192416e-007
	,2.879592617e-007
	,3.791888080e-007
	,4.983097406e-007
	,6.532418099e-007
	,8.538210681e-007
	,1.112095622e-006
	,1.442588105e-006
	,1.862484392e-006
	,2.391701346e-006
	,3.052786829e-006
	,3.870613603e-006
	,4.871855172e-006
	,6.084261158e-006
	,7.535788236e-006
	,9.253674808e-006
	,1.126356109e-005
	,1.358875102e-005
	,1.624968599e-005
	,1.926366138e-005
	,2.264477783e-005
	,2.640412205e-005
	,3.054998326e-005
	,3.508827982e-005
	,4.002298136e-005
	,4.535651142e-005
	,5.109008983e-005
	,5.722410168e-005
	,6.375835551e-005
	,7.069230819e-005
	,7.802523580e-005
	,8.575635799e-005
	,9.388492286e-005
	,1.024102656e-004
	,1.113023252e-004
	,1.201351462e-004
	,1.293342234e-004
	,1.388927808e-004
	,1.488045438e-004
	,1.590641302e-004
	,1.696654907e-004
	,1.806029756e-004
	,1.918712303e-004
	,2.034650477e-004
	,2.153793613e-004
	,2.276092457e-004
	,2.401499259e-004
	,2.529967888e-004
	,2.661453989e-004
	,2.795915164e-004
	,2.933311165e-004
	,3.073603136e-004
	,3.216754480e-004
	,3.362734384e-004
	,3.511513233e-004
	,3.652646808e-004
	,3.789713481e-004
	,3.928857239e-004
	,4.070070484e-004
	,4.213338617e-004
	,4.358649231e-004
	,4.505996162e-004
	,4.655374675e-004
	,4.806782735e-004
	,4.960221133e-004
	,5.115693646e-004
	,5.273207228e-004
	,5.432772267e-004
	,5.594402850e-004
	,5.758117310e-004
	,5.923938734e-004
	,6.091115850e-004
	,6.257194351e-004
	,6.424965372e-004
	,6.594419863e-004
	,6.765549309e-004
	,6.938345695e-004
	,7.112627345e-004
	,-7.083941855e-009
	,-4.950642863e-009
	,-3.458254183e-009
	,-2.414702375e-009
	,-1.685288319e-009
	,-1.175657823e-009
	,-8.197383849e-010
	,-5.712769449e-010
	,-3.979085546e-010
	,-2.769949610e-010
	,-1.927074281e-010
	,-1.339823873e-010
	,-9.309062679e-011
	,-6.463400206e-011
	,-4.484380978e-011
	,-3.108994146e-011
	,-2.153801624e-011
	,-1.490920959e-011
	,-1.031253194e-011
	,-7.127634167e-012
	,-4.922742773e-012
	,-3.397440901e-012
	,-2.343137470e-012
	,-1.614971112e-012
	,-1.112380880e-012
	,-7.656392269e-013
	,-5.266134173e-013
	,-3.618418437e-013
	,-2.483628276e-013
	,-1.701662557e-013
	,-1.163183336e-013
	,-7.921458241e-014
	,-5.373315075e-014
	,-3.614766962e-014
	,-2.401232427e-014
	,-1.567462326e-014
	,-9.930143803e-015
	,-5.975902575e-015
	,-3.221071354e-015
	,-1.315121651e-015
	,6.631309167e-018
	,9.303388853e-016
	,1.586333135e-015
	,1.994247413e-015
	,2.330468616e-015
	,2.609251813e-015
	,2.756240893e-015
	,2.897538389e-015
	,2.986985030e-015
	,3.121024450e-015
	,3.176895966e-015
	,3.189114596e-015
	,3.247126983e-015
	,3.329367765e-015
	,3.434427100e-015
	,3.471344073e-015
	,3.552383879e-015
	,3.634937959e-015
	,3.762241468e-015
	,3.872731305e-015
	,3.955285386e-015
	,4.127860487e-015
	,4.332809737e-015
	,4.547105717e-015
	,4.857218736e-015
	,5.255055255e-015
	,5.739936462e-015
	,6.423187656e-015
	,7.265072181e-015
	,8.220005146e-015
	,9.518939554e-015
	,1.119482393e-014
	,1.340655269e-014
	,1.628988840e-014
	,2.010606955e-014
	,2.511748339e-014
	,3.176990108e-014
	,4.056303327e-014
	,5.226555713e-014
	,6.782264117e-014
	,8.851499628e-014
	,1.160969358e-013
	,1.529668621e-013
	,2.022726912e-013
	,2.682836333e-013
	,3.567064679e-013
	,4.753217994e-013
	,6.345009476e-013
	,8.484704190e-013
	,1.136247781e-012
	,1.523835323e-012
	,2.018679727e-012
	,2.650371695e-012
	,3.489811345e-012
	,4.607784859e-012
	,6.099027299e-012
	,8.092059755e-012
	,1.076043790e-011
	,1.433881943e-011
	,1.914489507e-011
	,2.560860739e-011
	,3.426096174e-011
	,4.507789248e-011
	,5.935013401e-011
	,7.819109915e-011
	,1.030755534e-010
	,1.359565071e-010
	,1.794181511e-010
	,2.368960537e-010
	,3.129413394e-010
	,4.135903148e-010
	,5.468513742e-010
	,7.233462537e-010
	,9.571786679e-010
	,1.267066526e-009
	,1.677855580e-009
	,2.222528369e-009
	,2.944869652e-009
	,3.903001627e-009
	,5.174071468e-009
	,6.860462907e-009
	,9.098020826e-009
	,1.206693132e-008
	,1.600610933e-008
	,2.123220301e-008
	,2.814342893e-008
	,3.723512855e-008
	,4.927289166e-008
	,6.520026617e-008
	,8.625575475e-008
	,1.140599973e-007
	,1.507263962e-007
	,1.989986432e-007
	,2.624193901e-007
	,3.455334253e-007
	,4.541257848e-007
	,5.954917965e-007
	,7.787300877e-007
	,1.015041600e-006
	,1.318007977e-006
	,1.703812425e-006
	,2.191358347e-006
	,2.802237657e-006
	,3.560507568e-006
	,4.492252992e-006
	,5.624937902e-006
	,6.986591965e-006
	,8.604904199e-006
	,1.050632444e-005
	,1.271527293e-005
	,1.525352703e-005
	,1.813984949e-005
	,2.138985015e-005
	,2.501606542e-005
	,2.902818042e-005
	,3.343337851e-005
	,3.823674218e-005
	,4.344165243e-005
	,4.905016967e-005
	,5.506339514e-005
	,6.148174793e-005
	,6.830520999e-005
	,7.553351397e-005
	,8.316641278e-005
	,9.120365344e-005
	,9.964468964e-005
	,1.080347162e-004
	,1.167767336e-004
	,1.258872076e-004
	,1.353595819e-004
	,1.451877638e-004
	,1.553658144e-004
	,1.658879639e-004
	,1.767485756e-004
	,1.879421231e-004
	,1.994631798e-004
	,2.113064159e-004
	,2.234666033e-004
	,2.359386242e-004
	,2.487174836e-004
	,2.617983241e-004
	,2.751764422e-004
	,2.888473048e-004
	,3.028065799e-004
	,3.170508143e-004
	,3.315754223e-004
	,3.456069370e-004
	,3.589984004e-004
	,3.725964734e-004
	,3.863996150e-004
	,4.004060154e-004
	,4.146139188e-004
	,4.290209643e-004
	,4.436263379e-004
	,4.584289803e-004
	,4.734278902e-004
	,4.886222545e-004
	,5.040114479e-004
	,5.195950278e-004
	,5.353727388e-004
	,5.513445195e-004
	,-7.331589513e-009
	,-5.134094600e-009
	,-3.594177868e-009
	,-2.515387433e-009
	,-1.759867683e-009
	,-1.230901566e-009
	,-8.606597422e-010
	,-6.015887024e-010
	,-4.203595803e-010
	,-2.936211595e-010
	,-2.050188482e-010
	,-1.430985217e-010
	,-9.983971123e-011
	,-6.962865189e-011
	,-4.853768771e-011
	,-3.381917700e-011
	,-2.355201341e-011
	,-1.639299924e-011
	,-1.140354499e-011
	,-7.927784133e-012
	,-5.507798161e-012
	,-3.823782859e-012
	,-2.652589638e-012
	,-1.838617791e-012
	,-1.273212258e-012
	,-8.807542863e-013
	,-6.085375070e-013
	,-4.198793463e-013
	,-2.892050098e-013
	,-1.987785287e-013
	,-1.362055645e-013
	,-9.304105931e-014
	,-6.312483918e-014
	,-4.254427931e-014
	,-2.830482314e-014
	,-1.847342066e-014
	,-1.174748233e-014
	,-7.027853554e-015
	,-3.762972836e-015
	,-1.524457077e-015
	,1.112191694e-017
	,1.085473719e-015
	,1.838590416e-015
	,2.377881080e-015
	,2.741881392e-015
	,3.033875330e-015
	,3.211254337e-015
	,3.381688567e-015
	,3.473693810e-015
	,3.594940220e-015
	,3.674883481e-015
	,3.720572805e-015
	,3.799889470e-015
	,3.840148291e-015
	,3.903591180e-015
	,3.958575017e-015
	,3.981602436e-015
	,4.031312420e-015
	,4.098044940e-015
	,4.132559960e-015
	,4.162271074e-015
	,4.246757160e-015
	,4.268949117e-015
	,4.351555414e-015
	,4.393276293e-015
	,4.466796941e-015
	,4.589609842e-015
	,4.650807427e-015
	,4.774716872e-015
	,4.895649984e-015
	,5.105873087e-015
	,5.290196871e-015
	,5.545221620e-015
	,5.898674225e-015
	,6.325334180e-015
	,6.809693223e-015
	,7.464120982e-015
	,8.265851119e-015
	,9.345946722e-015
	,1.069485219e-014
	,1.248681356e-014
	,1.478965989e-014
	,1.782416198e-014
	,2.184915639e-014
	,2.714786470e-014
	,3.417994761e-014
	,4.343848430e-014
	,5.576504600e-014
	,7.220030494e-014
	,9.400533867e-014
	,1.231921483e-013
	,1.620871299e-013
	,2.141599565e-013
	,2.836701265e-013
	,3.767913378e-013
	,5.017252677e-013
	,6.694900402e-013
	,8.872983025e-013
	,1.156240907e-012
	,1.511896990e-012
	,1.983300682e-012
	,2.609349784e-012
	,3.442507231e-012
	,4.553322193e-012
	,6.036317371e-012
	,8.020706608e-012
	,1.068050952e-011
	,1.425075256e-011
	,1.878179935e-011
	,2.463957705e-011
	,3.234981776e-011
	,4.250420522e-011
	,5.588504742e-011
	,7.352683535e-011
	,9.679449324e-011
	,1.274994750e-010
	,1.680400481e-010
	,2.215910309e-010
	,2.923585036e-010
	,3.859153985e-010
	,5.096486381e-010
	,6.733508806e-010
	,8.900071936e-010
	,1.176838253e-009
	,1.556685432e-009
	,2.059848484e-009
	,2.726523637e-009
	,3.609979179e-009
	,4.780970027e-009
	,6.333340928e-009
	,8.391560862e-009
	,1.112071650e-008
	,1.473974200e-008
	,1.952203160e-008
	,2.579652181e-008
	,3.410249586e-008
	,4.509243496e-008
	,5.962485484e-008
	,7.882682502e-008
	,1.041739301e-007
	,1.375915889e-007
	,1.815819600e-007
	,2.393805956e-007
	,3.151463054e-007
	,4.141859635e-007
	,5.432127944e-007
	,7.106316918e-007
	,9.268377391e-007
	,1.204505202e-006
	,1.558834045e-006
	,2.007711915e-006
	,2.571744488e-006
	,3.274109547e-006
	,4.140204212e-006
	,5.197076774e-006
	,6.472683132e-006
	,7.995008360e-006
	,9.791166372e-006
	,1.188656508e-005
	,1.430422807e-005
	,1.706433172e-005
	,2.018397749e-005
	,2.367720038e-005
	,2.755512636e-005
	,3.182625056e-005
	,3.649685202e-005
	,4.157137359e-005
	,4.705280766e-005
	,5.294305978e-005
	,5.924332886e-005
	,6.595421834e-005
	,7.307600035e-005
	,8.060881237e-005
	,8.855273727e-005
	,9.652472957e-005
	,1.047931131e-004
	,1.134391587e-004
	,1.224563433e-004
	,1.318383356e-004
	,1.415791561e-004
	,1.516729323e-004
	,1.621138817e-004
	,1.728963044e-004
	,1.840145704e-004
	,1.954632922e-004
	,2.072371858e-004
	,2.193305156e-004
	,2.317379499e-004
	,2.444542581e-004
	,2.574743257e-004
	,2.707931711e-004
	,2.844060313e-004
	,2.983083367e-004
	,3.124944672e-004
	,3.264334148e-004
	,3.395228359e-004
	,3.528216160e-004
	,3.663271515e-004
	,3.800366636e-004
	,3.939485180e-004
	,4.080606907e-004
	,-7.527067260e-009
	,-5.278431347e-009
	,-3.700538324e-009
	,-2.593730753e-009
	,-1.817550582e-009
	,-1.273356043e-009
	,-8.918946602e-010
	,-6.245597724e-010
	,-4.372497789e-010
	,-3.060428253e-010
	,-2.141565518e-010
	,-1.498216710e-010
	,-1.047871121e-010
	,-7.327008307e-011
	,-5.121827446e-011
	,-3.579278826e-011
	,-2.500524938e-011
	,-1.746309280e-011
	,-1.219139581e-011
	,-8.507694694e-012
	,-5.934360942e-012
	,-4.137330147e-012
	,-2.882876464e-012
	,-2.007465844e-012
	,-1.396878270e-012
	,-9.711600897e-013
	,-6.744529454e-013
	,-4.677736102e-013
	,-3.238848249e-013
	,-2.237344548e-013
	,-1.540767736e-013
	,-1.056652543e-013
	,-7.205817232e-014
	,-4.866085262e-014
	,-3.249231489e-014
	,-2.126804076e-014
	,-1.351531973e-014
	,-8.115624963e-015
	,-4.379125996e-015
	,-1.781048316e-015
	,9.397248922e-019
	,1.259406446e-015
	,2.129487810e-015
	,2.736868620e-015
	,3.186451561e-015
	,3.460639718e-015
	,3.702401508e-015
	,3.860460459e-015
	,3.989121593e-015
	,4.080239158e-015
	,4.165508489e-015
	,4.255999457e-015
	,4.299443477e-015
	,4.338449105e-015
	,4.405912654e-015
	,4.468258999e-015
	,4.498283412e-015
	,4.566216908e-015
	,4.615874676e-015
	,4.645481357e-015
	,4.688873160e-015
	,4.736651138e-015
	,4.785786742e-015
	,4.792574870e-015
	,4.892464785e-015
	,4.946404295e-015
	,5.012666868e-015
	,5.039088350e-015
	,5.082741235e-015
	,5.141902382e-015
	,5.194745348e-015
	,5.315312945e-015
	,5.350297913e-015
	,5.470969942e-015
	,5.527938002e-015
	,5.613259549e-015
	,5.748238864e-015
	,5.925826737e-015
	,6.068272993e-015
	,6.299591510e-015
	,6.523965249e-015
	,6.781809682e-015
	,7.112443733e-015
	,7.588030427e-015
	,8.061893980e-015
	,8.790573416e-015
	,9.636008654e-015
	,1.081103362e-014
	,1.221340865e-014
	,1.411742635e-014
	,1.657827941e-014
	,1.982279574e-014
	,2.412291820e-014
	,2.977476582e-014
	,3.721763491e-014
	,4.711216698e-014
	,6.021946783e-014
	,7.770860976e-014
	,1.008713213e-013
	,1.318015311e-013
	,1.731225896e-013
	,2.283729390e-013
	,3.023836379e-013
	,4.008190135e-013
	,5.176621214e-013
	,6.713476898e-013
	,8.740592597e-013
	,1.141967719e-012
	,1.497004516e-012
	,1.967785841e-012
	,2.593621744e-012
	,3.427859234e-012
	,4.542029411e-012
	,6.032766971e-012
	,7.973556845e-012
	,1.041805000e-011
	,1.362546461e-011
	,1.783663748e-011
	,2.336918792e-011
	,3.064177150e-011
	,4.020332019e-011
	,5.278181229e-011
	,6.934353260e-011
	,9.116147338e-011
	,1.199185736e-010
	,1.578408126e-010
	,2.078727201e-010
	,2.739112657e-010
	,3.611151234e-010
	,4.763152686e-010
	,6.285594197e-010
	,8.298343726e-010
	,1.096023770e-009
	,1.448158375e-009
	,1.914133796e-009
	,2.530952757e-009
	,3.347660774e-009
	,4.429302017e-009
	,5.862140432e-009
	,7.760599577e-009
	,1.027648350e-008
	,1.359789058e-008
	,1.794031893e-008
	,2.368583527e-008
	,3.128546128e-008
	,4.133356344e-008
	,5.461208105e-008
	,7.214732318e-008
	,9.528327569e-008
	,1.257753002e-007
	,1.659060554e-007
	,2.186308661e-007
	,2.877546930e-007
	,3.781435307e-007
	,4.959701461e-007
	,6.489894504e-007
	,8.468340931e-007
	,1.101308942e-006
	,1.426656998e-006
	,1.839757715e-006
	,2.360212131e-006
	,3.010268755e-006
	,3.814553456e-006
	,4.799587463e-006
	,5.993108365e-006
	,7.423244326e-006
	,9.117622715e-006
	,1.110251770e-005
	,1.340209466e-005
	,1.603787893e-005
	,1.902843814e-005
	,2.238929178e-005
	,2.613301611e-005
	,3.026949156e-005
	,3.480631858e-005
	,3.974905667e-005
	,4.510170291e-005
	,5.086705678e-005
	,5.704704383e-005
	,6.364297987e-005
	,7.065579975e-005
	,7.808622518e-005
	,8.563462703e-005
	,9.341245706e-005
	,1.015771251e-004
	,1.101221073e-004
	,1.190412889e-004
	,1.283288275e-004
	,1.379785623e-004
	,1.479847122e-004
	,1.583414969e-004
	,1.690431771e-004
	,1.800840498e-004
	,1.914584504e-004
	,2.031607597e-004
	,2.151854142e-004
	,2.275269474e-004
	,2.401803110e-004
	,2.531399532e-004
	,2.664000646e-004
	,2.799558483e-004
	,-7.689872566e-009
	,-5.397945908e-009
	,-3.788365010e-009
	,-2.658230842e-009
	,-1.864888352e-009
	,-1.308074131e-009
	,-9.173373204e-010
	,-6.431955220e-010
	,-4.508983114e-010
	,-3.160366845e-010
	,-2.214723316e-010
	,-1.551756118e-010
	,-1.087045521e-010
	,-7.613606524e-011
	,-5.331478259e-011
	,-3.732646934e-011
	,-2.612704284e-011
	,-1.828356835e-011
	,-1.279132654e-011
	,-8.946295906e-012
	,-6.254864965e-012
	,-4.371526622e-012
	,-3.053920372e-012
	,-2.132318369e-012
	,-1.487831928e-012
	,-1.037324548e-012
	,-7.224398934e-013
	,-5.024173960e-013
	,-3.487551161e-013
	,-2.414609201e-013
	,-1.666089634e-013
	,-1.144414684e-013
	,-7.812566224e-014
	,-5.287309493e-014
	,-3.536056007e-014
	,-2.317226732e-014
	,-1.472856708e-014
	,-8.893440003e-015
	,-4.811529752e-015
	,-1.968975030e-015
	,1.482927917e-017
	,1.391722726e-015
	,2.371249601e-015
	,3.037687125e-015
	,3.543715961e-015
	,3.890171573e-015
	,4.144047561e-015
	,4.345759397e-015
	,4.472018578e-015
	,4.602768367e-015
	,4.711535065e-015
	,4.773150381e-015
	,4.862283723e-015
	,4.916954262e-015
	,4.980814882e-015
	,5.050575952e-015
	,5.107021847e-015
	,5.168898245e-015
	,5.200854663e-015
	,5.281267872e-015
	,5.303668695e-015
	,5.387162669e-015
	,5.444182945e-015
	,5.506947021e-015
	,5.568092390e-015
	,5.604800497e-015
	,5.677172386e-015
	,5.731947357e-015
	,5.803692649e-015
	,5.874236964e-015
	,5.906767762e-015
	,5.990575035e-015
	,6.060962701e-015
	,6.097461943e-015
	,6.170199346e-015
	,6.228211733e-015
	,6.308781591e-015
	,6.396766173e-015
	,6.448042648e-015
	,6.551587709e-015
	,6.638110233e-015
	,6.694921643e-015
	,6.825775865e-015
	,6.929895306e-015
	,7.054013616e-015
	,7.189462878e-015
	,7.383916638e-015
	,7.575080767e-015
	,7.715438368e-015
	,8.006126897e-015
	,8.273735791e-015
	,8.653870960e-015
	,9.103714983e-015
	,9.662430137e-015
	,1.038144954e-014
	,1.134917552e-014
	,1.253469597e-014
	,1.405695979e-014
	,1.614561457e-014
	,1.876468323e-014
	,2.225315444e-014
	,2.690161230e-014
	,3.290602485e-014
	,4.085930895e-014
	,5.150596560e-014
	,6.557864269e-014
	,8.430771453e-014
	,1.092635884e-013
	,1.425512107e-013
	,1.870794508e-013
	,2.399792803e-013
	,3.076937816e-013
	,3.965031739e-013
	,5.131499483e-013
	,6.668690918e-013
	,8.702646961e-013
	,1.139516526e-012
	,1.497077306e-012
	,1.972934741e-012
	,2.607565394e-012
	,3.455540541e-012
	,4.493829525e-012
	,5.851037609e-012
	,7.627176895e-012
	,9.953032574e-012
	,1.299983967e-011
	,1.699031441e-011
	,2.222522282e-011
	,2.909715625e-011
	,3.812371911e-011
	,4.998727115e-011
	,6.558856784e-011
	,8.611658848e-011
	,1.131414551e-010
	,1.487375070e-010
	,1.956463594e-010
	,2.574925573e-010
	,3.390396146e-010
	,4.466225459e-010
	,5.886362044e-010
	,7.761764717e-010
	,1.023934732e-009
	,1.351368602e-009
	,1.784254797e-009
	,2.356750380e-009
	,3.114129551e-009
	,4.116419583e-009
	,5.443237401e-009
	,7.200232453e-009
	,9.517253624e-009
	,1.253273643e-008
	,1.651953646e-008
	,2.178952965e-008
	,2.875402903e-008
	,3.795517136e-008
	,5.010582707e-008
	,6.614186213e-008
	,8.728902991e-008
	,1.151482053e-007
	,1.518029345e-007
	,1.999534849e-007
	,2.630813933e-007
	,3.456475778e-007
	,4.533250393e-007
	,5.932635429e-007
	,7.743782127e-007
	,1.007646236e-006
	,1.306385731e-006
	,1.686479586e-006
	,2.166521745e-006
	,2.767795315e-006
	,3.514085404e-006
	,4.431281139e-006
	,5.546773751e-006
	,6.888687513e-006
	,8.485013149e-006
	,1.036274971e-005
	,1.254709208e-005
	,1.506083507e-005
	,1.792396804e-005
	,2.115350248e-005
	,2.476351609e-005
	,2.876530921e-005
	,3.316774702e-005
	,3.797761822e-005
	,4.320001650e-005
	,4.883875442e-005
	,5.489671993e-005
	,6.137594933e-005
	,6.827810690e-005
	,7.539707311e-005
	,8.266840325e-005
	,9.033532660e-005
	,9.839151243e-005
	,1.068309764e-004
	,1.156478226e-004
	,1.248361989e-004
	,1.343902029e-004
	,1.443041196e-004
	,1.545721601e-004
	,1.651885415e-004
	,-7.828989982e-009
	,-5.500086404e-009
	,-3.863299728e-009
	,-2.713167549e-009
	,-1.905134197e-009
	,-1.337532208e-009
	,-9.388844275e-010
	,-6.589530039e-010
	,-4.624175313e-010
	,-3.244535147e-010
	,-2.276192238e-010
	,-1.596624812e-010
	,-1.119781174e-010
	,-7.852326951e-011
	,-5.505482443e-011
	,-3.859403189e-011
	,-2.704992581e-011
	,-1.895495536e-011
	,-1.327938548e-011
	,-9.300793883e-012
	,-6.512374795e-012
	,-4.558298466e-012
	,-3.189166826e-012
	,-2.230038954e-012
	,-1.558247791e-012
	,-1.087691884e-012
	,-7.582730637e-013
	,-5.276918420e-013
	,-3.664100973e-013
	,-2.537245089e-013
	,-1.750498961e-013
	,-1.202791541e-013
	,-8.214433847e-014
	,-5.563936153e-014
	,-3.724264689e-014
	,-2.448890308e-014
	,-1.557854514e-014
	,-9.413201745e-015
	,-5.086240072e-015
	,-2.103171100e-015
	,-1.603059519e-017
	,1.474903403e-015
	,2.520431769e-015
	,3.300492112e-015
	,3.856387582e-015
	,4.249629060e-015
	,4.524078298e-015
	,4.764900194e-015
	,4.923481308e-015
	,5.123992167e-015
	,5.244142033e-015
	,5.364030818e-015
	,5.455043950e-015
	,5.560051069e-015
	,5.617019128e-015
	,5.728031129e-015
	,5.799202041e-015
	,5.862853795e-015
	,5.952196004e-015
	,6.039240692e-015
	,6.083154658e-015
	,6.146388682e-015
	,6.201999115e-015
	,6.279331558e-015
	,6.367002843e-015
	,6.422874358e-015
	,6.529186886e-015
	,6.544277417e-015
	,6.615500545e-015
	,6.686828106e-015
	,6.772932899e-015
	,6.829953175e-015
	,6.869637615e-015
	,6.959501987e-015
	,7.026182291e-015
	,7.093489191e-015
	,7.153903531e-015
	,7.232280301e-015
	,7.277656326e-015
	,7.315983142e-015
	,7.420520313e-015
	,7.503126610e-015
	,7.522655532e-015
	,7.626670540e-015
	,7.661759940e-015
	,7.802169758e-015
	,7.851148712e-015
	,7.921536378e-015
	,7.983256127e-015
	,8.070875195e-015
	,8.225540082e-015
	,8.251909348e-015
	,8.405738773e-015
	,8.535235369e-015
	,8.632201167e-015
	,8.817203764e-015
	,9.002363010e-015
	,9.232793849e-015
	,9.478001920e-015
	,9.788584886e-015
	,1.012835680e-014
	,1.066164258e-014
	,1.124098320e-014
	,1.202490756e-014
	,1.300688860e-014
	,1.428984480e-014
	,1.600593578e-014
	,1.815636253e-014
	,2.107593639e-014
	,2.482225204e-014
	,2.980442472e-014
	,3.641204076e-014
	,4.524188105e-014
	,5.688127533e-014
	,7.227977825e-014
	,9.275433889e-014
	,1.176263011e-013
	,1.481741304e-013
	,1.879313608e-013
	,2.397807015e-013
	,3.076569168e-013
	,3.967998151e-013
	,5.144203725e-013
	,6.699235405e-013
	,8.762290065e-013
	,1.150951806e-012
	,1.517782663e-012
	,1.980711742e-012
	,2.568353250e-012
	,3.333167928e-012
	,4.326305157e-012
	,5.623025172e-012
	,7.317395451e-012
	,9.532895227e-012
	,1.243190759e-011
	,1.622780132e-011
	,2.120137600e-011
	,2.772228013e-011
	,3.627710908e-011
	,4.750700363e-011
	,6.225709814e-011
	,8.164158499e-011
	,1.071135273e-010
	,1.406132090e-010
	,1.847026577e-010
	,2.427588286e-010
	,3.192433705e-010
	,4.200536832e-010
	,5.529871983e-010
	,7.283577280e-010
	,9.598123598e-010
	,1.265415217e-009
	,1.669086458e-009
	,2.202514060e-009
	,2.907507834e-009
	,3.839777951e-009
	,5.073207855e-009
	,6.697891339e-009
	,8.800154552e-009
	,1.157682030e-008
	,1.524400160e-008
	,2.008686502e-008
	,2.648132697e-008
	,3.492235916e-008
	,4.606077363e-008
	,6.075080325e-008
	,8.011129097e-008
	,1.056038162e-007
	,1.391315611e-007
	,1.831630318e-007
	,2.408847324e-007
	,3.163860506e-007
	,4.148774501e-007
	,5.429471619e-007
	,7.088376016e-007
	,9.227414808e-007
	,1.197090240e-006
	,1.546804769e-006
	,1.989468295e-006
	,2.545375984e-006
	,3.237417719e-006
	,4.090762866e-006
	,5.132340738e-006
	,6.390133814e-006
	,7.892350778e-006
	,9.666557769e-006
	,1.173886075e-005
	,1.413322858e-005
	,1.687102512e-005
	,1.997073272e-005
	,2.344791420e-005
	,2.731534651e-005
	,3.158328109e-005
	,3.625979453e-005
	,4.135116514e-005
	,4.686249866e-005
	,5.279740211e-005
	,5.915888675e-005
	,6.584283916e-005
	,7.259279400e-005
	,7.974593521e-005
	,-7.950583379e-009
	,-5.589240009e-009
	,-3.928629763e-009
	,-2.761004564e-009
	,-1.940133287e-009
	,-1.363117092e-009
	,-9.575828154e-010
	,-6.726145024e-010
	,-4.723942768e-010
	,-3.317355280e-010
	,-2.329314831e-010
	,-1.635356677e-010
	,-1.148004943e-010
	,-8.057853381e-011
	,-5.655055973e-011
	,-3.968152452e-011
	,-2.783977704e-011
	,-1.952792182e-011
	,-1.369461611e-011
	,-9.601482995e-012
	,-6.729619225e-012
	,-4.714879954e-012
	,-3.301662817e-012
	,-2.310410181e-012
	,-1.615193084e-012
	,-1.127751186e-012
	,-7.860788026e-013
	,-5.467849664e-013
	,-3.794888880e-013
	,-2.626382609e-013
	,-1.812087125e-013
	,-1.245698254e-013
	,-8.515967715e-014
	,-5.773355125e-014
	,-3.867598623e-014
	,-2.543553364e-014
	,-1.627145636e-014
	,-9.801691534e-015
	,-5.360010497e-015
	,-2.198988138e-015
	,-1.232323296e-017
	,1.566334266e-015
	,2.675566602e-015
	,3.481474049e-015
	,4.070526913e-015
	,4.526480251e-015
	,4.842075988e-015
	,5.121172483e-015
	,5.333954189e-015
	,5.531645364e-015
	,5.688033390e-015
	,5.848703159e-015
	,5.972142657e-015
	,6.078768483e-015
	,6.243824427e-015
	,6.308050562e-015
	,6.443865339e-015
	,6.509031368e-015
	,6.631217672e-015
	,6.741603077e-015
	,6.817838977e-015
	,6.919817546e-015
	,6.994748037e-015
	,7.066493328e-015
	,7.179541768e-015
	,7.226849799e-015
	,7.283139045e-015
	,7.339950455e-015
	,7.410599203e-015
	,7.544534191e-015
	,7.581085649e-015
	,7.671472185e-015
	,7.690740025e-015
	,7.777784713e-015
	,7.852297473e-015
	,7.915322631e-015
	,7.987172355e-015
	,8.042365057e-015
	,8.080744089e-015
	,8.187317699e-015
	,8.247993120e-015
	,8.312950284e-015
	,8.385739903e-015
	,8.385531038e-015
	,8.513983307e-015
	,8.570951366e-015
	,8.634707553e-015
	,8.722274404e-015
	,8.780391224e-015
	,8.845035089e-015
	,8.921688719e-015
	,8.958344611e-015
	,9.094629335e-015
	,9.139535413e-015
	,9.215875745e-015
	,9.303599246e-015
	,9.403280295e-015
	,9.486147674e-015
	,9.576534209e-015
	,9.682115708e-015
	,9.843046559e-015
	,9.944189667e-015
	,1.006209423e-014
	,1.022224183e-014
	,1.038348598e-014
	,1.057543336e-014
	,1.080925826e-014
	,1.111545505e-014
	,1.145914319e-014
	,1.185525657e-014
	,1.244420500e-014
	,1.306166357e-014
	,1.388892752e-014
	,1.502332814e-014
	,1.638544436e-014
	,1.819040760e-014
	,2.055878547e-014
	,2.367124661e-014
	,2.778965610e-014
	,3.316606237e-014
	,4.038168582e-014
	,4.990866686e-014
	,6.197440779e-014
	,7.622879784e-014
	,9.469788438e-014
	,1.186186210e-013
	,1.497317969e-013
	,1.902688788e-013
	,2.427559380e-013
	,3.115900104e-013
	,4.023391364e-013
	,5.223170541e-013
	,6.814580843e-013
	,8.885885690e-013
	,1.144759101e-012
	,1.477647490e-012
	,1.910514823e-012
	,2.473847679e-012
	,3.207711939e-012
	,4.164254683e-012
	,5.412054800e-012
	,7.041072689e-012
	,9.169178920e-012
	,1.194881166e-011
	,1.557379244e-011
	,2.031549882e-011
	,2.652147172e-011
	,3.465137330e-011
	,4.530829355e-011
	,5.928635140e-011
	,7.763127226e-011
	,1.017211628e-010
	,1.333727520e-010
	,1.749820423e-010
	,2.297108394e-010
	,3.017326927e-010
	,3.965595459e-010
	,5.214740024e-010
	,6.860861087e-010
	,9.030367626e-010
	,1.189213776e-009
	,1.566893425e-009
	,2.065586657e-009
	,2.724421260e-009
	,3.595332359e-009
	,4.741272237e-009
	,6.213569821e-009
	,8.155970661e-009
	,1.071862545e-008
	,1.409966648e-008
	,1.856034352e-008
	,2.444365673e-008
	,3.220288331e-008
	,4.243315181e-008
	,5.591511903e-008
	,7.367135878e-008
	,9.703769695e-008
	,1.277541227e-007
	,1.680788558e-007
	,2.209297602e-007
	,2.900568591e-007
	,3.802485010e-007
	,4.975714049e-007
	,6.496407249e-007
	,8.459103271e-007
	,1.097965444e-006
	,1.419790426e-006
	,1.827974858e-006
	,2.341814395e-006
	,2.983261697e-006
	,3.776690119e-006
	,4.748454566e-006
	,5.926266996e-006
	,7.338409221e-006
	,9.012892723e-006
	,1.097660309e-005
	,1.325458844e-005
	,1.586950394e-005
	,1.884127140e-005
	,2.218695622e-005
	,2.592084134e-005
	,-8.058433983e-009
	,-5.668249416e-009
	,-3.986467524e-009
	,-2.803310859e-009
	,-1.971050759e-009
	,-1.385700754e-009
	,-9.740765178e-010
	,-6.846557217e-010
	,-4.811808203e-010
	,-3.381441325e-010
	,-2.376032742e-010
	,-1.669396534e-010
	,-1.172792419e-010
	,-8.238244839e-011
	,-5.786218814e-011
	,-4.063421881e-011
	,-2.853078628e-011
	,-2.002864281e-011
	,-1.405706048e-011
	,-9.863192170e-012
	,-6.918146062e-012
	,-4.850059415e-012
	,-3.397959775e-012
	,-2.378455108e-012
	,-1.662652490e-012
	,-1.160547922e-012
	,-8.084065222e-013
	,-5.620538161e-013
	,-3.898199489e-013
	,-2.698139388e-013
	,-1.862034171e-013
	,-1.280297342e-013
	,-8.757546749e-014
	,-5.946535936e-014
	,-3.989863252e-014
	,-2.626713154e-014
	,-1.675712081e-014
	,-1.020010243e-014
	,-5.559163730e-015
	,-2.304569637e-015
	,-1.644832615e-017
	,1.621996915e-015
	,2.794358843e-015
	,3.640316245e-015
	,4.273283076e-015
	,4.755553464e-015
	,5.081540259e-015
	,5.409615708e-015
	,5.643962775e-015
	,5.874550262e-015
	,6.033392458e-015
	,6.219178301e-015
	,6.347160622e-015
	,6.493366457e-015
	,6.645055010e-015
	,6.760348754e-015
	,6.883109439e-015
	,7.038557571e-015
	,7.128160861e-015
	,7.242828008e-015
	,7.344963227e-015
	,7.456131877e-015
	,7.532158911e-015
	,7.646460544e-015
	,7.774025135e-015
	,7.849477789e-015
	,7.919238858e-015
	,8.056620126e-015
	,8.123195997e-015
	,8.206063376e-015
	,8.326839838e-015
	,8.384068979e-015
	,8.470382638e-015
	,8.553824397e-015
	,8.639302593e-015
	,8.729219182e-015
	,8.772193254e-015
	,8.847332609e-015
	,8.935003894e-015
	,9.018445652e-015
	,9.070192074e-015
	,9.140840822e-015
	,9.233890393e-015
	,9.290336288e-015
	,9.381036122e-015
	,9.478524084e-015
	,9.518051875e-015
	,9.614443293e-015
	,9.659036073e-015
	,9.761066859e-015
	,9.864611920e-015
	,9.927845943e-015
	,9.964188536e-015
	,1.008412954e-014
	,1.013331736e-014
	,1.023059645e-014
	,1.032432484e-014
	,1.042833984e-014
	,1.047898972e-014
	,1.057287476e-014
	,1.063443785e-014
	,1.077542205e-014
	,1.084951708e-014
	,1.093368987e-014
	,1.103415416e-014
	,1.116600050e-014
	,1.127231302e-014
	,1.137502262e-014
	,1.144353050e-014
	,1.159072845e-014
	,1.176695869e-014
	,1.187838842e-014
	,1.201932041e-014
	,1.227157769e-014
	,1.248968546e-014
	,1.278799758e-014
	,1.302652196e-014
	,1.337746818e-014
	,1.388819649e-014
	,1.445798151e-014
	,1.513987508e-014
	,1.606838656e-014
	,1.729077177e-014
	,1.878076587e-014
	,2.081506341e-014
	,2.342781389e-014
	,2.678642299e-014
	,3.125092258e-014
	,3.707680736e-014
	,4.377548875e-014
	,5.232555374e-014
	,6.333793385e-014
	,7.756344825e-014
	,9.602183043e-014
	,1.200066365e-013
	,1.512500923e-013
	,1.921184349e-013
	,2.458193679e-013
	,3.166645538e-013
	,4.105590895e-013
	,5.267322614e-013
	,6.762264741e-013
	,8.678251996e-013
	,1.116008142e-012
	,1.438035212e-012
	,1.856285617e-012
	,2.399785755e-012
	,3.106696396e-012
	,4.026967038e-012
	,5.225571295e-012
	,6.788008196e-012
	,8.826248906e-012
	,1.148711646e-011
	,1.496312326e-011
	,1.950710707e-011
	,2.545081287e-011
	,3.323040511e-011
	,4.341368948e-011
	,5.672605210e-011
	,7.417433039e-011
	,9.705727640e-011
	,1.270823361e-010
	,1.664943498e-010
	,2.182685187e-010
	,2.863205283e-010
	,3.758177634e-010
	,4.935832505e-010
	,6.486313283e-010
	,8.528794299e-010
	,1.122094551e-009
	,1.477155387e-009
	,1.945739852e-009
	,2.564591290e-009
	,3.378102486e-009
	,4.414223129e-009
	,5.779094474e-009
	,7.577263141e-009
	,9.946814541e-009
	,1.306960966e-008
	,1.718525110e-008
	,2.260917520e-008
	,2.975625524e-008
	,3.917149751e-008
	,5.156980096e-008
	,6.788720556e-008
	,8.934654468e-008
	,1.175409175e-007
	,1.545388233e-007
	,2.030079353e-007
	,2.663930214e-007
	,3.490942734e-007
	,4.566985094e-007
	,5.962374921e-007
	,7.764725253e-007
	,1.008186292e-006
	,1.304462599e-006
	,1.680919147e-006
	,2.155852697e-006
	,2.750251901e-006
	,3.487637170e-006
	,4.393703967e-006
	,-8.155451261e-009
	,-5.739246254e-009
	,-4.038381300e-009
	,-2.841237990e-009
	,-1.998736192e-009
	,-1.405906475e-009
	,-9.888193435e-010
	,-6.954082108e-010
	,-4.890196120e-010
	,-3.438562418e-010
	,-2.417639873e-010
	,-1.699688165e-010
	,-1.194834860e-010
	,-8.398527355e-011
	,-5.902666430e-011
	,-4.147913037e-011
	,-2.914323130e-011
	,-2.047211002e-011
	,-1.437757051e-011
	,-1.009417081e-011
	,-7.083823798e-012
	,-4.968249914e-012
	,-3.481473540e-012
	,-2.436691764e-012
	,-1.702842855e-012
	,-1.187812699e-012
	,-8.269761252e-013
	,-5.746762357e-013
	,-3.985884872e-013
	,-2.758393946e-013
	,-1.904698600e-013
	,-1.310502946e-013
	,-8.971435442e-014
	,-6.093112507e-014
	,-4.091330101e-014
	,-2.697419340e-014
	,-1.725108767e-014
	,-1.048191418e-014
	,-5.738892474e-015
	,-2.375322817e-015
	,-2.005125564e-017
	,1.693220043e-015
	,2.891742372e-015
	,3.780256115e-015
	,4.476770268e-015
	,4.940921576e-015
	,5.324241944e-015
	,5.631483062e-015
	,5.888753115e-015
	,6.118714006e-015
	,6.302150112e-015
	,6.504749625e-015
	,6.651738706e-015
	,6.790790897e-015
	,6.943837076e-015
	,7.100016238e-015
	,7.234630038e-015
	,7.350393729e-015
	,7.450231428e-015
	,7.603434256e-015
	,7.731259928e-015
	,7.846553672e-015
	,7.973700532e-015
	,8.066384587e-015
	,8.215932270e-015
	,8.284231281e-015
	,8.417905187e-015
	,8.546357456e-015
	,8.658413785e-015
	,8.758930296e-015
	,8.884876179e-015
	,9.006435887e-015
	,9.112278468e-015
	,9.206842313e-015
	,9.304904655e-015
	,9.438369696e-015
	,9.517007548e-015
	,9.654702114e-015
	,9.762842215e-015
	,9.833334314e-015
	,9.966538273e-015
	,1.005044998e-014
	,1.015885116e-014
	,1.024218849e-014
	,1.035779553e-014
	,1.041455472e-014
	,1.054791533e-014
	,1.060671096e-014
	,1.068910839e-014
	,1.081213016e-014
	,1.086774059e-014
	,1.098548851e-014
	,1.106877362e-014
	,1.116412071e-014
	,1.125210529e-014
	,1.131507823e-014
	,1.139664020e-014
	,1.151276941e-014
	,1.158858757e-014
	,1.166759094e-014
	,1.174727312e-014
	,1.188350563e-014
	,1.197457098e-014
	,1.204532416e-014
	,1.214364758e-014
	,1.224139663e-014
	,1.237856903e-014
	,1.245177638e-014
	,1.253683684e-014
	,1.267615012e-014
	,1.271896754e-014
	,1.284099720e-014
	,1.294824962e-014
	,1.308181909e-014
	,1.323684949e-014
	,1.331204107e-014
	,1.342028560e-014
	,1.357583816e-014
	,1.368862552e-014
	,1.388897973e-014
	,1.406176370e-014
	,1.422091919e-014
	,1.443323095e-014
	,1.469368620e-014
	,1.498202499e-014
	,1.532952493e-014
	,1.576840352e-014
	,1.627719982e-014
	,1.687700926e-014
	,1.765111694e-014
	,1.864484666e-014
	,1.994821946e-014
	,2.164420714e-014
	,2.376189422e-014
	,2.665739634e-014
	,2.993747203e-014
	,3.403797130e-014
	,3.930070254e-014
	,4.607979714e-014
	,5.466641358e-014
	,6.576547286e-014
	,8.001333587e-014
	,9.861014365e-014
	,1.228070526e-013
	,1.544006192e-013
	,1.958973857e-013
	,2.487426492e-013
	,3.155720830e-013
	,4.019407778e-013
	,5.136227153e-013
	,6.582004956e-013
	,8.455155469e-013
	,1.088402444e-012
	,1.403482649e-012
	,1.812297085e-012
	,2.343149270e-012
	,3.027826598e-012
	,3.917685644e-012
	,5.075237599e-012
	,6.582034878e-012
	,8.545012479e-012
	,1.110399759e-011
	,1.444235374e-011
	,1.880016312e-011
	,2.449282389e-011
	,3.193309265e-011
	,4.166384035e-011
	,5.439888903e-011
	,7.107575594e-011
	,9.292801191e-011
	,1.215785014e-010
	,1.591539052e-010
	,2.083755839e-010
	,2.730007300e-010
	,3.579020428e-010
	,4.695107330e-010
	,6.163219384e-010
	,8.095662790e-010
	,1.064060347e-009
	,1.399532994e-009
	,1.842138746e-009
	,2.423517448e-009
	,3.156131132e-009
	,4.119929243e-009
	,5.388028478e-009
	,7.056829708e-009
	,9.253372046e-009
	,1.214499024e-008
	,1.595197106e-008
	,2.096410714e-008
	,2.756229222e-008
	,3.624653859e-008
	,4.767035918e-008
	,6.269301149e-008
	,8.243499522e-008
	,1.083561659e-007
	,1.423524982e-007
	,1.868770388e-007
	,2.450889409e-007
	,3.210340097e-007
	,4.198587368e-007
	,-8.243836936e-009
	,-5.803868230e-009
	,-4.085587197e-009
	,-2.875687186e-009
	,-2.023860103e-009
	,-1.424226331e-009
	,-1.002172400e-009
	,-7.051365319e-010
	,-4.961040104e-010
	,-3.490128910e-010
	,-2.455158334e-010
	,-1.726972872e-010
	,-1.214666171e-010
	,-8.542571589e-011
	,-6.007161735e-011
	,-4.223644537e-011
	,-2.969160338e-011
	,-2.086863852e-011
	,-1.466353205e-011
	,-1.029960609e-011
	,-7.230538481e-012
	,-5.072110831e-012
	,-3.554128075e-012
	,-2.486834047e-012
	,-1.737006824e-012
	,-1.210962148e-012
	,-8.427295428e-013
	,-5.855207402e-013
	,-4.061775621e-013
	,-2.811866119e-013
	,-1.942917327e-013
	,-1.336893099e-013
	,-9.158746002e-014
	,-6.230279688e-014
	,-4.186990490e-014
	,-2.762543596e-014
	,-1.772552560e-014
	,-1.076195057e-014
	,-5.852045346e-015
	,-2.426285994e-015
	,1.284505713e-017
	,1.721521316e-015
	,2.967090593e-015
	,3.912154664e-015
	,4.555199255e-015
	,5.092035749e-015
	,5.507521401e-015
	,5.823169355e-015
	,6.112134743e-015
	,6.327527267e-015
	,6.513626408e-015
	,6.704790537e-015
	,6.912350606e-015
	,7.061062826e-015
	,7.186956493e-015
	,7.340890350e-015
	,7.474146525e-015
	,7.618577003e-015
	,7.730894414e-015
	,7.874750511e-015
	,8.024245977e-015
	,8.099855280e-015
	,8.280262837e-015
	,8.415189936e-015
	,8.552780069e-015
	,8.669327006e-015
	,8.797831491e-015
	,8.932497508e-015
	,9.079016641e-015
	,9.205014740e-015
	,9.355658966e-015
	,9.468864055e-015
	,9.637940660e-015
	,9.760022532e-015
	,9.914113038e-015
	,1.005906568e-014
	,1.014611037e-014
	,1.032009531e-014
	,1.045684998e-014
	,1.058274365e-014
	,1.071338901e-014
	,1.085473872e-014
	,1.097535853e-014
	,1.109874581e-014
	,1.122980890e-014
	,1.133027319e-014
	,1.147188399e-014
	,1.160232048e-014
	,1.172680430e-014
	,1.180063825e-014
	,1.193159691e-014
	,1.205759500e-014
	,1.217972909e-014
	,1.226405853e-014
	,1.238509607e-014
	,1.249668246e-014
	,1.261959979e-014
	,1.266946642e-014
	,1.281327030e-014
	,1.294245360e-014
	,1.300438222e-014
	,1.310521203e-014
	,1.325178337e-014
	,1.332598284e-014
	,1.344299972e-014
	,1.350733029e-014
	,1.366873109e-014
	,1.375598464e-014
	,1.382229943e-014
	,1.395858415e-014
	,1.405836963e-014
	,1.421052813e-014
	,1.432425539e-014
	,1.442445860e-014
	,1.456664377e-014
	,1.466152092e-014
	,1.477806785e-014
	,1.491581464e-014
	,1.499393033e-014
	,1.517031722e-014
	,1.526801405e-014
	,1.539636189e-014
	,1.554100123e-014
	,1.565639941e-014
	,1.581790464e-014
	,1.597554586e-014
	,1.607287717e-014
	,1.626597330e-014
	,1.644716411e-014
	,1.668307766e-014
	,1.690849573e-014
	,1.708780674e-014
	,1.741823193e-014
	,1.770954705e-014
	,1.808665367e-014
	,1.856610438e-014
	,1.907782480e-014
	,1.982133368e-014
	,2.065298380e-014
	,2.180242274e-014
	,2.318286690e-014
	,2.485963896e-014
	,2.689075130e-014
	,2.942026889e-014
	,3.268212105e-014
	,3.679577886e-014
	,4.205542932e-014
	,4.882763136e-014
	,5.754410992e-014
	,6.875130930e-014
	,8.336202386e-014
	,1.022972459e-013
	,1.268806605e-013
	,1.573709996e-013
	,1.966223056e-013
	,2.472190799e-013
	,3.124483953e-013
	,3.965963801e-013
	,5.054301758e-013
	,6.460288077e-013
	,8.280274493e-013
	,1.063709845e-012
	,1.369185579e-012
	,1.765333996e-012
	,2.279452871e-012
	,2.947172724e-012
	,3.814492313e-012
	,4.942138021e-012
	,6.409447349e-012
	,8.319879879e-012
	,1.079495454e-011
	,1.401763581e-011
	,1.821846284e-011
	,2.369815847e-011
	,3.085100604e-011
	,4.019400662e-011
	,5.240563779e-011
	,6.837713835e-011
	,8.927951621e-011
	,1.166526002e-010
	,1.525225225e-010
	,1.995540627e-010
	,2.612620370e-010
	,3.422830787e-010
	,4.487357443e-010
	,5.886933563e-010
	,7.725354843e-010
	,1.014596218e-009
	,1.333644023e-009
	,1.752568758e-009
	,2.273744198e-009
	,2.958247059e-009
	,3.857404165e-009
	,5.038836738e-009
	,6.591450410e-009
	,8.632502459e-009
	,1.131626221e-008
	,1.484559475e-008
	,1.948715398e-008
	,2.559116399e-008
	,3.361713702e-008
	,-8.325179772e-009
	,-5.863303289e-009
	,-4.128971469e-009
	,-2.907321849e-009
	,-2.046917900e-009
	,-1.441027260e-009
	,-1.014408133e-009
	,-7.140428511e-010
	,-5.025835655e-010
	,-3.537246571e-010
	,-2.489403774e-010
	,-1.751849760e-010
	,-1.232725744e-010
	,-8.673548524e-011
	,-6.102038904e-011
	,-4.292316253e-011
	,-3.018803819e-011
	,-2.122684161e-011
	,-1.492107686e-011
	,-1.048390392e-011
	,-7.361406801e-012
	,-5.163997178e-012
	,-3.617718737e-012
	,-2.530178124e-012
	,-1.766359786e-012
	,-1.230932351e-012
	,-8.564503338e-013
	,-5.950989455e-013
	,-4.129125339e-013
	,-2.860175659e-013
	,-1.977012006e-013
	,-1.361662456e-013
	,-9.329624071e-014
	,-6.347447999e-014
	,-4.269816096e-014
	,-2.820477658e-014
	,-1.807370435e-014
	,-1.094940734e-014
	,-6.024411582e-015
	,-2.500224373e-015
	,-1.227101659e-017
	,1.789768111e-015
	,3.030690131e-015
	,4.031730151e-015
	,4.719785251e-015
	,5.248893723e-015
	,5.659366604e-015
	,5.999712900e-015
	,6.249516011e-015
	,6.502295456e-015
	,6.707088057e-015
	,6.885250310e-015
	,7.058556440e-015
	,7.225805472e-015
	,7.382297931e-015
	,7.530279122e-015
	,7.667138226e-015
	,7.850574332e-015
	,7.970933064e-015
	,8.082728311e-015
	,8.250656155e-015
	,8.404067849e-015
	,8.543485555e-015
	,8.643271037e-015
	,8.835740575e-015
	,8.969988861e-015
	,9.115359234e-015
	,9.290701803e-015
	,9.402131535e-015
	,9.580711519e-015
	,9.725977459e-015
	,9.882678783e-015
	,1.003708259e-014
	,1.017796235e-014
	,1.038097960e-014
	,1.052018844e-014
	,1.066132929e-014
	,1.080805728e-014
	,1.098517521e-014
	,1.115310305e-014
	,1.131304179e-014
	,1.146070969e-014
	,1.162090951e-014
	,1.176111046e-014
	,1.193420772e-014
	,1.209952475e-014
	,1.225324974e-014
	,1.244598036e-014
	,1.255725344e-014
	,1.274486686e-014
	,1.287921958e-014
	,1.301748853e-014
	,1.317450315e-014
	,1.333214437e-014
	,1.346148431e-014
	,1.364267512e-014
	,1.375149403e-014
	,1.388266155e-014
	,1.403863185e-014
	,1.420018929e-014
	,1.432853713e-014
	,1.448173996e-014
	,1.457118660e-014
	,1.475655471e-014
	,1.485534808e-014
	,1.497508022e-014
	,1.512029394e-014
	,1.519788747e-014
	,1.534968045e-014
	,1.547922926e-014
	,1.559734269e-014
	,1.568929572e-014
	,1.584578818e-014
	,1.596781783e-014
	,1.615188054e-014
	,1.628832191e-014
	,1.634607321e-014
	,1.653822945e-014
	,1.664736167e-014
	,1.678401190e-014
	,1.690092436e-014
	,1.703282291e-014
	,1.716936871e-014
	,1.732659220e-014
	,1.747441674e-014
	,1.756490771e-014
	,1.768364773e-014
	,1.788729158e-014
	,1.803715256e-014
	,1.820936214e-014
	,1.832810217e-014
	,1.852255593e-014
	,1.871951607e-014
	,1.887548637e-014
	,1.905077672e-014
	,1.921280411e-014
	,1.940245397e-014
	,1.963257151e-014
	,1.984195915e-014
	,2.004048579e-014
	,2.038370398e-014
	,2.064880649e-014
	,2.103505098e-014
	,2.147006555e-014
	,2.197959288e-014
	,2.260394401e-014
	,2.336374441e-014
	,2.428980172e-014
	,2.538770310e-014
	,2.666162587e-014
	,2.832335961e-014
	,3.034992913e-014
	,3.295411612e-014
	,3.625998669e-014
	,4.037322676e-014
	,4.573939862e-014
	,5.252622125e-014
	,6.137156980e-014
	,7.271317412e-014
	,8.699367236e-014
	,1.052569220e-013
	,1.286536151e-013
	,1.587401128e-013
	,1.975370842e-013
	,2.474067456e-013
	,3.117637865e-013
	,3.947491216e-013
	,5.014572933e-013
	,6.391166136e-013
	,8.170767367e-013
	,1.047222578e-012
	,1.345132735e-012
	,1.730987164e-012
	,2.231215023e-012
	,2.880044404e-012
	,3.722311988e-012
	,4.816254693e-012
	,6.238061111e-012
	,8.086633743e-012
	,1.049202555e-011
	,1.362414119e-011
	,1.770494289e-011
	,2.302546855e-011
	,2.996631600e-011
	,3.899311315e-011
	,5.076664323e-011
	,6.614618848e-011
	,8.624911055e-011
	,1.125453250e-010
	,1.469670451e-010
	,1.920579964e-010
	,2.511695505e-010
	,3.287225484e-010
	,4.305561124e-010
	,5.643953737e-010
	,7.404819187e-010
	,9.724294222e-010
	,1.277122381e-009
	,1.650549245e-009
	,2.140268240e-009
	,2.781558058e-009
	,-8.400650961e-009
	,-5.918419063e-009
	,-4.169180074e-009
	,-2.936626330e-009
	,-2.068268856e-009
	,-1.456576087e-009
	,-1.025724957e-009
	,-7.222747238e-010
	,-5.085681135e-010
	,-3.580730581e-010
	,-2.520981357e-010
	,-1.774766580e-010
	,-1.249344506e-010
	,-8.793916169e-011
	,-6.189118253e-011
	,-4.355256194e-011
	,-3.064236807e-011
	,-2.155376177e-011
	,-1.515541380e-011
	,-1.065073512e-011
	,-7.479004123e-012
	,-5.245800700e-012
	,-3.673715937e-012
	,-2.568124908e-012
	,-1.791999538e-012
	,-1.248466712e-012
	,-8.686600352e-013
	,-6.036599237e-013
	,-4.189582496e-013
	,-2.903082895e-013
	,-2.007079236e-013
	,-1.383566701e-013
	,-9.489750790e-014
	,-6.456836072e-014
	,-4.346527164e-014
	,-2.871477386e-014
	,-1.837462729e-014
	,-1.117106582e-014
	,-6.122212842e-015
	,-2.560064333e-015
	,7.623420183e-018
	,1.821097932e-015
	,3.131885455e-015
	,4.090473566e-015
	,4.813513634e-015
	,5.340011288e-015
	,5.787975522e-015
	,6.133856753e-015
	,6.413005464e-015
	,6.658683483e-015
	,6.877365638e-015
	,7.062524884e-015
	,7.201577076e-015
	,7.381305820e-015
	,7.543280998e-015
	,7.723688555e-015
	,7.827964644e-015
	,8.012079563e-015
	,8.145335738e-015
	,8.299791759e-015
	,8.450227120e-015
	,8.610844672e-015
	,8.764621880e-015
	,8.906023809e-015
	,9.056250304e-015
	,9.227311130e-015
	,9.394037998e-015
	,9.552253597e-015
	,9.695587532e-015
	,9.900432349e-015
	,1.002350633e-014
	,1.024177076e-014
	,1.039147509e-014
	,1.053694989e-014
	,1.074497991e-014
	,1.091071467e-014
	,1.108950351e-014
	,1.129528823e-014
	,1.145366048e-014
	,1.161245046e-014
	,1.179776635e-014
	,1.196031591e-014
	,1.215617951e-014
	,1.234744807e-014
	,1.255213624e-014
	,1.272324928e-014
	,1.291258584e-014
	,1.308787619e-014
	,1.327987578e-014
	,1.346179761e-014
	,1.365661689e-014
	,1.385519574e-014
	,1.400009617e-014
	,1.422248568e-014
	,1.441829707e-014
	,1.458293528e-014
	,1.479634358e-014
	,1.497325264e-014
	,1.515856854e-014
	,1.532137918e-014
	,1.554585735e-014
	,1.569018340e-014
	,1.591288621e-014
	,1.607590572e-014
	,1.623161493e-014
	,1.642596426e-014
	,1.657989812e-014
	,1.673143002e-014
	,1.688123878e-014
	,1.708744123e-014
	,1.723093181e-014
	,1.738100166e-014
	,1.757018156e-014
	,1.772223563e-014
	,1.782598956e-014
	,1.802080883e-014
	,1.814424833e-014
	,1.833160066e-014
	,1.849289703e-014
	,1.863335906e-014
	,1.876374334e-014
	,1.892744166e-014
	,1.907923464e-014
	,1.924914671e-014
	,1.943874435e-014
	,1.960541900e-014
	,1.971684873e-014
	,1.987339341e-014
	,2.004372320e-014
	,2.023102332e-014
	,2.043471938e-014
	,2.053429599e-014
	,2.071736658e-014
	,2.091897399e-014
	,2.104941048e-014
	,2.124898144e-014
	,2.140704039e-014
	,2.159815231e-014
	,2.180022966e-014
	,2.196418906e-014
	,2.211822735e-014
	,2.238755938e-014
	,2.253522727e-014
	,2.278027869e-014
	,2.297102509e-014
	,2.323059266e-014
	,2.343893598e-014
	,2.371249754e-014
	,2.400423039e-014
	,2.431966948e-014
	,2.469484410e-014
	,2.513199954e-014
	,2.556696190e-014
	,2.615157637e-014
	,2.678386439e-014
	,2.749860206e-014
	,2.841995990e-014
	,2.948632259e-014
	,3.085825549e-014
	,3.258348433e-014
	,3.466059929e-014
	,3.728353197e-014
	,4.058992470e-014
	,4.484357459e-014
	,5.024060632e-014
	,5.714935417e-014
	,6.578108556e-014
	,7.680286461e-014
	,9.093945454e-014
	,1.089849619e-013
	,1.320702888e-013
	,1.618050048e-013
	,1.999809147e-013
	,2.491279015e-013
	,3.123392631e-013
	,3.938808156e-013
	,4.989923152e-013
	,6.347169667e-013
	,8.100568724e-013
	,1.036745834e-012
	,1.329983044e-012
	,1.708551200e-012
	,2.198050632e-012
	,2.832230240e-012
	,3.654476293e-012
	,4.720970523e-012
	,6.105528550e-012
	,7.904077065e-012
	,1.024196507e-011
	,1.328275046e-011
	,1.723949463e-011
	,2.239211903e-011
	,2.910665456e-011
	,3.786234845e-011
	,4.928739385e-011
	,6.420541819e-011
	,8.369774036e-011
	,1.091845959e-010
	,1.424553104e-010
	,1.859569277e-010
	,2.429453449e-010
	,-8.471123737e-009
	,-5.969868648e-009
	,-4.206698307e-009
	,-2.963963147e-009
	,-2.088180790e-009
	,-1.471071377e-009
	,-1.036270336e-009
	,-7.299418217e-010
	,-5.141390684e-010
	,-3.621185092e-010
	,-2.550339850e-010
	,-1.796056554e-010
	,-1.264767442e-010
	,-8.905487957e-011
	,-6.269750980e-011
	,-4.413468799e-011
	,-3.106170228e-011
	,-2.185477238e-011
	,-1.537034186e-011
	,-1.080294782e-011
	,-7.585466982e-012
	,-5.319123239e-012
	,-3.723527690e-012
	,-2.601711208e-012
	,-1.814849735e-012
	,-1.264193760e-012
	,-8.796452106e-013
	,-6.113927503e-013
	,-4.244578865e-013
	,-2.942539672e-013
	,-2.035277119e-013
	,-1.403545206e-013
	,-9.629930855e-014
	,-6.560548225e-014
	,-4.414392779e-014
	,-2.919986393e-014
	,-1.875048072e-014
	,-1.136525850e-014
	,-6.250665111e-015
	,-2.570820905e-015
	,2.276616733e-017
	,1.836971709e-015
	,3.211463202e-015
	,4.144465292e-015
	,4.895597767e-015
	,5.480629971e-015
	,5.851105112e-015
	,6.236305270e-015
	,6.545060663e-015
	,6.772880683e-015
	,6.996680042e-015
	,7.193170241e-015
	,7.334363304e-015
	,7.540513530e-015
	,7.691941002e-015
	,7.868693413e-015
	,8.009573177e-015
	,8.203556990e-015
	,8.301984847e-015
	,8.465683165e-015
	,8.635543015e-015
	,8.775900616e-015
	,8.969727779e-015
	,9.093376142e-015
	,9.278430956e-015
	,9.440458350e-015
	,9.623998889e-015
	,9.786861745e-015
	,9.970820015e-015
	,1.012553712e-014
	,1.030980869e-014
	,1.050488904e-014
	,1.067668090e-014
	,1.087249228e-014
	,1.106741599e-014
	,1.124072212e-014
	,1.144948317e-014
	,1.163949853e-014
	,1.181849625e-014
	,1.202840605e-014
	,1.222421744e-014
	,1.241381508e-014
	,1.261897319e-014
	,1.284465234e-014
	,1.303059483e-014
	,1.324071350e-014
	,1.344717703e-014
	,1.367703349e-014
	,1.386015630e-014
	,1.409831516e-014
	,1.428801723e-014
	,1.451453184e-014
	,1.474444051e-014
	,1.497883980e-014
	,1.518796636e-014
	,1.541542086e-014
	,1.562914246e-014
	,1.585069652e-014
	,1.607120625e-014
	,1.628894851e-014
	,1.653880383e-014
	,1.677534399e-014
	,1.697501938e-014
	,1.722388260e-014
	,1.746433898e-014
	,1.764730514e-014
	,1.790875250e-014
	,1.809391175e-014
	,1.835556798e-014
	,1.855064833e-014
	,1.877946046e-014
	,1.899704608e-014
	,1.921598931e-014
	,1.942663015e-014
	,1.965058616e-014
	,1.982577208e-014
	,2.004356655e-014
	,2.025405074e-014
	,2.044714687e-014
	,2.064165285e-014
	,2.081198265e-014
	,2.101975158e-014
	,2.117718393e-014
	,2.139973010e-014
	,2.156609145e-014
	,2.177490472e-014
	,2.192904744e-014
	,2.210287573e-014
	,2.233476863e-014
	,2.245476185e-014
	,2.267683807e-014
	,2.287578243e-014
	,2.310052169e-014
	,2.323529214e-014
	,2.343726505e-014
	,2.367464067e-014
	,2.384836453e-014
	,2.405874428e-014
	,2.424996063e-014
	,2.445209020e-014
	,2.465369760e-014
	,2.485379073e-014
	,2.504866222e-014
	,2.527669110e-014
	,2.545678536e-014
	,2.569128908e-014
	,2.588767484e-014
	,2.612134310e-014
	,2.639453914e-014
	,2.653212927e-014
	,2.679498648e-014
	,2.702390304e-014
	,2.730717685e-014
	,2.748920311e-014
	,2.784892168e-014
	,2.808201555e-014
	,2.838048432e-014
	,2.870803761e-014
	,2.908091470e-014
	,2.950078653e-014
	,2.994018728e-014
	,3.043164775e-014
	,3.101093615e-014
	,3.164808029e-014
	,3.250463761e-014
	,3.342562994e-014
	,3.456347685e-014
	,3.601237667e-014
	,3.772131401e-014
	,3.987884218e-014
	,4.258934170e-014
	,4.599301353e-014
	,5.026232833e-014
	,5.559351522e-014
	,6.238900576e-014
	,7.106726194e-014
	,8.207008645e-014
	,9.613467000e-014
	,1.141461323e-013
	,1.371650399e-013
	,1.667000284e-013
	,2.046219056e-013
	,2.533530413e-013
	,3.159455866e-013
	,3.964879267e-013
	,5.002591365e-013
	,6.341340754e-013
	,8.068569488e-013
	,1.029860479e-012
	,1.317960172e-012
	,1.690604434e-012
	,2.172729557e-012
	,2.796860855e-012
	,3.605522977e-012
	,4.653942093e-012
	,6.011941621e-012
	,7.771384200e-012
	,1.005571789e-011
	,1.302343003e-011
	,1.688187239e-011
	,2.190137721e-011
	,-8.537283799e-009
	,-6.018157767e-009
	,-4.241901560e-009
	,-2.989610920e-009
	,-2.106858909e-009
	,-1.484665109e-009
	,-1.046156974e-009
	,-7.371275262e-010
	,-5.193583425e-010
	,-3.659069657e-010
	,-2.577818563e-010
	,-1.815970813e-010
	,-1.279181311e-010
	,-9.009669075e-011
	,-6.344988173e-011
	,-4.467713435e-011
	,-3.145170524e-011
	,-2.213402104e-011
	,-1.556889204e-011
	,-1.094270718e-011
	,-7.682503168e-012
	,-5.385360121e-012
	,-3.768175088e-012
	,-2.631874934e-012
	,-1.835395832e-012
	,-1.278421885e-012
	,-8.895818813e-013
	,-6.185163685e-013
	,-4.295286703e-013
	,-2.978764256e-013
	,-2.061292881e-013
	,-1.421976540e-013
	,-9.760873845e-014
	,-6.650537916e-014
	,-4.485772556e-014
	,-2.967571171e-014
	,-1.900205919e-014
	,-1.159631594e-014
	,-6.334942331e-015
	,-2.609722100e-015
	,-1.143555468e-017
	,1.907098293e-015
	,3.245769357e-015
	,4.239446868e-015
	,5.009011722e-015
	,5.580363237e-015
	,6.012244829e-015
	,6.363243264e-015
	,6.683956205e-015
	,6.895850233e-015
	,7.101373863e-015
	,7.293582319e-015
	,7.485268612e-015
	,7.669487963e-015
	,7.791569835e-015
	,8.000591962e-015
	,8.166692233e-015
	,8.298016402e-015
	,8.473985568e-015
	,8.616745122e-015
	,8.814749595e-015
	,8.979492241e-015
	,9.123139473e-015
	,9.279527500e-015
	,9.453303577e-015
	,9.646086413e-015
	,9.808218241e-015
	,9.996458253e-015
	,1.015018324e-014
	,1.034933648e-014
	,1.056002953e-014
	,1.071636534e-014
	,1.094131346e-014
	,1.108840697e-014
	,1.131842008e-014
	,1.150885318e-014
	,1.169578778e-014
	,1.191843838e-014
	,1.212594623e-014
	,1.233261862e-014
	,1.256425044e-014
	,1.278794536e-014
	,1.300704525e-014
	,1.322933034e-014
	,1.344012782e-014
	,1.368387383e-014
	,1.390532346e-014
	,1.411638202e-014
	,1.438550519e-014
	,1.462345518e-014
	,1.484506146e-014
	,1.512206930e-014
	,1.538602304e-014
	,1.561144111e-014
	,1.583868675e-014
	,1.610185725e-014
	,1.637244248e-014
	,1.661509195e-014
	,1.687596493e-014
	,1.711929321e-014
	,1.742126048e-014
	,1.766067253e-014
	,1.794425963e-014
	,1.822330391e-014
	,1.842846203e-014
	,1.877564867e-014
	,1.895741385e-014
	,1.926381951e-014
	,1.956087843e-014
	,1.979031716e-014
	,2.006398315e-014
	,2.040453832e-014
	,2.064034744e-014
	,2.092195032e-014
	,2.117833269e-014
	,2.146573159e-014
	,2.173866656e-014
	,2.201060941e-014
	,2.224323333e-014
	,2.252447070e-014
	,2.277599695e-014
	,2.308172379e-014
	,2.327810956e-014
	,2.358315759e-014
	,2.379024771e-014
	,2.405347043e-014
	,2.429528444e-014
	,2.452545419e-014
	,2.476335197e-014
	,2.501049205e-014
	,2.524275046e-014
	,2.541438567e-014
	,2.565484205e-014
	,2.588981571e-014
	,2.612233521e-014
	,2.636268715e-014
	,2.657322356e-014
	,2.680704846e-014
	,2.704421521e-014
	,2.725193193e-014
	,2.748006525e-014
	,2.767498895e-014
	,2.795753173e-014
	,2.816984349e-014
	,2.838356509e-014
	,2.863843319e-014
	,2.889204809e-014
	,2.912112131e-014
	,2.936173434e-014
	,2.963320724e-014
	,2.981288377e-014
	,3.008477440e-014
	,3.033186226e-014
	,3.057320632e-014
	,3.087564354e-014
	,3.110273253e-014
	,3.138778169e-014
	,3.161043229e-014
	,3.190649910e-014
	,3.221045059e-014
	,3.245424882e-014
	,3.273653051e-014
	,3.304335390e-014
	,3.338526669e-014
	,3.373636955e-014
	,3.407311292e-014
	,3.444719099e-014
	,3.485970031e-014
	,3.528735238e-014
	,3.579473884e-014
	,3.637914445e-014
	,3.701200684e-014
	,3.772590905e-014
	,3.864481272e-014
	,3.959849249e-014
	,4.082902345e-014
	,4.227238834e-014
	,4.409233768e-014
	,4.634474299e-014
	,4.910213282e-014
	,5.249395153e-014
	,5.684963221e-014
	,6.225663727e-014
	,6.910314320e-014
	,7.786525886e-014
	,8.892181402e-014
	,1.030322958e-013
	,1.210767066e-013
	,1.441099215e-013
	,1.736453277e-013
	,2.113924367e-013
	,2.599833192e-013
	,3.222724875e-013
	,4.025058111e-013
	,5.057498444e-013
	,6.387472350e-013
	,8.099812631e-013
	,1.030695314e-012
	,1.315624221e-012
	,1.683612088e-012
	,2.159157008e-012
	,-3.121710725e-009
	,-2.572846143e-009
	,-2.150505852e-009
	,-1.821676594e-009
	,-1.563806851e-009
	,-1.359228627e-009
	,-1.194895344e-009
	,-1.061172833e-009
	,-9.504948831e-010
	,-8.558380409e-010
	,-7.756801135e-010
	,-7.060959324e-010
	,-6.454325600e-010
	,-5.925622820e-010
	,-5.460974399e-010
	,-5.049536476e-010
	,-4.682769896e-010
	,-4.346428170e-010
	,-4.024864986e-010
	,-3.734072546e-010
	,-3.460966478e-010
	,-3.206754512e-010
	,-2.976440927e-010
	,-2.764768960e-010
	,-2.571292500e-010
	,-2.391310863e-010
	,-2.225329242e-010
	,-2.070493242e-010
	,-1.925859106e-010
	,-1.790127082e-010
	,-1.658908570e-010
	,-1.534119576e-010
	,-1.413179038e-010
	,-1.290775298e-010
	,-1.166592245e-010
	,-1.036199772e-010
	,-8.937897315e-011
	,-7.307934001e-011
	,-5.376585651e-011
	,-3.005816047e-011
	,-1.618877195e-018
	,3.911523491e-011
	,9.104640542e-011
	,1.606011977e-010
	,2.544598308e-010
	,3.824398129e-010
	,5.580481826e-010
	,8.000432704e-010
	,1.134559369e-009
	,1.598032484e-009
	,2.241289337e-009
	,3.135204116e-009
	,4.378453590e-009
	,6.095960058e-009
	,8.436611606e-009
	,1.166408779e-008
	,1.609256147e-008
	,2.219334022e-008
	,3.052781512e-008
	,4.191358964e-008
	,5.753033112e-008
	,7.891303810e-008
	,1.080701344e-007
	,1.477579596e-007
	,2.016322465e-007
	,2.744923658e-007
	,3.723764269e-007
	,5.031969301e-007
	,6.767411402e-007
	,9.049961604e-007
	,1.201624568e-006
	,1.583919580e-006
	,2.071258345e-006
	,2.685352213e-006
	,3.450263814e-006
	,4.392026459e-006
	,5.538156802e-006
	,6.905697185e-006
	,8.506293452e-006
	,1.037560462e-005
	,1.254146840e-005
	,1.502735691e-005
	,1.784205554e-005
	,2.085234034e-005
	,2.416075051e-005
	,2.781285967e-005
	,3.182158366e-005
	,3.614436601e-005
	,4.066065911e-005
	,4.554965571e-005
	,5.077870309e-005
	,5.639051401e-005
	,6.209795105e-005
	,6.808174818e-005
	,7.445244200e-005
	,8.119480232e-005
	,8.833241235e-005
	,9.561401889e-005
	,1.029670520e-004
	,1.107815938e-004
	,1.188863218e-004
	,1.269595327e-004
	,1.354050571e-004
	,1.442217530e-004
	,1.534090890e-004
	,1.622976699e-004
	,1.713668670e-004
	,1.806902100e-004
	,1.901674077e-004
	,1.990514164e-004
	,2.081951406e-004
	,2.175989828e-004
	,2.271855984e-004
	,2.368677395e-004
	,2.467729743e-004
	,2.568954686e-004
	,2.672320467e-004
	,2.777752758e-004
	,2.885202165e-004
	,2.994632280e-004
	,3.105996281e-004
	,3.219279132e-004
	,3.334451929e-004
	,3.451546556e-004
	,3.570466506e-004
	,3.691184157e-004
	,3.813657783e-004
	,3.937881363e-004
	,4.063830581e-004
	,4.187106465e-004
	,4.310031764e-004
	,4.434441939e-004
	,4.560302069e-004
	,4.687539435e-004
	,4.816133104e-004
	,4.946063891e-004
	,5.077439230e-004
	,5.210166789e-004
	,5.344210265e-004
	,5.479558199e-004
	,5.616200542e-004
	,5.754138409e-004
	,5.893363535e-004
	,6.033867771e-004
	,6.174958894e-004
	,6.314102566e-004
	,6.454456851e-004
	,6.596021765e-004
	,6.738797796e-004
	,6.882785946e-004
	,7.027988690e-004
	,7.174407759e-004
	,7.322253869e-004
	,7.471334253e-004
	,7.621650059e-004
	,7.771089838e-004
	,7.921355328e-004
	,8.072690045e-004
	,8.225086826e-004
	,8.378539239e-004
	,8.533041619e-004
	,8.688588942e-004
	,8.845135282e-004
	,9.002637762e-004
	,9.161161776e-004
	,9.320705271e-004
	,9.481266727e-004
	,9.642844215e-004
	,9.805437346e-004
	,9.969046717e-004
	,1.013367269e-003
	,1.029931605e-003
	,1.046135422e-003
	,1.062173291e-003
	,1.078302585e-003
	,1.094523303e-003
	,1.110842851e-003
	,1.127255726e-003
	,1.143760324e-003
	,1.160356753e-003
	,1.177045127e-003
	,1.193825557e-003
	,1.210697964e-003
	,1.227661803e-003
	,1.244717963e-003
	,1.261866452e-003
	,1.279107090e-003
	,1.296439833e-003
	,1.313861514e-003
	,1.331374604e-003
	,1.348978999e-003
	,1.366674399e-003
	,1.384441111e-003
	,1.402296135e-003
	,1.420240721e-003
	,1.438274541e-003
	,1.456397240e-003
	,1.474608441e-003
	,1.492906419e-003
	,1.511281370e-003
	,1.529743429e-003
	,-5.657400707e-009
	,-4.188989331e-009
	,-3.108691346e-009
	,-2.318626142e-009
	,-1.742813153e-009
	,-1.322222962e-009
	,-1.013766123e-009
	,-7.862504670e-010
	,-6.170766904e-010
	,-4.905803000e-010
	,-3.952604927e-010
	,-3.225879974e-010
	,-2.672010859e-010
	,-2.248099343e-010
	,-1.920427810e-010
	,-1.663956936e-010
	,-1.459551355e-010
	,-1.294045986e-010
	,-1.157764713e-010
	,-1.043152913e-010
	,-9.465001874e-011
	,-8.642040974e-011
	,-7.932432220e-011
	,-7.303883818e-011
	,-6.738514868e-011
	,-6.226494235e-011
	,-5.748971823e-011
	,-5.312670596e-011
	,-4.902520815e-011
	,-4.507813769e-011
	,-4.140981184e-011
	,-3.797832331e-011
	,-3.470989109e-011
	,-3.151764883e-011
	,-2.831675885e-011
	,-2.499410845e-011
	,-2.141528239e-011
	,-1.738933425e-011
	,-1.270970035e-011
	,-7.052353566e-012
	,2.010313251e-017
	,9.029395960e-012
	,2.082590495e-011
	,3.649556952e-011
	,5.754063311e-011
	,8.599264024e-011
	,1.247644388e-010
	,1.778398271e-010
	,2.507311764e-010
	,3.510771842e-010
	,4.877811827e-010
	,6.759872036e-010
	,9.355452823e-010
	,1.293865695e-009
	,1.787425945e-009
	,2.466724056e-009
	,3.404550857e-009
	,4.699852078e-009
	,6.489475620e-009
	,8.923653390e-009
	,1.221247393e-008
	,1.670762672e-008
	,2.284825506e-008
	,3.123028088e-008
	,4.265973002e-008
	,5.809879606e-008
	,7.898741809e-008
	,1.072505281e-007
	,1.453597008e-007
	,1.965335160e-007
	,2.651227093e-007
	,3.567186380e-007
	,4.785189439e-007
	,6.381628421e-007
	,8.472859881e-007
	,1.119178268e-006
	,1.469859492e-006
	,1.916823677e-006
	,2.478880091e-006
	,3.179962605e-006
	,4.043752393e-006
	,5.093533363e-006
	,6.353715340e-006
	,7.848156314e-006
	,9.599090125e-006
	,1.162719855e-005
	,1.394916059e-005
	,1.656832203e-005
	,1.948945612e-005
	,2.273210228e-005
	,2.630823533e-005
	,3.022783202e-005
	,3.445819453e-005
	,3.893033814e-005
	,4.373610655e-005
	,4.888265791e-005
	,5.436941645e-005
	,6.020764396e-005
	,6.641520572e-005
	,7.287663830e-005
	,7.962884912e-005
	,8.672801072e-005
	,9.383134499e-005
	,1.009626686e-004
	,1.083645675e-004
	,1.160330842e-004
	,1.239649402e-004
	,1.321571981e-004
	,1.405997881e-004
	,1.492875191e-004
	,1.582011332e-004
	,1.673253539e-004
	,1.766916995e-004
	,1.863037722e-004
	,1.961589141e-004
	,2.062537034e-004
	,2.164749028e-004
	,2.267376071e-004
	,2.372192755e-004
	,2.479149151e-004
	,2.586836836e-004
	,2.694074221e-004
	,2.803100996e-004
	,2.913875844e-004
	,3.026358580e-004
	,3.140559101e-004
	,3.256427806e-004
	,3.373910437e-004
	,3.492974912e-004
	,3.613594792e-004
	,3.735752956e-004
	,3.859412022e-004
	,3.984539407e-004
	,4.111132748e-004
	,4.239229177e-004
	,4.368735969e-004
	,4.499631849e-004
	,4.631896911e-004
	,4.765531325e-004
	,4.900611605e-004
	,5.036855286e-004
	,5.174338524e-004
	,5.313122259e-004
	,5.453195792e-004
	,5.594432570e-004
	,5.732974192e-004
	,5.867464824e-004
	,6.003072787e-004
	,6.139777543e-004
	,6.277575771e-004
	,6.416466893e-004
	,6.556451510e-004
	,6.697524235e-004
	,6.839684092e-004
	,6.982990698e-004
	,7.127506191e-004
	,7.273120167e-004
	,7.419832259e-004
	,7.566077052e-004
	,7.713076426e-004
	,7.861035952e-004
	,8.009948485e-004
	,8.159807175e-004
	,8.310605529e-004
	,8.462370488e-004
	,8.615069155e-004
	,8.768592538e-004
	,8.923029338e-004
	,9.078376575e-004
	,9.234631715e-004
	,9.391792647e-004
	,9.549857672e-004
	,9.708824762e-004
	,9.868693268e-004
	,1.002946298e-003
	,1.019113367e-003
	,1.035370540e-003
	,1.051717854e-003
	,1.068158266e-003
	,1.084696082e-003
	,1.101324195e-003
	,1.118040876e-003
	,1.134848128e-003
	,1.151746132e-003
	,1.168735038e-003
	,1.185815005e-003
	,1.202986148e-003
	,1.220247916e-003
	,1.237601264e-003
	,1.255045875e-003
	,1.272581551e-003
	,1.290204954e-003
	,1.307918174e-003
	,1.325721638e-003
	,1.343615165e-003
	,1.361598537e-003
	,1.379671508e-003
	,1.397833800e-003
	,1.416085110e-003
	,1.434411570e-003
	,1.452816599e-003
	,-1.753487415e-008
	,-1.259697109e-008
	,-9.038071693e-009
	,-6.478050829e-009
	,-4.639622093e-009
	,-3.321760935e-009
	,-2.378794413e-009
	,-1.704717669e-009
	,-1.222639889e-009
	,-8.778013933e-010
	,-6.316264447e-010
	,-4.560761505e-010
	,-3.307793740e-010
	,-2.411703415e-010
	,-1.768521861e-010
	,-1.306898551e-010
	,-9.750628867e-011
	,-7.359059895e-011
	,-5.626182519e-011
	,-4.365240449e-011
	,-3.442075062e-011
	,-2.758898829e-011
	,-2.250035829e-011
	,-1.866329603e-011
	,-1.575015511e-011
	,-1.349624518e-011
	,-1.167994587e-011
	,-1.022439901e-011
	,-9.032946308e-012
	,-8.028080186e-012
	,-7.173219789e-012
	,-6.416618746e-012
	,-5.721913368e-012
	,-5.084867760e-012
	,-4.481284699e-012
	,-3.873616230e-012
	,-3.256861380e-012
	,-2.601470230e-012
	,-1.872368729e-012
	,-1.024710431e-012
	,2.469817302e-017
	,1.279328100e-012
	,2.915669544e-012
	,5.049182519e-012
	,7.870379388e-012
	,1.163819831e-011
	,1.670505967e-011
	,2.355276094e-011
	,3.283551725e-011
	,4.545110083e-011
	,6.262165691e-011
	,8.604134135e-011
	,1.179653060e-010
	,1.615720693e-010
	,2.211861646e-010
	,3.027315257e-010
	,4.118570847e-010
	,5.596760694e-010
	,7.612509611e-010
	,1.036336570e-009
	,1.411986105e-009
	,1.924137093e-009
	,2.623598698e-009
	,3.579408282e-009
	,4.885870886e-009
	,6.657725311e-009
	,8.927155624e-009
	,1.196848419e-008
	,1.604285859e-008
	,2.149882979e-008
	,2.880090016e-008
	,3.856699812e-008
	,5.161708369e-008
	,6.903851750e-008
	,9.226663971e-008
	,1.231378873e-007
	,1.640790943e-007
	,2.183325088e-007
	,2.899752671e-007
	,3.842487952e-007
	,5.079356092e-007
	,6.695020810e-007
	,8.794357164e-007
	,1.150545348e-006
	,1.498130970e-006
	,1.940249241e-006
	,2.497650681e-006
	,3.193518553e-006
	,4.053052339e-006
	,5.102805925e-006
	,6.369567431e-006
	,7.880047144e-006
	,9.659538631e-006
	,1.172001644e-005
	,1.408674135e-005
	,1.677534773e-005
	,1.979767305e-005
	,2.316113513e-005
	,2.687124934e-005
	,3.093138614e-005
	,3.534223315e-005
	,4.010279992e-005
	,4.521083236e-005
	,5.066218695e-005
	,5.643508572e-005
	,6.253565369e-005
	,6.896319551e-005
	,7.571317375e-005
	,8.272018681e-005
	,9.001777736e-005
	,9.760355849e-005
	,1.054717865e-004
	,1.136126869e-004
	,1.220169905e-004
	,1.306834303e-004
	,1.396092468e-004
	,1.487889217e-004
	,1.582168339e-004
	,1.678874090e-004
	,1.777959801e-004
	,1.879371939e-004
	,1.981709467e-004
	,2.084003424e-004
	,2.188356132e-004
	,2.294715335e-004
	,2.403025257e-004
	,2.513219453e-004
	,2.625242590e-004
	,2.739065156e-004
	,2.854647247e-004
	,2.971918557e-004
	,3.090847324e-004
	,3.211379274e-004
	,3.333481003e-004
	,3.457111815e-004
	,3.582229410e-004
	,3.708795263e-004
	,3.836849065e-004
	,3.966294509e-004
	,4.097099742e-004
	,4.229241325e-004
	,4.362688362e-004
	,4.497466178e-004
	,4.633555167e-004
	,4.770895850e-004
	,4.909468726e-004
	,5.049255848e-004
	,5.190240783e-004
	,5.331872423e-004
	,5.467989123e-004
	,5.605247010e-004
	,5.743641989e-004
	,5.883165433e-004
	,6.023812289e-004
	,6.165578281e-004
	,6.308459823e-004
	,6.452453933e-004
	,6.597558127e-004
	,6.743905493e-004
	,6.891379311e-004
	,7.039970060e-004
	,7.189585132e-004
	,7.338875975e-004
	,7.489156716e-004
	,7.640419124e-004
	,7.792655716e-004
	,7.945876429e-004
	,8.100065665e-004
	,8.255209614e-004
	,8.411314498e-004
	,8.568266127e-004
	,8.726149111e-004
	,8.884960765e-004
	,9.044697879e-004
	,9.205357671e-004
	,9.366937771e-004
	,9.529436209e-004
	,9.692851398e-004
	,9.857181435e-004
	,1.002242591e-003
	,1.018858500e-003
	,1.035569191e-003
	,1.052376591e-003
	,1.069275528e-003
	,1.086266045e-003
	,1.103347721e-003
	,1.120519180e-003
	,1.137782312e-003
	,1.155137189e-003
	,1.172584174e-003
	,1.190123308e-003
	,1.207754259e-003
	,1.225476944e-003
	,1.243290859e-003
	,1.261196025e-003
	,1.279189282e-003
	,1.297273442e-003
	,1.315448318e-003
	,1.333713693e-003
	,1.352069321e-003
	,1.370514925e-003
	,-4.524711140e-008
	,-3.178849366e-008
	,-2.230922086e-008
	,-1.564127930e-008
	,-1.095795944e-008
	,-7.671735782e-009
	,-5.365985149e-009
	,-3.748119269e-009
	,-2.614217375e-009
	,-1.821280130e-009
	,-1.267894191e-009
	,-8.821998161e-010
	,-6.136162183e-010
	,-4.266936402e-010
	,-2.966380847e-010
	,-2.062030643e-010
	,-1.433455611e-010
	,-9.966335128e-011
	,-6.933823828e-011
	,-4.830090632e-011
	,-3.371245708e-011
	,-2.359619039e-011
	,-1.657876368e-011
	,-1.170777156e-011
	,-8.323477901e-012
	,-5.968402046e-012
	,-4.325608277e-012
	,-3.175717090e-012
	,-2.361983506e-012
	,-1.784096538e-012
	,-1.370976810e-012
	,-1.071983581e-012
	,-8.519393094e-013
	,-6.856747654e-013
	,-5.532499273e-013
	,-4.455381048e-013
	,-3.531705846e-013
	,-2.687586460e-013
	,-1.858345607e-013
	,-9.841375822e-014
	,-5.117373957e-018
	,1.161261248e-013
	,2.583589724e-013
	,4.381147120e-013
	,6.706221956e-013
	,9.758295904e-013
	,1.380648952e-012
	,1.921507726e-012
	,2.647555457e-012
	,3.625460753e-012
	,4.944831759e-012
	,6.728957382e-012
	,9.144855961e-012
	,1.241950417e-011
	,1.686187874e-011
	,2.289234151e-011
	,3.108290029e-011
	,4.221249289e-011
	,5.734101536e-011
	,7.791488396e-011
	,1.059056016e-010
	,1.440052795e-010
	,1.947648218e-010
	,2.623199613e-010
	,3.538214701e-010
	,4.778705164e-010
	,6.461775865e-010
	,8.746990349e-010
	,1.185184567e-009
	,1.607270742e-009
	,2.181348209e-009
	,2.962463681e-009
	,3.965651729e-009
	,5.282646461e-009
	,7.037779961e-009
	,9.376656994e-009
	,1.249304726e-008
	,1.664459624e-008
	,2.217356255e-008
	,2.953400202e-008
	,3.932765682e-008
	,5.235028953e-008
	,6.965161246e-008
	,9.261372890e-008
	,1.230487567e-007
	,1.633234993e-007
	,2.164572199e-007
	,2.863414977e-007
	,3.781208262e-007
	,4.982345438e-007
	,6.547759937e-007
	,8.577861914e-007
	,1.119572257e-006
	,1.454941394e-006
	,1.881379547e-006
	,2.419084848e-006
	,3.090823293e-006
	,3.921592329e-006
	,4.937992055e-006
	,6.167433133e-006
	,7.637192677e-006
	,9.373418814e-006
	,1.140023986e-005
	,1.373901446e-005
	,1.640782495e-005
	,1.942124876e-005
	,2.279037327e-005
	,2.652300998e-005
	,3.062404010e-005
	,3.509585196e-005
	,3.993879660e-005
	,4.515159515e-005
	,5.073173200e-005
	,5.667568198e-005
	,6.297944829e-005
	,6.963832922e-005
	,7.664759090e-005
	,8.400249433e-005
	,9.169808319e-005
	,9.972924745e-005
	,1.080909672e-004
	,1.167781871e-004
	,1.257865081e-004
	,1.351104286e-004
	,1.447448698e-004
	,1.546846047e-004
	,1.649241080e-004
	,1.753999884e-004
	,1.857778155e-004
	,1.963912159e-004
	,2.072574033e-004
	,2.183686393e-004
	,2.297192908e-004
	,2.413020603e-004
	,2.531106496e-004
	,2.651378949e-004
	,2.773777605e-004
	,2.898247177e-004
	,3.024739885e-004
	,3.153197930e-004
	,3.283586429e-004
	,3.415887549e-004
	,3.550031686e-004
	,3.685971307e-004
	,3.822211496e-004
	,3.959831056e-004
	,4.098934308e-004
	,4.239522387e-004
	,4.381517727e-004
	,4.524885681e-004
	,4.669594186e-004
	,4.815614878e-004
	,4.955344685e-004
	,5.093815420e-004
	,5.233503935e-004
	,5.374396865e-004
	,5.516482660e-004
	,5.659750962e-004
	,5.804192524e-004
	,5.949799130e-004
	,6.096563499e-004
	,6.244479187e-004
	,6.393636266e-004
	,6.543957071e-004
	,6.695425193e-004
	,6.848036721e-004
	,7.001067783e-004
	,7.154672981e-004
	,7.309293205e-004
	,7.464933729e-004
	,7.621573860e-004
	,7.779202473e-004
	,7.937811553e-004
	,8.097425511e-004
	,8.257933694e-004
	,8.419368420e-004
	,8.581750505e-004
	,8.745074917e-004
	,8.909337103e-004
	,9.074532974e-004
	,9.240657796e-004
	,9.407709428e-004
	,9.575685150e-004
	,9.744582594e-004
	,9.914399779e-004
	,1.008519928e-003
	,1.025692549e-003
	,1.042956909e-003
	,1.060312934e-003
	,1.077760572e-003
	,1.095299787e-003
	,1.112928957e-003
	,1.130649126e-003
	,1.148460669e-003
	,1.166363563e-003
	,1.184357775e-003
	,1.202443262e-003
	,1.220619967e-003
	,1.238887810e-003
	,1.257243230e-003
	,1.275687846e-003
	,-6.420606190e-008
	,-4.447619595e-008
	,-3.078151092e-008
	,-2.128460769e-008
	,-1.470534279e-008
	,-1.015245139e-008
	,-7.004486872e-009
	,-4.829592805e-009
	,-3.328186010e-009
	,-2.292527585e-009
	,-1.578605171e-009
	,-1.086710963e-009
	,-7.479395085e-010
	,-5.147064294e-010
	,-3.541707160e-010
	,-2.436909649e-010
	,-1.676687391e-010
	,-1.153621664e-010
	,-7.937553690e-011
	,-5.461670528e-011
	,-3.758200289e-011
	,-2.586369355e-011
	,-1.780247429e-011
	,-1.225693378e-011
	,-8.441678112e-012
	,-5.816156396e-012
	,-4.009300936e-012
	,-2.765479653e-012
	,-1.908835388e-012
	,-1.318463121e-012
	,-9.110571687e-013
	,-6.294825893e-013
	,-4.348271698e-013
	,-2.999732262e-013
	,-2.061690770e-013
	,-1.405135716e-013
	,-9.400178830e-014
	,-6.039669053e-014
	,-3.545481061e-014
	,-1.611057773e-014
	,-2.480294525e-017
	,1.454842026e-014
	,2.913950147e-014
	,4.514251330e-014
	,6.396703667e-014
	,8.733292211e-014
	,1.172863725e-013
	,1.553151367e-013
	,2.053656756e-013
	,2.718722555e-013
	,3.607311490e-013
	,4.798738136e-013
	,6.400108189e-013
	,8.556743460e-013
	,1.146512527e-012
	,1.539139314e-012
	,2.069762635e-012
	,2.787334553e-012
	,3.758570826e-012
	,5.073861489e-012
	,6.856261413e-012
	,9.273174451e-012
	,1.255198091e-011
	,1.700239174e-011
	,2.304595361e-011
	,3.125659575e-011
	,4.241588865e-011
	,5.758935542e-011
	,7.794199945e-011
	,1.046198781e-010
	,1.406705832e-010
	,1.894404126e-010
	,2.554826724e-010
	,3.449960623e-010
	,4.664215754e-010
	,6.312577018e-010
	,8.551709550e-010
	,1.159510168e-009
	,1.561297578e-009
	,2.077184755e-009
	,2.764083014e-009
	,3.678754320e-009
	,4.896778490e-009
	,6.518759451e-009
	,8.678558332e-009
	,1.155418906e-008
	,1.538221464e-008
	,2.047675650e-008
	,2.725443592e-008
	,3.626712666e-008
	,4.824459956e-008
	,6.414992192e-008
	,8.525113453e-008
	,1.132126007e-007
	,1.501634758e-007
	,1.988515261e-007
	,2.629906308e-007
	,3.472543296e-007
	,4.575961672e-007
	,6.015263953e-007
	,7.884102543e-007
	,1.029769395e-006
	,1.339557822e-006
	,1.734373220e-006
	,2.233556198e-006
	,2.859127604e-006
	,3.635521547e-006
	,4.589092191e-006
	,5.746819826e-006
	,7.136827570e-006
	,8.786290215e-006
	,1.072076081e-005
	,1.296338757e-005
	,1.553432868e-005
	,1.845041106e-005
	,2.172507674e-005
	,2.536845031e-005
	,2.938775375e-005
	,3.378754188e-005
	,3.857019129e-005
	,4.373637726e-005
	,4.928544323e-005
	,5.521575753e-005
	,6.152507624e-005
	,6.821074333e-005
	,7.526958481e-005
	,8.269838508e-005
	,9.049385719e-005
	,9.865261380e-005
	,1.071713380e-004
	,1.160476644e-004
	,1.252776489e-004
	,1.348578564e-004
	,1.447849742e-004
	,1.550554927e-004
	,1.652487017e-004
	,1.757020788e-004
	,1.864618748e-004
	,1.975200093e-004
	,2.088694244e-004
	,2.205033282e-004
	,2.324151613e-004
	,2.445987217e-004
	,2.570483884e-004
	,2.697587076e-004
	,2.827256331e-004
	,2.959416644e-004
	,3.094015485e-004
	,3.231002025e-004
	,3.370331308e-004
	,3.511959758e-004
	,3.655852006e-004
	,3.801991384e-004
	,3.950322382e-004
	,4.100813260e-004
	,4.253427383e-004
	,4.405955890e-004
	,4.546260721e-004
	,4.687917837e-004
	,4.830540219e-004
	,4.974048923e-004
	,5.118966387e-004
	,5.265278610e-004
	,5.412973176e-004
	,5.562039165e-004
	,5.712467085e-004
	,5.864248793e-004
	,6.017448144e-004
	,6.171996949e-004
	,6.327890603e-004
	,6.485125717e-004
	,6.643493120e-004
	,6.802601115e-004
	,6.962972097e-004
	,7.124593491e-004
	,7.287461888e-004
	,7.451575146e-004
	,7.616932351e-004
	,7.783547443e-004
	,7.951406580e-004
	,8.120461196e-004
	,8.288714706e-004
	,8.457288051e-004
	,8.626847405e-004
	,8.797385160e-004
	,8.968894163e-004
	,9.141367796e-004
	,9.314799969e-004
	,9.489185100e-004
	,9.664551301e-004
	,9.840886477e-004
	,1.001816184e-003
	,1.019637439e-003
	,1.037552102e-003
	,1.055560161e-003
	,1.073660981e-003
	,1.091854320e-003
	,1.110138379e-003
	,1.128513182e-003
	,1.146979695e-003
	,1.165537703e-003
	,-7.679430471e-008
	,-5.307419227e-008
	,-3.661917730e-008
	,-2.522695309e-008
	,-1.736062461e-008
	,-1.194020952e-008
	,-8.209375429e-009
	,-5.643009480e-009
	,-3.878310076e-009
	,-2.665157632e-009
	,-1.831318618e-009
	,-1.258270882e-009
	,-8.644929765e-010
	,-5.939259754e-010
	,-4.080286282e-010
	,-2.803103218e-010
	,-1.925657544e-010
	,-1.322851230e-010
	,-9.087292828e-011
	,-6.242360429e-011
	,-4.287968316e-011
	,-2.945347277e-011
	,-2.022973693e-011
	,-1.389309335e-011
	,-9.539851649e-012
	,-6.549079091e-012
	,-4.494066013e-012
	,-3.082197781e-012
	,-2.112070375e-012
	,-1.445436048e-012
	,-9.872477965e-013
	,-6.722656539e-013
	,-4.557158584e-013
	,-3.067403632e-013
	,-2.042600465e-013
	,-1.336134395e-013
	,-8.489024069e-014
	,-5.120942918e-014
	,-2.784338708e-014
	,-1.148300641e-014
	,1.138299879e-017
	,8.277338720e-015
	,1.436550632e-014
	,1.912560278e-014
	,2.305008068e-014
	,2.661567547e-014
	,3.018972931e-014
	,3.410287625e-014
	,3.870198964e-014
	,4.443017759e-014
	,5.170224694e-014
	,6.115831815e-014
	,7.366476524e-014
	,8.948924931e-014
	,1.104672280e-013
	,1.383765642e-013
	,1.756251635e-013
	,2.254955038e-013
	,2.923551708e-013
	,3.820384041e-013
	,5.026530482e-013
	,6.648871673e-013
	,8.834334557e-013
	,1.178160085e-012
	,1.575766069e-012
	,2.112742242e-012
	,2.838368640e-012
	,3.819739745e-012
	,5.147725042e-012
	,6.945824236e-012
	,9.382058949e-012
	,1.268463357e-011
	,1.716413273e-011
	,2.324322230e-011
	,3.147613269e-011
	,4.204750712e-011
	,5.628421134e-011
	,7.548265894e-011
	,1.014034270e-010
	,1.364396394e-010
	,1.838454543e-010
	,2.480480643e-010
	,3.350729149e-010
	,4.531234174e-010
	,6.131198480e-010
	,8.141786521e-010
	,1.081505748e-009
	,1.437015227e-009
	,1.909878552e-009
	,2.538925566e-009
	,3.375836358e-009
	,4.489380332e-009
	,5.971044666e-009
	,7.942494485e-009
	,1.056545121e-008
	,1.405475583e-008
	,1.869559795e-008
	,2.486618722e-008
	,3.306750162e-008
	,4.396216609e-008
	,5.842503320e-008
	,7.760861900e-008
	,1.029900149e-007
	,1.364683425e-007
	,1.806739135e-007
	,2.389231899e-007
	,3.154854422e-007
	,4.158144617e-007
	,5.468137241e-007
	,7.171275076e-007
	,9.374428346e-007
	,1.220777614e-006
	,1.582719513e-006
	,2.041571084e-006
	,2.618351863e-006
	,3.336611211e-006
	,4.222021580e-006
	,5.301753547e-006
	,6.603653441e-006
	,8.155322244e-006
	,9.983171212e-006
	,1.211156663e-005
	,1.456217280e-005
	,1.735351680e-005
	,2.050082896e-005
	,2.401610065e-005
	,2.790832637e-005
	,3.218386688e-005
	,3.684688025e-005
	,4.189974367e-005
	,4.734349868e-005
	,5.317842713e-005
	,5.940383664e-005
	,6.601877140e-005
	,7.302211873e-005
	,8.041276550e-005
	,8.818972349e-005
	,9.635219897e-005
	,1.048999247e-004
	,1.138334129e-004
	,1.231524152e-004
	,1.328573503e-004
	,1.428595273e-004
	,1.527462973e-004
	,1.629668821e-004
	,1.735138135e-004
	,1.843796451e-004
	,1.955572638e-004
	,2.070405002e-004
	,2.188228152e-004
	,2.308967656e-004
	,2.432560564e-004
	,2.558940685e-004
	,2.688045676e-004
	,2.819813569e-004
	,2.954183945e-004
	,3.091097411e-004
	,3.230524046e-004
	,3.372388258e-004
	,3.516637541e-004
	,3.663234689e-004
	,3.812113962e-004
	,3.963233844e-004
	,4.116550694e-004
	,4.257329546e-004
	,4.399255605e-004
	,4.542917959e-004
	,4.688293587e-004
	,4.835365362e-004
	,4.984117787e-004
	,5.134536955e-004
	,5.286610507e-004
	,5.440363353e-004
	,5.595760796e-004
	,5.752788966e-004
	,5.911442933e-004
	,6.071723240e-004
	,6.233525363e-004
	,6.396622957e-004
	,6.561287428e-004
	,6.727515441e-004
	,6.895304884e-004
	,7.064654995e-004
	,7.235566303e-004
	,7.408048727e-004
	,7.582116500e-004
	,7.757480249e-004
	,7.932853927e-004
	,8.109721105e-004
	,8.288088518e-004
	,8.467964865e-004
	,8.649360021e-004
	,8.832285623e-004
	,9.016755182e-004
	,9.200890535e-004
	,9.382882474e-004
	,9.566043571e-004
	,9.750372088e-004
	,9.935866185e-004
	,1.012252636e-003
	,1.031035391e-003
	,-8.499774367e-008
	,-5.895158326e-008
	,-4.084120502e-008
	,-2.826459637e-008
	,-1.954151799e-008
	,-1.349831492e-008
	,-9.316358496e-009
	,-6.425441861e-009
	,-4.428878610e-009
	,-3.051114298e-009
	,-2.101043255e-009
	,-1.446298577e-009
	,-9.953039354e-010
	,-6.847802856e-010
	,-4.710453588e-010
	,-3.239695863e-010
	,-2.227852175e-010
	,-1.531853379e-010
	,-1.053178450e-010
	,-7.240070496e-011
	,-4.976668895e-011
	,-3.420458227e-011
	,-2.350551745e-011
	,-1.615014049e-011
	,-1.109376595e-011
	,-7.617877212e-012
	,-5.228534365e-012
	,-3.586142871e-012
	,-2.457077348e-012
	,-1.681044191e-012
	,-1.147544793e-012
	,-7.807817652e-013
	,-5.285826011e-013
	,-3.551636312e-013
	,-2.359136619e-013
	,-1.538158484e-013
	,-9.730478696e-014
	,-5.834432612e-014
	,-3.147127600e-014
	,-1.289227401e-014
	,-1.153998741e-017
	,8.957926880e-015
	,1.527344455e-014
	,1.975674204e-014
	,2.298026739e-014
	,2.532164940e-014
	,2.716128431e-014
	,2.860125513e-014
	,2.987502125e-014
	,3.104002067e-014
	,3.217510011e-014
	,3.339116714e-014
	,3.484967477e-014
	,3.650717898e-014
	,3.853850019e-014
	,4.118795878e-014
	,4.450573468e-014
	,4.887817681e-014
	,5.456856011e-014
	,6.162064189e-014
	,7.093938405e-014
	,8.318568918e-014
	,9.939506011e-014
	,1.209419883e-013
	,1.496968120e-013
	,1.879802876e-013
	,2.392744115e-013
	,3.079511038e-013
	,4.000546703e-013
	,5.237714889e-013
	,6.900574416e-013
	,9.139115239e-013
	,1.215378556e-012
	,1.621812709e-012
	,2.170198786e-012
	,2.910621057e-012
	,3.911150348e-012
	,5.264088073e-012
	,7.094771012e-012
	,9.573534026e-012
	,1.293197645e-011
	,1.723748070e-011
	,2.295107918e-011
	,3.062725696e-011
	,4.095524850e-011
	,5.486977202e-011
	,7.363940569e-011
	,9.898764655e-011
	,1.332563426e-010
	,1.796294955e-010
	,2.424380252e-010
	,3.233250273e-010
	,4.285169956e-010
	,5.681571711e-010
	,7.535791502e-010
	,9.998563372e-010
	,1.327037654e-009
	,1.761790001e-009
	,2.339582069e-009
	,3.107585898e-009
	,4.128529759e-009
	,5.485810537e-009
	,7.290271306e-009
	,9.689174803e-009
	,1.287806888e-008
	,1.711644707e-008
	,2.274837343e-008
	,3.022957308e-008
	,4.016290270e-008
	,5.334461440e-008
	,7.079519596e-008
	,9.381463244e-008
	,1.242555889e-007
	,1.644484053e-007
	,2.174167281e-007
	,2.870606022e-007
	,3.783747551e-007
	,4.977014819e-007
	,6.530129178e-007
	,8.542106166e-007
	,1.113421526e-006
	,1.445259257e-006
	,1.867008922e-006
	,2.398688327e-006
	,3.062936705e-006
	,3.884694976e-006
	,4.890662912e-006
	,6.108554181e-006
	,7.566210832e-006
	,9.290659287e-006
	,1.130721893e-005
	,1.363876807e-005
	,1.630522455e-005
	,1.932327780e-005
	,2.270636030e-005
	,2.646481793e-005
	,3.060621995e-005
	,3.513576600e-005
	,4.005670776e-005
	,4.537085896e-005
	,5.107880613e-005
	,5.718037613e-005
	,6.367475729e-005
	,7.056089649e-005
	,7.783761996e-005
	,8.550373504e-005
	,9.355825546e-005
	,1.020001704e-004
	,1.108286495e-004
	,1.200430808e-004
	,1.296075022e-004
	,1.391014357e-004
	,1.489512484e-004
	,1.591506543e-004
	,1.696942298e-004
	,1.805769908e-004
	,1.917943309e-004
	,2.033419897e-004
	,2.152160430e-004
	,2.274129108e-004
	,2.399293797e-004
	,2.527627296e-004
	,2.659123036e-004
	,2.793756163e-004
	,2.931512022e-004
	,3.072115055e-004
	,3.213252024e-004
	,3.356958081e-004
	,3.503179481e-004
	,3.651861745e-004
	,3.802950147e-004
	,3.946726247e-004
	,4.086155785e-004
	,4.227415775e-004
	,4.370482707e-004
	,4.515336499e-004
	,4.661955601e-004
	,4.810345229e-004
	,4.960475511e-004
	,5.112320123e-004
	,5.265862071e-004
	,5.421086887e-004
	,5.577981295e-004
	,5.736533127e-004
	,5.896431750e-004
	,6.057928479e-004
	,6.221014501e-004
	,6.385679045e-004
	,6.551912270e-004
	,6.719705217e-004
	,6.889049769e-004
	,7.059961216e-004
	,7.232404716e-004
	,7.406355714e-004
	,7.581832406e-004
	,7.758830669e-004
	,7.937347219e-004
	,8.117380335e-004
	,8.298928858e-004
	,8.482009542e-004
	,8.666610004e-004
	,-9.070284117e-008
	,-6.329230030e-008
	,-4.412688795e-008
	,-3.073859306e-008
	,-2.139404273e-008
	,-1.487735749e-008
	,-1.033656896e-008
	,-7.175261623e-009
	,-4.976272423e-009
	,-3.448046474e-009
	,-2.386970359e-009
	,-1.650952988e-009
	,-1.140912319e-009
	,-7.878127234e-010
	,-5.435957628e-010
	,-3.748388505e-010
	,-2.583231538e-010
	,-1.779367240e-010
	,-1.225126632e-010
	,-8.432067590e-011
	,-5.801536095e-011
	,-3.990415282e-011
	,-2.743863371e-011
	,-1.886109477e-011
	,-1.296023721e-011
	,-8.901475985e-012
	,-6.110143538e-012
	,-4.190743160e-012
	,-2.871103186e-012
	,-1.963791498e-012
	,-1.340064354e-012
	,-9.112895315e-013
	,-6.165226431e-013
	,-4.139348782e-013
	,-2.746595657e-013
	,-1.788750063e-013
	,-1.130117842e-013
	,-6.765398264e-014
	,-3.644175221e-014
	,-1.487315420e-014
	,-2.501181074e-017
	,1.030140185e-014
	,1.751853957e-014
	,2.252467957e-014
	,2.608249412e-014
	,2.864590013e-014
	,3.052072887e-014
	,3.188832781e-014
	,3.296936330e-014
	,3.383772153e-014
	,3.454154597e-014
	,3.515994444e-014
	,3.574497664e-014
	,3.630719029e-014
	,3.687081378e-014
	,3.744159092e-014
	,3.806066819e-014
	,3.878825109e-014
	,3.961838693e-014
	,4.056903815e-014
	,4.168171677e-014
	,4.310132320e-014
	,4.484801298e-014
	,4.703582664e-014
	,4.992600270e-014
	,5.335975115e-014
	,5.768284881e-014
	,6.334853377e-014
	,7.075192728e-014
	,8.042709838e-014
	,9.324344962e-014
	,1.101386826e-013
	,1.325646211e-013
	,1.624073728e-013
	,2.021784406e-013
	,2.552708441e-013
	,3.263513692e-013
	,4.215412364e-013
	,5.492944325e-013
	,7.208583115e-013
	,9.515210951e-013
	,1.261989341e-012
	,1.680128316e-012
	,2.243961613e-012
	,3.004854059e-012
	,4.032330495e-012
	,5.420992833e-012
	,7.214317466e-012
	,9.542539486e-012
	,1.265735986e-011
	,1.683154213e-011
	,2.243440045e-011
	,2.996597158e-011
	,4.010414110e-011
	,5.376817445e-011
	,7.220626785e-011
	,9.711334273e-011
	,1.300359395e-010
	,1.718781500e-010
	,2.273018381e-010
	,3.007432793e-010
	,3.980948385e-010
	,5.271838815e-010
	,6.984104860e-010
	,9.255942585e-010
	,1.227100759e-009
	,1.627338131e-009
	,2.158745804e-009
	,2.864435292e-009
	,3.801695704e-009
	,5.046644666e-009
	,6.700391986e-009
	,8.897201729e-009
	,1.181527414e-008
	,1.569103579e-008
	,2.083790272e-008
	,2.767100989e-008
	,3.673965123e-008
	,4.874685348e-008
	,6.457397384e-008
	,8.552200484e-008
	,1.132161741e-007
	,1.497775798e-007
	,1.979619959e-007
	,2.613302272e-007
	,3.444529599e-007
	,4.531507692e-007
	,5.947659740e-007
	,7.784571382e-007
	,1.015498774e-006
	,1.319559031e-006
	,1.706917853e-006
	,2.196579876e-006
	,2.810233599e-006
	,3.572014849e-006
	,4.508051373e-006
	,5.645795534e-006
	,7.013193252e-006
	,8.637755235e-006
	,1.054564539e-005
	,1.276088627e-005
	,1.530475444e-005
	,1.819541713e-005
	,2.144781198e-005
	,2.507374048e-005
	,2.908212454e-005
	,3.347938885e-005
	,3.826984673e-005
	,4.345609360e-005
	,4.903943913e-005
	,5.502025486e-005
	,6.139826944e-005
	,6.817294474e-005
	,7.534346100e-005
	,8.290866892e-005
	,9.086768903e-005
	,9.921954505e-005
	,1.079634761e-004
	,1.170988166e-004
	,1.261422631e-004
	,1.355458885e-004
	,1.453046991e-004
	,1.554125534e-004
	,1.658636744e-004
	,1.766525695e-004
	,1.877744198e-004
	,1.992250002e-004
	,2.109989130e-004
	,2.230911797e-004
	,2.354973539e-004
	,2.482131963e-004
	,2.612346916e-004
	,2.745580706e-004
	,2.881798351e-004
	,3.020967850e-004
	,3.163057694e-004
	,3.308046974e-004
	,3.455914139e-004
	,3.606642069e-004
	,3.750200272e-004
	,3.889078467e-004
	,4.030094685e-004
	,4.173256250e-004
	,4.318538297e-004
	,4.465949904e-004
	,4.615497109e-004
	,4.767190561e-004
	,4.918500758e-004
	,5.071155260e-004
	,5.225566441e-004
	,5.381570477e-004
	,5.539198329e-004
	,5.698510706e-004
	,5.859492991e-004
	,6.022131500e-004
	,6.186413413e-004
	,6.352326721e-004
	,6.519870916e-004
	,6.689037559e-004
	,6.859796778e-004
	,7.032129143e-004
	,-9.448179153e-008
	,-6.614849688e-008
	,-4.628206853e-008
	,-3.236243290e-008
	,-2.261586522e-008
	,-1.579543301e-008
	,-1.102539958e-008
	,-7.691234127e-009
	,-5.362011809e-009
	,-3.735749668e-009
	,-2.600948009e-009
	,-1.809559192e-009
	,-1.258005243e-009
	,-8.738569922e-010
	,-6.064923794e-010
	,-4.205486742e-010
	,-2.913353920e-010
	,-2.016228577e-010
	,-1.393941442e-010
	,-9.627283140e-011
	,-6.642356967e-011
	,-4.578389602e-011
	,-3.152784726e-011
	,-2.169128303e-011
	,-1.491074413e-011
	,-1.024085552e-011
	,-7.027005600e-012
	,-4.816677020e-012
	,-3.297221083e-012
	,-2.253184330e-012
	,-1.535968058e-012
	,-1.043472921e-012
	,-7.052945963e-013
	,-4.730097633e-013
	,-3.135558526e-013
	,-2.040455417e-013
	,-1.287796135e-013
	,-7.705183260e-014
	,-4.148339934e-014
	,-1.695042581e-014
	,-2.401969972e-017
	,1.176669761e-014
	,1.989005043e-014
	,2.561009262e-014
	,2.964318057e-014
	,3.254646293e-014
	,3.463501327e-014
	,3.622212982e-014
	,3.737423180e-014
	,3.832577070e-014
	,3.911408123e-014
	,3.977827345e-014
	,4.033719747e-014
	,4.086160647e-014
	,4.137191705e-014
	,4.184160329e-014
	,4.234564791e-014
	,4.276995812e-014
	,4.328924992e-014
	,4.375000716e-014
	,4.425593157e-014
	,4.482075604e-014
	,4.533263311e-014
	,4.596403344e-014
	,4.662577150e-014
	,4.733737618e-014
	,4.814740872e-014
	,4.910082741e-014
	,5.022614239e-014
	,5.155859970e-014
	,5.317871700e-014
	,5.499642104e-014
	,5.731310470e-014
	,6.017920901e-014
	,6.382103970e-014
	,6.848270830e-014
	,7.445009943e-014
	,8.226297372e-014
	,9.247299709e-014
	,1.058512487e-013
	,1.236033000e-013
	,1.470376934e-013
	,1.782255387e-013
	,2.196906622e-013
	,2.750346878e-013
	,3.490057544e-013
	,4.479920649e-013
	,5.807424199e-013
	,7.589084843e-013
	,9.984064343e-013
	,1.320469221e-012
	,1.754039543e-012
	,2.338440450e-012
	,3.102556682e-012
	,4.067497332e-012
	,5.352422610e-012
	,7.066715992e-012
	,9.358210010e-012
	,1.242647380e-011
	,1.654144250e-011
	,2.206852411e-011
	,2.950114344e-011
	,3.951110152e-011
	,5.300816796e-011
	,6.992893006e-011
	,9.219614476e-011
	,1.216288457e-010
	,1.605516770e-010
	,2.120471939e-010
	,2.802040605e-010
	,3.704477249e-010
	,4.899786650e-010
	,6.483550590e-010
	,8.582666756e-010
	,1.136563322e-009
	,1.505620233e-009
	,1.995151135e-009
	,2.644616462e-009
	,3.506419466e-009
	,4.650141645e-009
	,6.168159673e-009
	,8.183077460e-009
	,1.085753816e-008
	,1.440732893e-008
	,1.911846139e-008
	,2.536983385e-008
	,3.364526455e-008
	,4.453643482e-008
	,5.895680979e-008
	,7.803425224e-008
	,1.032469351e-007
	,1.365255235e-007
	,1.803812144e-007
	,2.380638161e-007
	,3.137533157e-007
	,4.127865990e-007
	,5.419177181e-007
	,7.096049293e-007
	,9.263103960e-007
	,1.204789200e-006
	,1.560333757e-006
	,2.010932033e-006
	,2.577289710e-006
	,3.282672615e-006
	,4.152538078e-006
	,5.213950408e-006
	,6.494810005e-006
	,8.022959995e-006
	,9.825270641e-006
	,1.192679406e-005
	,1.435008674e-005
	,1.711477056e-005
	,2.023729741e-005
	,2.373096170e-005
	,2.760609914e-005
	,3.187040922e-005
	,3.652934790e-005
	,4.158655204e-005
	,4.704417853e-005
	,5.290332784e-005
	,5.916433170e-005
	,6.582701271e-005
	,7.289089098e-005
	,8.035533982e-005
	,8.821969625e-005
	,9.648330768e-005
	,1.051458270e-004
	,1.137753327e-004
	,1.227287230e-004
	,1.320454724e-004
	,1.417199462e-004
	,1.517455283e-004
	,1.621163769e-004
	,1.728268589e-004
	,1.838714987e-004
	,1.952449578e-004
	,2.069420247e-004
	,2.189576136e-004
	,2.312867703e-004
	,2.439246821e-004
	,2.568669857e-004
	,2.701090795e-004
	,2.836467356e-004
	,2.974757446e-004
	,3.115920455e-004
	,3.259924486e-004
	,3.406757007e-004
	,3.549826326e-004
	,3.685246103e-004
	,3.822742987e-004
	,3.962305728e-004
	,4.103918110e-004
	,4.247561165e-004
	,4.393224584e-004
	,4.540902622e-004
	,4.690588236e-004
	,4.842200415e-004
	,4.995726237e-004
	,5.151238427e-004
	,5.308739490e-004
	,5.468234832e-004
	,-9.722323928e-008
	,-6.820071426e-008
	,-4.781587554e-008
	,-3.350726047e-008
	,-2.346939771e-008
	,-1.643116308e-008
	,-1.149847912e-008
	,-8.042966204e-009
	,-5.623276333e-009
	,-3.929603640e-009
	,-2.744589590e-009
	,-1.915807532e-009
	,-1.336412903e-009
	,-9.315445114e-010
	,-6.487734121e-010
	,-4.513976477e-010
	,-3.137338939e-010
	,-2.178110602e-010
	,-1.510509501e-010
	,-1.046459864e-010
	,-7.242945633e-011
	,-5.008787157e-011
	,-3.460937374e-011
	,-2.389459520e-011
	,-1.648303692e-011
	,-1.135975682e-011
	,-7.820603194e-012
	,-5.377242095e-012
	,-3.691460103e-012
	,-2.529047222e-012
	,-1.727972714e-012
	,-1.176195131e-012
	,-7.963246986e-013
	,-5.348835504e-013
	,-3.550201406e-013
	,-2.312443175e-013
	,-1.461172758e-013
	,-8.750946600e-014
	,-4.708548475e-014
	,-1.926277552e-014
	,1.524701013e-017
	,1.335094226e-014
	,2.265135648e-014
	,2.916775052e-014
	,3.376957917e-014
	,3.707466649e-014
	,3.949604397e-014
	,4.126633555e-014
	,4.262688527e-014
	,4.374948500e-014
	,4.463256824e-014
	,4.536944565e-014
	,4.608115476e-014
	,4.666650026e-014
	,4.719947275e-014
	,4.774706581e-014
	,4.831502326e-014
	,4.879525721e-014
	,4.926557005e-014
	,4.981425966e-014
	,5.033193275e-014
	,5.079524860e-014
	,5.132106744e-014
	,5.182594752e-014
	,5.237139971e-014
	,5.289753185e-014
	,5.341186309e-014
	,5.394666315e-014
	,5.452208754e-014
	,5.504226701e-014
	,5.563742919e-014
	,5.629686972e-014
	,5.695432603e-014
	,5.767752274e-014
	,5.847434454e-014
	,5.937873206e-014
	,6.045271835e-014
	,6.157244618e-014
	,6.289790650e-014
	,6.449014025e-014
	,6.638846637e-014
	,6.882248021e-014
	,7.177437601e-014
	,7.559024386e-014
	,8.043806382e-014
	,8.674104956e-014
	,9.489181597e-014
	,1.055918900e-013
	,1.196884822e-013
	,1.382764654e-013
	,1.628875024e-013
	,1.955048231e-013
	,2.389750551e-013
	,2.969794525e-013
	,3.744576838e-013
	,4.782315044e-013
	,6.173110577e-013
	,8.040116267e-013
	,1.054850450e-012
	,1.388827759e-012
	,1.796268226e-012
	,2.335968527e-012
	,3.052540136e-012
	,4.005857475e-012
	,5.276883277e-012
	,6.974432279e-012
	,9.245796782e-012
	,1.228997045e-011
	,1.637611440e-011
	,2.186770805e-011
	,2.893279938e-011
	,3.800371012e-011
	,4.996067051e-011
	,6.573034348e-011
	,8.653961371e-011
	,1.140125602e-010
	,1.503003720e-010
	,1.982529122e-010
	,2.616470191e-010
	,3.454892129e-010
	,4.564177077e-010
	,6.032205634e-010
	,7.975790884e-010
	,1.054984076e-009
	,1.395986630e-009
	,1.847857222e-009
	,2.446785483e-009
	,3.240791864e-009
	,4.293597128e-009
	,5.689773972e-009
	,7.541517593e-009
	,9.997654423e-009
	,1.325555401e-008
	,1.757688837e-008
	,2.329483803e-008
	,3.080216679e-008
	,4.074187387e-008
	,5.389443300e-008
	,7.128572513e-008
	,9.426070626e-008
	,1.245771520e-007
	,1.645235435e-007
	,2.170654144e-007
	,2.860239502e-007
	,3.762892737e-007
	,4.940682318e-007
	,6.471611209e-007
	,8.452604833e-007
	,1.100244790e-006
	,1.426443951e-006
	,1.840834442e-006
	,2.363118103e-006
	,3.015637937e-006
	,3.823093784e-006
	,4.812042207e-006
	,6.010197177e-006
	,7.445583302e-006
	,9.145627051e-006
	,1.113628308e-005
	,1.344129240e-005
	,1.608164233e-005
	,1.907526217e-005
	,2.243694971e-005
	,2.617850166e-005
	,3.030898088e-005
	,3.483507150e-005
	,3.976151397e-005
	,4.509139815e-005
	,5.082663760e-005
	,5.696827216e-005
	,6.351673457e-005
	,7.047207725e-005
	,7.783423234e-005
	,8.560319045e-005
	,9.377852790e-005
	,1.019911086e-004
	,1.104804958e-004
	,1.193425355e-004
	,1.285706272e-004
	,1.381585227e-004
	,1.481004721e-004
	,1.583904764e-004
	,1.690228302e-004
	,1.799919367e-004
	,1.912922903e-004
	,2.029184731e-004
	,2.148651571e-004
	,2.271271546e-004
	,2.396994733e-004
	,2.525778749e-004
	,2.657578333e-004
	,2.792337717e-004
	,2.930011940e-004
	,3.070557847e-004
	,3.213933038e-004
	,3.356000387e-004
	,3.488329243e-004
	,3.622743408e-004
	,3.759215926e-004
	,3.897732078e-004
	,4.038272237e-004
	,-9.937476597e-008
	,-6.980154541e-008
	,-4.900490752e-008
	,-3.438904357e-008
	,-2.412237320e-008
	,-1.691402122e-008
	,-1.185502886e-008
	,-8.305841389e-009
	,-5.816742787e-009
	,-4.071676385e-009
	,-2.848626212e-009
	,-1.991706055e-009
	,-1.391512190e-009
	,-9.713039802e-010
	,-6.772812189e-010
	,-4.717346155e-010
	,-3.282150382e-010
	,-2.281437397e-010
	,-1.584598515e-010
	,-1.099899225e-010
	,-7.630487753e-011
	,-5.291037625e-011
	,-3.667116372e-011
	,-2.540336818e-011
	,-1.758791112e-011
	,-1.216874142e-011
	,-8.412338309e-012
	,-5.809264253e-012
	,-4.005953814e-012
	,-2.757154902e-012
	,-1.892549311e-012
	,-1.294135514e-012
	,-8.801437203e-013
	,-5.937293623e-013
	,-3.956668769e-013
	,-2.587172815e-013
	,-1.640008079e-013
	,-9.850863536e-014
	,-5.317182478e-014
	,-2.177845577e-014
	,2.334054740e-017
	,1.516770640e-014
	,2.575807381e-014
	,3.317446920e-014
	,3.843359750e-014
	,4.223181622e-014
	,4.497829282e-014
	,4.703154490e-014
	,4.860539850e-014
	,4.985034118e-014
	,5.086380869e-014
	,5.167352793e-014
	,5.240194629e-014
	,5.309814714e-014
	,5.370881758e-014
	,5.430089900e-014
	,5.481778884e-014
	,5.532418319e-014
	,5.584112525e-014
	,5.635300232e-014
	,5.685219081e-014
	,5.737378012e-014
	,5.786492729e-014
	,5.835200159e-014
	,5.884957137e-014
	,5.936338045e-014
	,5.985692957e-014
	,6.030327510e-014
	,6.079985277e-014
	,6.131507169e-014
	,6.180439129e-014
	,6.228076123e-014
	,6.281065295e-014
	,6.329986811e-014
	,6.379420048e-014
	,6.436221015e-014
	,6.489821118e-014
	,6.546204354e-014
	,6.602833007e-014
	,6.667957263e-014
	,6.735875094e-014
	,6.802367419e-014
	,6.883694415e-014
	,6.963381816e-014
	,7.055319178e-014
	,7.155209093e-014
	,7.275343294e-014
	,7.415627792e-014
	,7.582934262e-014
	,7.787330018e-014
	,8.041247780e-014
	,8.361945056e-014
	,8.765175526e-014
	,9.278373671e-014
	,9.950737752e-014
	,1.081663136e-013
	,1.194590957e-013
	,1.343990866e-013
	,1.540187087e-013
	,1.800577067e-013
	,2.146513126e-013
	,2.606721576e-013
	,3.221805867e-013
	,4.043073803e-013
	,5.143959875e-013
	,6.620118207e-013
	,8.401489573e-013
	,1.071426328e-012
	,1.376843632e-012
	,1.781087204e-012
	,2.317523878e-012
	,3.030802409e-012
	,3.981284973e-012
	,5.250298513e-012
	,6.947700317e-012
	,9.221831766e-012
	,1.222214055e-011
	,1.597578345e-011
	,2.090811900e-011
	,2.739329685e-011
	,3.592575724e-011
	,4.715802461e-011
	,6.195298860e-011
	,8.145105696e-011
	,1.071606765e-010
	,1.410775405e-010
	,1.858427011e-010
	,2.449527147e-010
	,3.230320405e-010
	,4.262074413e-010
	,5.626091515e-010
	,7.430035111e-010
	,9.816604571e-010
	,1.297501727e-009
	,1.715615484e-009
	,2.269272031e-009
	,3.002596525e-009
	,3.974113275e-009
	,5.261448203e-009
	,6.967563596e-009
	,9.229028476e-009
	,1.222690704e-008
	,1.619110558e-008
	,2.137869843e-008
	,2.824456604e-008
	,3.732814438e-008
	,4.933986650e-008
	,6.521354379e-008
	,8.617369994e-008
	,1.138212991e-007
	,1.502424568e-007
	,1.981434923e-007
	,2.610169458e-007
	,3.433415277e-007
	,4.508168647e-007
	,5.906303299e-007
	,7.717475428e-007
	,1.005210311e-006
	,1.304416311e-006
	,1.685344738e-006
	,2.166683928e-006
	,2.769814212e-006
	,3.518604450e-006
	,4.438995710e-006
	,5.558380718e-006
	,6.904813129e-006
	,8.506121103e-006
	,1.038901963e-005
	,1.257831986e-005
	,1.509631384e-005
	,1.796237529e-005
	,2.119280382e-005
	,2.480087242e-005
	,2.879707230e-005
	,3.318938171e-005
	,3.798366232e-005
	,4.318407527e-005
	,4.879344477e-005
	,5.481362351e-005
	,6.124579130e-005
	,6.809060438e-005
	,7.534848549e-005
	,8.301985577e-005
	,9.081049546e-005
	,9.881901910e-005
	,1.072094193e-004
	,1.159751620e-004
	,1.251099903e-004
	,1.346077575e-004
	,1.444626290e-004
	,1.546688547e-004
	,1.652206622e-004
	,1.761130061e-004
	,1.873403351e-004
	,1.988966806e-004
	,2.107765583e-004
	,2.229745903e-004
	,2.354855100e-004
	,2.483041037e-004
	,2.614253097e-004
	,2.748442060e-004
	,-1.011499783e-007
	,-7.111752453e-008
	,-4.997871490e-008
	,-3.510843037e-008
	,-2.465292402e-008
	,-1.730462730e-008
	,-1.214205490e-008
	,-8.516280696e-009
	,-5.970596727e-009
	,-4.183743681e-009
	,-2.929848434e-009
	,-2.050183171e-009
	,-1.433274139e-009
	,-1.000887977e-009
	,-6.981288086e-010
	,-4.864270841e-010
	,-3.386224232e-010
	,-2.355705144e-010
	,-1.637979657e-010
	,-1.138490018e-010
	,-7.910666855e-011
	,-5.495059127e-011
	,-3.815966997e-011
	,-2.649074980e-011
	,-1.838284389e-011
	,-1.275005655e-011
	,-8.837301963e-012
	,-6.119776727e-012
	,-4.232635413e-012
	,-2.922309169e-012
	,-2.012509005e-012
	,-1.380941364e-012
	,-9.425286011e-013
	,-6.382144195e-013
	,-4.269389473e-013
	,-2.802589881e-013
	,-1.783549312e-013
	,-1.075179433e-013
	,-5.827691479e-014
	,-2.394094449e-014
	,-5.430672184e-018
	,1.677863362e-014
	,2.858334492e-014
	,3.689822738e-014
	,4.285225112e-014
	,4.711890289e-014
	,5.026086627e-014
	,5.262094174e-014
	,5.435713603e-014
	,5.575173082e-014
	,5.686759464e-014
	,5.778106781e-014
	,5.856906504e-014
	,5.926479594e-014
	,5.988852048e-014
	,6.047757334e-014
	,6.107283995e-014
	,6.159322829e-014
	,6.211278117e-014
	,6.265551811e-014
	,6.312953831e-014
	,6.365582710e-014
	,6.420811964e-014
	,6.468595164e-014
	,6.520090948e-014
	,6.570046348e-014
	,6.622555129e-014
	,6.673533971e-014
	,6.726544029e-014
	,6.776530760e-014
	,6.827859451e-014
	,6.878885287e-014
	,6.934260747e-014
	,6.985960174e-014
	,7.039863133e-014
	,7.093677323e-014
	,7.144217547e-014
	,7.201770430e-014
	,7.258456520e-014
	,7.309048961e-014
	,7.370528514e-014
	,7.426102396e-014
	,7.483535181e-014
	,7.542487462e-014
	,7.604149773e-014
	,7.665968733e-014
	,7.732816129e-014
	,7.798613976e-014
	,7.869978088e-014
	,7.940412749e-014
	,8.019202029e-014
	,8.102596793e-014
	,8.195421833e-014
	,8.294685151e-014
	,8.412542718e-014
	,8.541558924e-014
	,8.696698980e-014
	,8.884406385e-014
	,9.105375617e-014
	,9.380112045e-014
	,9.723194479e-014
	,1.016026638e-013
	,1.071608352e-013
	,1.143125458e-013
	,1.236535322e-013
	,1.357784865e-013
	,1.517099097e-013
	,1.727757685e-013
	,2.006910573e-013
	,2.376645287e-013
	,2.869992856e-013
	,3.527246042e-013
	,4.335722012e-013
	,5.348984839e-013
	,6.678523782e-013
	,8.428891157e-013
	,1.073921017e-012
	,1.379695534e-012
	,1.785255115e-012
	,2.324569224e-012
	,3.043193876e-012
	,4.002696191e-012
	,5.284543052e-012
	,6.880763005e-012
	,8.949845522e-012
	,1.166146357e-011
	,1.521757305e-011
	,1.988437066e-011
	,2.601276423e-011
	,3.406554955e-011
	,4.465342337e-011
	,5.858241714e-011
	,7.691702606e-011
	,1.010547898e-010
	,1.328465428e-010
	,1.747532397e-010
	,2.300194039e-010
	,3.029374893e-010
	,3.991879599e-010
	,5.262899613e-010
	,6.941995952e-010
	,9.161029704e-010
	,1.209468349e-009
	,1.597441602e-009
	,2.110697873e-009
	,2.789898881e-009
	,3.688954082e-009
	,4.879327316e-009
	,6.455758453e-009
	,8.544089496e-009
	,1.130367678e-008
	,1.489934209e-008
	,1.965524264e-008
	,2.594427789e-008
	,3.425814050e-008
	,4.524420897e-008
	,5.975332748e-008
	,7.890132501e-008
	,1.041476498e-007
	,1.373949723e-007
	,1.811139296e-007
	,2.384970364e-007
	,3.136436966e-007
	,4.117865534e-007
	,5.395420138e-007
	,7.051938534e-007
	,9.189899220e-007
	,1.193431309e-006
	,1.543521976e-006
	,1.986938061e-006
	,2.544070353e-006
	,3.237896520e-006
	,4.093650083e-006
	,5.138279650e-006
	,6.399723968e-006
	,7.906062384e-006
	,9.684628417e-006
	,1.176117892e-005
	,1.415921137e-005
	,1.689948869e-005
	,1.999979105e-005
	,2.347488587e-005
	,2.733671224e-005
	,3.159460026e-005
	,3.625564871e-005
	,4.132512880e-005
	,4.680685314e-005
	,5.270367647e-005
	,5.901751574e-005
	,6.574972964e-005
	,7.290139824e-005
	,8.026433068e-005
	,8.777517951e-005
	,9.567682426e-005
	,1.039632882e-004
	,1.126281822e-004
	,1.216654850e-004
	,1.310692223e-004
	,1.408336767e-004
	,1.509534638e-004
	,1.614226764e-004
	,-1.026621204e-007
	,-7.223579834e-008
	,-5.080418780e-008
	,-3.571667437e-008
	,-2.510028196e-008
	,-1.763299798e-008
	,-1.238252462e-008
	,-8.691866008e-009
	,-6.098309049e-009
	,-4.276142372e-009
	,-2.996215394e-009
	,-2.097419991e-009
	,-1.466581453e-009
	,-1.024231065e-009
	,-7.144935946e-010
	,-4.979689964e-010
	,-3.468294426e-010
	,-2.414496122e-010
	,-1.680327261e-010
	,-1.169108361e-010
	,-8.132568995e-011
	,-5.656107229e-011
	,-3.932950693e-011
	,-2.734079350e-011
	,-1.900045895e-011
	,-1.319874445e-011
	,-9.163141142e-012
	,-6.356315784e-012
	,-4.404035802e-012
	,-3.046259865e-012
	,-2.101926718e-012
	,-1.445140137e-012
	,-9.883314428e-013
	,-6.705548890e-013
	,-4.494977765e-013
	,-2.956050658e-013
	,-1.884715917e-013
	,-1.138803513e-013
	,-6.180433941e-014
	,-2.547438262e-014
	,-2.945020214e-017
	,1.786645724e-014
	,3.048297644e-014
	,3.948560070e-014
	,4.591588995e-014
	,5.061311790e-014
	,5.407574201e-014
	,5.671789031e-014
	,5.876743503e-014
	,6.039434045e-014
	,6.173442136e-014
	,6.286407029e-014
	,6.387842549e-014
	,6.472563608e-014
	,6.555551084e-014
	,6.628481687e-014
	,6.700676040e-014
	,6.767236246e-014
	,6.829640029e-014
	,6.892242235e-014
	,6.949372164e-014
	,7.009332221e-014
	,7.065198515e-014
	,7.126589301e-014
	,7.184304054e-014
	,7.242572301e-014
	,7.298511697e-014
	,7.355902709e-014
	,7.410134630e-014
	,7.471483643e-014
	,7.526932206e-014
	,7.580673293e-014
	,7.644998639e-014
	,7.697658847e-014
	,7.758892984e-014
	,7.818022800e-014
	,7.877225720e-014
	,7.937065680e-014
	,7.996258156e-014
	,8.059262427e-014
	,8.120574889e-014
	,8.183103991e-014
	,8.242317354e-014
	,8.304460055e-014
	,8.368895055e-014
	,8.434353496e-014
	,8.497441314e-014
	,8.562758770e-014
	,8.624133891e-014
	,8.691273699e-014
	,8.758810351e-014
	,8.830085695e-014
	,8.901094736e-014
	,8.970913244e-014
	,9.043420895e-014
	,9.119907433e-014
	,9.197365195e-014
	,9.276065707e-014
	,9.360959081e-014
	,9.448337953e-014
	,9.548415847e-014
	,9.648415416e-014
	,9.759803376e-014
	,9.895947116e-014
	,1.003979799e-013
	,1.021263940e-013
	,1.041682107e-013
	,1.066860840e-013
	,1.096774554e-013
	,1.134293582e-013
	,1.181944152e-013
	,1.243481665e-013
	,1.321130540e-013
	,1.422530030e-013
	,1.554788872e-013
	,1.727613045e-013
	,1.956211089e-013
	,2.258851423e-013
	,2.638333888e-013
	,3.094392704e-013
	,3.687751329e-013
	,4.462664706e-013
	,5.479331518e-013
	,6.815647102e-013
	,8.580646547e-013
	,1.091898852e-012
	,1.402578052e-012
	,1.815774591e-012
	,2.365354177e-012
	,3.067754106e-012
	,3.951137696e-012
	,5.104800628e-012
	,6.612604847e-012
	,8.584730600e-012
	,1.116598422e-011
	,1.454688919e-011
	,1.897829577e-011
	,2.479022880e-011
	,3.241640732e-011
	,4.242000601e-011
	,5.556187775e-011
	,7.283664752e-011
	,9.555679323e-011
	,1.254549624e-010
	,1.648193744e-010
	,2.166732215e-010
	,2.850119964e-010
	,3.751183051e-010
	,4.939788497e-010
	,6.508367627e-010
	,8.578649446e-010
	,1.131246411e-009
	,1.492415051e-009
	,1.969757034e-009
	,2.600873685e-009
	,3.435608265e-009
	,4.540062492e-009
	,6.001951244e-009
	,7.932331121e-009
	,1.043377765e-008
	,1.373949061e-008
	,1.810754631e-008
	,2.387845128e-008
	,3.150096776e-008
	,4.156574137e-008
	,5.484889420e-008
	,7.236821624e-008
	,9.545441252e-008
	,1.258444273e-007
	,1.657947128e-007
	,2.182243038e-007
	,2.868888533e-007
	,3.765888146e-007
	,4.934116042e-007
	,6.450040435e-007
	,8.408647324e-007
	,1.092638115e-006
	,1.414382190e-006
	,1.822772297e-006
	,2.337196752e-006
	,2.979697914e-006
	,3.774720987e-006
	,4.748650343e-006
	,5.929182151e-006
	,7.344497399e-006
	,9.022396983e-006
	,1.098945215e-005
	,1.327026510e-005
	,1.588691733e-005
	,1.885863692e-005
	,2.220172107e-005
	,2.592958665e-005
	,3.005294283e-005
	,3.458021580e-005
	,3.951796122e-005
	,4.487102679e-005
	,5.064310808e-005
	,5.683702661e-005
	,6.345499127e-005
	,7.038442435e-005
	,7.738194434e-005
	,-1.039774700e-007
	,-7.320725789e-008
	,-5.152019601e-008
	,-3.624334975e-008
	,-2.548688547e-008
	,-1.791612287e-008
	,-1.258928346e-008
	,-8.842301393e-009
	,-6.207211129e-009
	,-4.354424310e-009
	,-3.051966201e-009
	,-2.136715212e-009
	,-1.494062757e-009
	,-1.043428927e-009
	,-7.279828420e-010
	,-5.075304800e-010
	,-3.536616533e-010
	,-2.463608054e-010
	,-1.715766686e-010
	,-1.194739456e-010
	,-8.318164791e-011
	,-5.790563874e-011
	,-4.030343944e-011
	,-2.804595959e-011
	,-1.951088592e-011
	,-1.356785884e-011
	,-9.429809044e-012
	,-6.548560687e-012
	,-4.542389026e-012
	,-3.145475353e-012
	,-2.172803025e-012
	,-1.495494471e-012
	,-1.023768865e-012
	,-6.952400210e-013
	,-4.664171856e-013
	,-3.069487587e-013
	,-1.958456919e-013
	,-1.183515868e-013
	,-6.426989195e-014
	,-2.647573593e-014
	,8.145583880e-018
	,1.862349017e-014
	,3.180671362e-014
	,4.121620783e-014
	,4.803498687e-014
	,5.301418322e-014
	,5.678112433e-014
	,5.961918844e-014
	,6.188381239e-014
	,6.372177638e-014
	,6.531385348e-014
	,6.667341110e-014
	,6.787031472e-014
	,6.900351437e-014
	,7.004068811e-014
	,7.100575105e-014
	,7.196522684e-014
	,7.287619363e-014
	,7.376282758e-014
	,7.459969933e-014
	,7.543458686e-014
	,7.624206080e-014
	,7.707042129e-014
	,7.782562664e-014
	,7.856584589e-014
	,7.933259106e-014
	,8.002873970e-014
	,8.071987557e-014
	,8.144677965e-014
	,8.215222280e-014
	,8.277558182e-014
	,8.347204375e-014
	,8.411728143e-014
	,8.480523210e-014
	,8.547412379e-014
	,8.616870594e-014
	,8.678632116e-014
	,8.748649046e-014
	,8.817924503e-014
	,8.882432606e-014
	,8.951608852e-014
	,9.021077510e-014
	,9.089444403e-014
	,9.160124480e-014
	,9.231164851e-014
	,9.299542187e-014
	,9.369350251e-014
	,9.441126873e-014
	,9.511504095e-014
	,9.587672114e-014
	,9.656874468e-014
	,9.731084372e-014
	,9.806531805e-014
	,9.877368531e-014
	,9.957880952e-014
	,1.002964191e-013
	,1.010682815e-013
	,1.018281341e-013
	,1.026222928e-013
	,1.034066349e-013
	,1.042523312e-013
	,1.050525993e-013
	,1.058266026e-013
	,1.067740164e-013
	,1.076037345e-013
	,1.085255100e-013
	,1.094238927e-013
	,1.104115653e-013
	,1.114812176e-013
	,1.125490424e-013
	,1.137708532e-013
	,1.150460292e-013
	,1.165646379e-013
	,1.181387003e-013
	,1.200727424e-013
	,1.223612293e-013
	,1.251277047e-013
	,1.284925276e-013
	,1.326128169e-013
	,1.378308509e-013
	,1.445270259e-013
	,1.531156788e-013
	,1.643122260e-013
	,1.789663846e-013
	,1.978581104e-013
	,2.196062805e-013
	,2.470390379e-013
	,2.824605865e-013
	,3.284679597e-013
	,3.883232708e-013
	,4.666306980e-013
	,5.694582013e-013
	,7.050159172e-013
	,8.845473875e-013
	,1.122974066e-012
	,1.437648185e-012
	,1.823317506e-012
	,2.325155092e-012
	,2.978697783e-012
	,3.830502792e-012
	,4.941747495e-012
	,6.389753841e-012
	,8.275312268e-012
	,1.073841784e-011
	,1.395965439e-011
	,1.817548585e-011
	,2.369647402e-011
	,3.093166091e-011
	,4.041935247e-011
	,5.286830500e-011
	,6.921246988e-011
	,9.068295265e-011
	,1.189032586e-010
	,1.560151977e-010
	,2.048458488e-010
	,2.690979306e-010
	,3.536940553e-010
	,4.651543574e-010
	,6.120802650e-010
	,8.058462951e-010
	,1.061501409e-009
	,1.398964808e-009
	,1.844614820e-009
	,2.433403383e-009
	,3.211674808e-009
	,4.240933481e-009
	,5.599218450e-009
	,7.346960540e-009
	,9.653992219e-009
	,1.269938017e-008
	,1.671924328e-008
	,2.202500742e-008
	,2.902684635e-008
	,3.826437017e-008
	,5.044642469e-008
	,6.650245007e-008
	,8.764837287e-008
	,1.154704915e-007
	,1.520312614e-007
	,2.000011155e-007
	,2.628202787e-007
	,3.448936948e-007
	,4.518202163e-007
	,5.906537905e-007
	,7.701890335e-007
	,1.001256177e-006
	,1.296997613e-006
	,1.673108506e-006
	,2.147970803e-006
	,2.742659223e-006
	,3.480770305e-006
	,4.388046403e-006
	,5.491801183e-006
	,6.820175829e-006
	,8.401295012e-006
	,1.026240916e-005
	,1.242911558e-005
	,1.492473755e-005
	,1.776992661e-005
	,2.098244270e-005
	,2.457721348e-005
	,-1.051385234e-007
	,-7.406412500e-008
	,-5.215114292e-008
	,-3.670690897e-008
	,-2.582666278e-008
	,-1.816449681e-008
	,-1.277022688e-008
	,-8.973519832e-009
	,-6.301762719e-009
	,-4.421957933e-009
	,-3.099683628e-009
	,-2.170097725e-009
	,-1.517321667e-009
	,-1.059700427e-009
	,-7.394681121e-010
	,-5.157113017e-010
	,-3.595296592e-010
	,-2.505891373e-010
	,-1.746317601e-010
	,-1.216844584e-010
	,-8.478199640e-011
	,-5.906402992e-011
	,-4.114156105e-011
	,-2.865199828e-011
	,-1.994863157e-011
	,-1.388366245e-011
	,-9.657156662e-012
	,-6.711828638e-012
	,-4.659255266e-012
	,-3.228701301e-012
	,-2.231827156e-012
	,-1.536934426e-012
	,-1.052578568e-012
	,-7.150126370e-013
	,-4.797650473e-013
	,-3.157905566e-013
	,-2.014777495e-013
	,-1.217647098e-013
	,-6.613177103e-014
	,-2.726352430e-014
	,-2.172217946e-017
	,1.919766137e-014
	,3.279652712e-014
	,4.255299911e-014
	,4.958393326e-014
	,5.480791994e-014
	,5.873855937e-014
	,6.178303480e-014
	,6.421715307e-014
	,6.625040629e-014
	,6.794921365e-014
	,6.948766454e-014
	,7.086690773e-014
	,7.214344131e-014
	,7.342791179e-014
	,7.459432105e-014
	,7.571744294e-014
	,7.683701412e-014
	,7.795966606e-014
	,7.902211253e-014
	,8.011327800e-014
	,8.117896189e-014
	,8.224803984e-014
	,8.328839878e-014
	,8.432954097e-014
	,8.532770909e-014
	,8.636086218e-014
	,8.733005021e-014
	,8.827892608e-014
	,8.924649540e-014
	,9.017589457e-014
	,9.108607810e-014
	,9.201657381e-014
	,9.284968598e-014
	,9.371736539e-014
	,9.457261731e-014
	,9.540463294e-014
	,9.617962830e-014
	,9.701843205e-014
	,9.780987557e-014
	,9.861212787e-014
	,9.942800864e-014
	,1.002031084e-013
	,1.009410302e-013
	,1.017548745e-013
	,1.025606253e-013
	,1.033437664e-013
	,1.041342700e-013
	,1.049167323e-013
	,1.057600789e-013
	,1.065946531e-013
	,1.073700662e-013
	,1.082117419e-013
	,1.090598402e-013
	,1.098781751e-013
	,1.107066922e-013
	,1.115613698e-013
	,1.124042464e-013
	,1.132530235e-013
	,1.141133926e-013
	,1.150015931e-013
	,1.158823788e-013
	,1.167638433e-013
	,1.176939213e-013
	,1.185136661e-013
	,1.195202932e-013
	,1.203679216e-013
	,1.213260919e-013
	,1.222625403e-013
	,1.231967434e-013
	,1.241590389e-013
	,1.251692690e-013
	,1.261627376e-013
	,1.271891548e-013
	,1.282297748e-013
	,1.293717990e-013
	,1.305010302e-013
	,1.317120845e-013
	,1.329778093e-013
	,1.343776779e-013
	,1.359398873e-013
	,1.375927442e-013
	,1.394472608e-013
	,1.416273464e-013
	,1.441995248e-013
	,1.472166911e-013
	,1.509494305e-013
	,1.555362730e-013
	,1.613421067e-013
	,1.686634683e-013
	,1.781585973e-013
	,1.888773126e-013
	,2.022787483e-013
	,2.193211269e-013
	,2.410970239e-013
	,2.691216016e-013
	,3.053826850e-013
	,3.525448755e-013
	,4.141209247e-013
	,4.948844012e-013
	,6.003191200e-013
	,7.398592739e-013
	,9.133462817e-013
	,1.134441460e-012
	,1.421017428e-012
	,1.792958596e-012
	,2.276189609e-012
	,2.904344336e-012
	,3.721911384e-012
	,4.786896405e-012
	,6.175378388e-012
	,7.987050547e-012
	,1.035250863e-011
	,1.344340180e-011
	,1.748485131e-011
	,2.276591545e-011
	,2.966469519e-011
	,3.869885610e-011
	,5.053531244e-011
	,6.604882088e-011
	,8.640012279e-011
	,1.131136185e-010
	,1.481981350e-010
	,1.943025582e-010
	,2.549212302e-010
	,3.346660195e-010
	,4.396264628e-010
	,5.778475804e-010
	,7.599631409e-010
	,1.000037088e-009
	,1.316681800e-009
	,1.734532409e-009
	,2.286051271e-009
	,3.014713255e-009
	,3.975846192e-009
	,5.202386210e-009
	,6.819525120e-009
	,8.951753506e-009
	,1.176333162e-008
	,1.547084866e-008
	,2.035968013e-008
	,2.680549357e-008
	,3.530226756e-008
	,4.649865673e-008
	,6.124252737e-008
	,8.064685881e-008
	,1.061626747e-007
	,1.396768756e-007
	,1.836340031e-007
	,2.411868739e-007
	,3.163784541e-007
	,4.143577508e-007
	,5.416289733e-007
	,7.063282957e-007
	,9.185163821e-007
	,1.190466135e-006
	,1.536915848e-006
	,1.975248637e-006
	,2.525553126e-006
	,3.210523714e-006
	,4.055167419e-006
	,-1.061793126e-007
	,-7.483139730e-008
	,-5.271543136e-008
	,-3.712092376e-008
	,-2.612963645e-008
	,-1.838552964e-008
	,-1.293083852e-008
	,-9.089585561e-009
	,-6.384988137e-009
	,-4.481019538e-009
	,-3.141120637e-009
	,-2.198942100e-009
	,-1.537409468e-009
	,-1.073800206e-009
	,-7.494642547e-010
	,-5.228579622e-010
	,-3.646686763e-010
	,-2.542975378e-010
	,-1.773130788e-010
	,-1.236249453e-010
	,-8.618651361e-011
	,-6.008023853e-011
	,-4.187640682e-011
	,-2.918300800e-011
	,-2.033173456e-011
	,-1.415957834e-011
	,-9.855383316e-012
	,-6.853705057e-012
	,-4.760414404e-012
	,-3.300434844e-012
	,-2.282223472e-012
	,-1.572051867e-012
	,-1.076805711e-012
	,-7.314887814e-013
	,-4.907603004e-013
	,-3.229858156e-013
	,-2.060882460e-013
	,-1.245452315e-013
	,-6.765539248e-014
	,-2.788777100e-014
	,3.488036505e-017
	,1.964755761e-014
	,3.356102699e-014
	,4.357372470e-014
	,5.083806602e-014
	,5.622418453e-014
	,6.029251853e-014
	,6.348852586e-014
	,6.604582255e-014
	,6.818434396e-014
	,6.999975048e-014
	,7.171056761e-014
	,7.319346029e-014
	,7.460685298e-014
	,7.596766378e-014
	,7.733197308e-014
	,7.863289171e-014
	,7.992723108e-014
	,8.117734318e-014
	,8.243836850e-014
	,8.368070037e-014
	,8.498381208e-014
	,8.622134004e-014
	,8.749275642e-014
	,8.873388731e-014
	,9.000206627e-014
	,9.126074186e-014
	,9.253121834e-014
	,9.375198485e-014
	,9.499118373e-014
	,9.620349118e-014
	,9.742801726e-014
	,9.862408542e-014
	,9.985962915e-014
	,1.010079193e-013
	,1.021811167e-013
	,1.033533220e-013
	,1.044503879e-013
	,1.055871383e-013
	,1.066768939e-013
	,1.077521856e-013
	,1.087873229e-013
	,1.098326946e-013
	,1.108460055e-013
	,1.118274122e-013
	,1.128180611e-013
	,1.137620287e-013
	,1.147150818e-013
	,1.156816591e-013
	,1.165847934e-013
	,1.175578976e-013
	,1.184855737e-013
	,1.194174270e-013
	,1.203473483e-013
	,1.213378928e-013
	,1.222771609e-013
	,1.232348613e-013
	,1.241771579e-013
	,1.251281747e-013
	,1.260787737e-013
	,1.271227356e-013
	,1.280646144e-013
	,1.291057566e-013
	,1.300557290e-013
	,1.310786999e-013
	,1.320830818e-013
	,1.330616688e-013
	,1.341571160e-013
	,1.351561718e-013
	,1.362174695e-013
	,1.372281173e-013
	,1.382806949e-013
	,1.393457522e-013
	,1.404123760e-013
	,1.414932548e-013
	,1.425867700e-013
	,1.436909896e-013
	,1.448059657e-013
	,1.459200542e-013
	,1.470873511e-013
	,1.482373122e-013
	,1.493686843e-013
	,1.506478287e-013
	,1.518763755e-013
	,1.531753099e-013
	,1.545123100e-013
	,1.559016832e-013
	,1.573931393e-013
	,1.590316890e-013
	,1.607590587e-013
	,1.626734675e-013
	,1.647953841e-013
	,1.673205155e-013
	,1.701533580e-013
	,1.736728979e-013
	,1.778402864e-013
	,1.829961307e-013
	,1.889115143e-013
	,1.959184812e-013
	,2.045369496e-013
	,2.153453203e-013
	,2.289418886e-013
	,2.461606541e-013
	,2.683146499e-013
	,2.967077185e-013
	,3.334683037e-013
	,3.812930154e-013
	,4.439272294e-013
	,5.242930260e-013
	,6.247156000e-013
	,7.543698897e-013
	,9.220606716e-013
	,1.139089813e-012
	,1.419614583e-012
	,1.780296231e-012
	,2.248086184e-012
	,2.855463966e-012
	,3.644754493e-012
	,4.671414839e-012
	,6.007952656e-012
	,7.749296624e-012
	,1.001979846e-011
	,1.298232102e-011
	,1.684981885e-011
	,2.190303357e-011
	,2.850998067e-011
	,3.715380793e-011
	,4.846972696e-011
	,6.329265934e-011
	,8.270442711e-011
	,1.081150118e-010
	,1.414469066e-010
	,1.851955062e-010
	,2.426498696e-010
	,3.181473943e-010
	,4.173852206e-010
	,5.479350990e-010
	,7.197798765e-010
	,9.461216816e-010
	,1.244436865e-009
	,1.637889089e-009
	,2.157227177e-009
	,2.842194873e-009
	,3.707372240e-009
	,4.846485651e-009
	,6.346418059e-009
	,8.321759878e-009
	,1.092356430e-008
	,1.435035152e-008
	,1.886379108e-008
	,2.480874704e-008
	,3.263791947e-008
	,4.294550859e-008
	,5.651015071e-008
	,7.435020482e-008
	,9.779438187e-008
	,1.285712630e-007
	,1.689216282e-007
	,2.217376451e-007
	,2.907326379e-007
	,3.806439835e-007
	,-1.071245497e-007
	,-7.552758747e-008
	,-5.322689873e-008
	,-3.749571444e-008
	,-2.640348756e-008
	,-1.858492662e-008
	,-1.307534860e-008
	,-9.193633549e-009
	,-6.459218597e-009
	,-4.533365555e-009
	,-3.177628509e-009
	,-2.224284968e-009
	,-1.555082554e-009
	,-1.086247921e-009
	,-7.583185738e-010
	,-5.292027308e-010
	,-3.692368405e-010
	,-2.575956456e-010
	,-1.796976866e-010
	,-1.253500632e-010
	,-8.743436960e-011
	,-6.098254836e-011
	,-4.252853481e-011
	,-2.965375784e-011
	,-2.067105741e-011
	,-1.440352528e-011
	,-1.003026852e-011
	,-6.978544841e-012
	,-4.849055346e-012
	,-3.362926925e-012
	,-2.325903300e-012
	,-1.602306710e-012
	,-1.097463133e-012
	,-7.454754059e-013
	,-5.000738732e-013
	,-3.290706936e-013
	,-2.099134084e-013
	,-1.268443182e-013
	,-6.893364920e-014
	,-2.840967361e-014
	,3.289461518e-018
	,2.003218338e-014
	,3.424777668e-014
	,4.449174069e-014
	,5.192615073e-014
	,5.743779739e-014
	,6.164534023e-014
	,6.492249179e-014
	,6.756954843e-014
	,6.981824638e-014
	,7.173620585e-014
	,7.348618525e-014
	,7.510959218e-014
	,7.664882632e-014
	,7.811307775e-014
	,7.953221424e-014
	,8.097636237e-014
	,8.234719872e-014
	,8.373662410e-014
	,8.513628388e-014
	,8.655160858e-014
	,8.797361697e-014
	,8.940392776e-014
	,9.078719160e-014
	,9.222512599e-014
	,9.365658554e-014
	,9.512532758e-014
	,9.655856249e-014
	,9.802370160e-014
	,9.947150488e-014
	,1.009574261e-013
	,1.024175524e-013
	,1.038460879e-013
	,1.053070497e-013
	,1.067834153e-013
	,1.082419752e-013
	,1.096897262e-013
	,1.111654130e-013
	,1.126169237e-013
	,1.140458246e-013
	,1.154891895e-013
	,1.168968906e-013
	,1.183035474e-013
	,1.197181933e-013
	,1.210587963e-013
	,1.224226879e-013
	,1.237836554e-013
	,1.251030064e-013
	,1.263671647e-013
	,1.276548204e-013
	,1.289003374e-013
	,1.301004262e-013
	,1.313355000e-013
	,1.324959044e-013
	,1.336648723e-013
	,1.347991162e-013
	,1.359546123e-013
	,1.370993518e-013
	,1.382023703e-013
	,1.393220460e-013
	,1.404047524e-013
	,1.415817616e-013
	,1.426623271e-013
	,1.438000696e-013
	,1.449142103e-013
	,1.460855801e-013
	,1.472326693e-013
	,1.483580887e-013
	,1.495418860e-013
	,1.506835447e-013
	,1.518787252e-013
	,1.530116115e-013
	,1.542196372e-013
	,1.553988395e-013
	,1.566502570e-013
	,1.578596926e-013
	,1.590864640e-013
	,1.602806001e-013
	,1.615412599e-013
	,1.627735140e-013
	,1.640781922e-013
	,1.652964001e-013
	,1.666093807e-013
	,1.679053910e-013
	,1.691821857e-013
	,1.705228410e-013
	,1.718618254e-013
	,1.732045171e-013
	,1.746199462e-013
	,1.760046721e-013
	,1.773756651e-013
	,1.788353737e-013
	,1.803281875e-013
	,1.818177639e-013
	,1.834435728e-013
	,1.851308403e-013
	,1.868212930e-013
	,1.886965395e-013
	,1.907481729e-013
	,1.929455422e-013
	,1.954086405e-013
	,1.982062369e-013
	,2.015080346e-013
	,2.052792575e-013
	,2.094346884e-013
	,2.144099685e-013
	,2.204147988e-013
	,2.276657205e-013
	,2.366422888e-013
	,2.478442665e-013
	,2.618551194e-013
	,2.795010671e-013
	,3.021160812e-013
	,3.311152774e-013
	,3.686630244e-013
	,4.148555046e-013
	,4.740716351e-013
	,5.500790879e-013
	,6.478224400e-013
	,7.738832514e-013
	,9.365764568e-013
	,1.146805670e-012
	,1.418980728e-012
	,1.771589256e-012
	,2.228812444e-012
	,2.821816886e-012
	,3.592122899e-012
	,4.593189757e-012
	,5.886674759e-012
	,7.569211973e-012
	,9.759602046e-012
	,1.261341775e-011
	,1.633434621e-011
	,2.118923423e-011
	,2.752816593e-011
	,3.581017829e-011
	,4.663809358e-011
	,6.080369200e-011
	,7.934693429e-011
	,1.036339785e-010
	,1.354661724e-010
	,1.772134496e-010
	,2.319979593e-010
	,3.038948962e-010
	,3.982093621e-010
	,5.221724857e-010
	,6.852208826e-010
	,8.998407503e-010
	,1.182578922e-009
	,1.555406477e-009
	,2.047297467e-009
	,2.660806447e-009
	,3.467250834e-009
	,4.527479507e-009
	,5.921670096e-009
	,7.755453284e-009
	,1.016793330e-008
	,1.334221479e-008
	,1.751917151e-008
	,2.301543988e-008
	,3.024685759e-008
	,-1.079917666e-007
	,-7.616589198e-008
	,-5.369546197e-008
	,-3.783872279e-008
	,-2.665379285e-008
	,-1.876686121e-008
	,-1.320687755e-008
	,-9.287998230e-009
	,-6.526211243e-009
	,-4.580340267e-009
	,-3.210248991e-009
	,-2.246913067e-009
	,-1.570900438e-009
	,-1.097424598e-009
	,-7.662884614e-010
	,-5.349218783e-010
	,-3.733565458e-010
	,-2.605695278e-010
	,-1.818466953e-010
	,-1.269032856e-010
	,-8.855665488e-011
	,-6.179328697e-011
	,-4.311376178e-011
	,-3.007561144e-011
	,-2.097452940e-011
	,-1.462125605e-011
	,-1.018591790e-011
	,-7.089312417e-012
	,-4.927338754e-012
	,-3.417859277e-012
	,-2.364033991e-012
	,-1.628499120e-012
	,-1.115342592e-012
	,-7.574829778e-013
	,-5.080484093e-013
	,-3.343023039e-013
	,-2.132769258e-013
	,-1.288858216e-013
	,-7.003635449e-014
	,-2.889330163e-014
	,-8.929168941e-018
	,2.037947446e-014
	,3.486319881e-014
	,4.527383747e-014
	,5.284646424e-014
	,5.846640765e-014
	,6.282506466e-014
	,6.619944311e-014
	,6.890832393e-014
	,7.119874276e-014
	,7.324588552e-014
	,7.504766357e-014
	,7.676918505e-014
	,7.835181099e-014
	,7.989882537e-014
	,8.141764291e-014
	,8.289980456e-014
	,8.439737004e-014
	,8.590845955e-014
	,8.740336200e-014
	,8.892165737e-014
	,9.043060602e-014
	,9.194493295e-014
	,9.354087406e-014
	,9.506470437e-014
	,9.664889681e-014
	,9.821883417e-014
	,9.987377979e-014
	,1.014415763e-013
	,1.030944855e-013
	,1.047316253e-013
	,1.064064131e-013
	,1.080585913e-013
	,1.097460155e-013
	,1.114168871e-013
	,1.131018049e-013
	,1.147985758e-013
	,1.165224470e-013
	,1.182209933e-013
	,1.199562477e-013
	,1.216707200e-013
	,1.233905183e-013
	,1.251328741e-013
	,1.268739246e-013
	,1.285941928e-013
	,1.302892928e-013
	,1.320305521e-013
	,1.337237723e-013
	,1.354610632e-013
	,1.371006572e-013
	,1.387960705e-013
	,1.404327403e-013
	,1.420593847e-013
	,1.437145914e-013
	,1.453099059e-013
	,1.469126352e-013
	,1.484338546e-013
	,1.499770572e-013
	,1.514485145e-013
	,1.529396052e-013
	,1.544407736e-013
	,1.558429397e-013
	,1.572361247e-013
	,1.586532770e-013
	,1.600123124e-013
	,1.613473283e-013
	,1.627393123e-013
	,1.640785055e-013
	,1.653963945e-013
	,1.667347523e-013
	,1.681011502e-013
	,1.694446774e-013
	,1.708006843e-013
	,1.721695886e-013
	,1.735090429e-013
	,1.749122012e-013
	,1.762936375e-013
	,1.777002943e-013
	,1.791136347e-013
	,1.805217536e-013
	,1.819359817e-013
	,1.833838894e-013
	,1.848021905e-013
	,1.862644055e-013
	,1.877182658e-013
	,1.891797498e-013
	,1.906825369e-013
	,1.922069416e-013
	,1.936857614e-013
	,1.951962243e-013
	,1.967190103e-013
	,1.982861280e-013
	,1.998377896e-013
	,2.013726898e-013
	,2.029776121e-013
	,2.045944398e-013
	,2.062277156e-013
	,2.078316459e-013
	,2.095226730e-013
	,2.112102016e-013
	,2.129332374e-013
	,2.146965319e-013
	,2.165508397e-013
	,2.184457717e-013
	,2.204038333e-013
	,2.224335358e-013
	,2.246495986e-013
	,2.270189685e-013
	,2.295548043e-013
	,2.324189244e-013
	,2.354475783e-013
	,2.388807523e-013
	,2.427464346e-013
	,2.472302020e-013
	,2.525312601e-013
	,2.588295986e-013
	,2.664251483e-013
	,2.757167902e-013
	,2.872341548e-013
	,3.016840952e-013
	,3.199164327e-013
	,3.425943152e-013
	,3.709722411e-013
	,4.069873854e-013
	,4.529172695e-013
	,5.112834742e-013
	,5.860130880e-013
	,6.819276662e-013
	,8.052934341e-013
	,9.643276296e-013
	,1.169417237e-012
	,1.434487737e-012
	,1.777390024e-012
	,2.221451502e-012
	,2.797021891e-012
	,3.543828501e-012
	,4.513465178e-012
	,5.772974555e-012
	,7.410550342e-012
	,9.541566382e-012
	,1.231642895e-011
	,1.593221088e-011
	,2.062309172e-011
	,2.673714527e-011
	,3.471445605e-011
	,4.512964861e-011
	,5.873727147e-011
	,7.652824333e-011
	,9.980415392e-011
	,1.302766520e-010
	,1.701979835e-010
	,2.225341665e-010
	,2.911948964e-010
	,3.813387195e-010
	,4.997786358e-010
	,6.555224972e-010
	,8.605230362e-010
	,1.130561017e-009
	,1.486343494e-009
	,1.924457169e-009
	,2.498830699e-009
	,-1.087939990e-007
	,-7.675603809e-008
	,-5.412838208e-008
	,-3.815536911e-008
	,-2.688459777e-008
	,-1.893435276e-008
	,-1.332767968e-008
	,-9.374367760e-009
	,-6.587244287e-009
	,-4.622930638e-009
	,-3.239746459e-009
	,-2.267392172e-009
	,-1.585257924e-009
	,-1.107598825e-009
	,-7.735579578e-010
	,-5.401435760e-010
	,-3.771188200e-010
	,-2.632847104e-010
	,-1.838073600e-010
	,-1.283189849e-010
	,-8.957857780e-011
	,-6.253059318e-011
	,-4.364512344e-011
	,-3.045784398e-011
	,-2.124892491e-011
	,-1.481757582e-011
	,-1.032581135e-011
	,-7.188414491e-012
	,-4.997041237e-012
	,-3.466460342e-012
	,-2.397616740e-012
	,-1.651430617e-012
	,-1.130869182e-012
	,-7.679222832e-013
	,-5.149989825e-013
	,-3.388762490e-013
	,-2.161696605e-013
	,-1.306962676e-013
	,-7.101546364e-014
	,-2.927672643e-014
	,3.978870378e-017
	,2.066374037e-014
	,3.537340495e-014
	,4.595818521e-014
	,5.369800879e-014
	,5.944013851e-014
	,6.383169184e-014
	,6.730653458e-014
	,7.011979591e-014
	,7.250284658e-014
	,7.456983157e-014
	,7.645646122e-014
	,7.818294326e-014
	,7.985538135e-014
	,8.145962487e-014
	,8.304841235e-014
	,8.460602665e-014
	,8.618750383e-014
	,8.776965983e-014
	,8.936398224e-014
	,9.094102103e-014
	,9.253529122e-014
	,9.416731385e-014
