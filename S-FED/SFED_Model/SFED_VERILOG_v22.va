	,9.217261512e-005
	,1.035108913e-004
	,1.145639561e-004
	,1.253840058e-004
	,1.359479740e-004
	,1.462099645e-004
	,1.562290003e-004
	,1.660691557e-004
	,1.757628949e-004
	,1.853331430e-004
	,1.947997142e-004
	,2.041783693e-004
	,2.134797095e-004
	,2.227098002e-004
	,2.318715094e-004
	,2.409657053e-004
	,2.499924630e-004
	,2.589522531e-004
	,2.678457693e-004
	,2.766710292e-004
	,2.854174688e-004
	,2.940591623e-004
	,3.025633505e-004
	,3.109273682e-004
	,3.191834793e-004
	,3.273642571e-004
	,3.354895583e-004
	,3.435672127e-004
	,3.515930307e-004
	,3.595513304e-004
	,3.674230651e-004
	,3.752018300e-004
	,3.828982659e-004
	,3.905279112e-004
	,3.981014212e-004
	,4.056224817e-004
	,4.130884304e-004
	,4.204911272e-004
	,4.278179609e-004
	,4.350505146e-004
	,4.421478443e-004
	,4.489678469e-004
	,4.549191942e-004
	,4.593403481e-004
	,4.635880928e-004
	,4.681108027e-004
	,4.728236698e-004
	,4.776489136e-004
	,4.825370256e-004
	,4.874558940e-004
	,4.923836704e-004
	,4.973048247e-004
	,5.022079163e-004
	,5.070842856e-004
	,5.119272769e-004
	,5.167318290e-004
	,5.214943251e-004
	,5.262121925e-004
	,5.308823514e-004
	,5.354989965e-004
	,5.400497073e-004
	,5.445030989e-004
	,5.488013944e-004
	,5.529451183e-004
	,5.569993687e-004
	,5.609984183e-004
	,5.649517633e-004
	,5.688600020e-004
	,5.727199879e-004
	,5.765286065e-004
	,5.802887103e-004
	,5.840103042e-004
	,5.877038948e-004
	,5.913762741e-004
	,5.950310609e-004
	,5.986701779e-004
	,6.022947767e-004
	,6.059056005e-004
	,6.095029987e-004
	,6.130867521e-004
	,6.166556740e-004
	,6.202067351e-004
	,6.237334871e-004
	,6.272256483e-004
	,6.306775581e-004
	,6.340999770e-004
	,6.375094211e-004
	,6.409152561e-004
	,6.443207252e-004
	,6.477262393e-004
	,6.511307490e-004
	,6.545316921e-004
	,6.579238829e-004
	,6.612978926e-004
	,6.646412090e-004
	,6.679468135e-004
	,6.712195271e-004
	,6.744691493e-004
	,6.777034167e-004
	,6.809271451e-004
	,6.841432993e-004
	,6.873538519e-004
	,6.905602797e-004
	,6.937638772e-004
	,6.969663881e-004
	,7.001702253e-004
	,7.033769884e-004
	,7.065859474e-004
	,7.097933580e-004
	,7.129884424e-004
	,7.161775222e-004
	,7.193711823e-004
	,7.225708845e-004
	,7.257761212e-004
	,7.289855293e-004
	,7.321960690e-004
	,7.353985264e-004
	,7.385531967e-004
	,7.415230796e-004
	,7.443216471e-004
	,7.470990960e-004
	,7.498847872e-004
	,7.526770411e-004
	,7.554712042e-004
	,7.582634873e-004
	,7.610514010e-004
	,7.638336598e-004
	,7.666100263e-004
	,7.693812232e-004
	,7.721490556e-004
	,7.749162896e-004
	,7.776847950e-004
	,7.804562765e-004
	,7.832336145e-004
	,7.860205494e-004
	,7.888216060e-004
	,7.916422604e-004
	,7.944892180e-004
	,7.973707644e-004
	,8.002971803e-004
	,8.032812343e-004
	,8.063387650e-004
	,8.094893923e-004
	,8.127573609e-004
	,8.161721521e-004
	,8.197676512e-004
	,8.235806089e-004
	,8.276510025e-004
	,8.320236981e-004
	,8.367482041e-004
	,8.418775524e-004
	,8.474668754e-004
	,8.535720109e-004
	,8.602481940e-004
	,-7.480755692e-004
	,-7.286250373e-004
	,-7.091811218e-004
	,-6.898973360e-004
	,-6.708184429e-004
	,-6.518212217e-004
	,-6.326564613e-004
	,-6.131597896e-004
	,-5.933457108e-004
	,-5.732411597e-004
	,-5.528703681e-004
	,-5.323540186e-004
	,-5.119204802e-004
	,-4.917359203e-004
	,-4.718754015e-004
	,-4.523731167e-004
	,-4.332600287e-004
	,-4.145551126e-004
	,-3.962521848e-004
	,-3.783090323e-004
	,-3.606277634e-004
	,-3.430329224e-004
	,-3.252787901e-004
	,-3.071043223e-004
	,-2.883735454e-004
	,-2.692005130e-004
	,-2.498354126e-004
	,-2.305349902e-004
	,-2.114777851e-004
	,-1.927383368e-004
	,-1.743227429e-004
	,-1.561964569e-004
	,-1.382921970e-004
	,-1.205172881e-004
	,-1.028085091e-004
	,-8.515718416e-005
	,-6.755560052e-005
	,-5.009546903e-005
	,-3.295731680e-005
	,-1.624928042e-005
	,-3.780482125e-017
	,1.579666568e-005
	,3.115117730e-005
	,4.604964236e-005
	,6.042858853e-005
	,7.421962501e-005
	,8.744693184e-005
	,1.001960810e-004
	,1.125467992e-004
	,1.245637390e-004
	,1.362999191e-004
	,1.477967655e-004
	,1.590868787e-004
	,1.701988725e-004
	,1.811572736e-004
	,1.919754991e-004
	,2.026410206e-004
	,2.130913392e-004
	,2.232691150e-004
	,2.332422898e-004
	,2.430964565e-004
	,2.528737475e-004
	,2.625937314e-004
	,2.722631915e-004
	,2.818755275e-004
	,2.914079505e-004
	,3.008262939e-004
	,3.101024441e-004
	,3.192341409e-004
	,3.282484679e-004
	,3.371773281e-004
	,3.460409682e-004
	,3.548499766e-004
	,3.636101548e-004
	,3.723251938e-004
	,3.809978015e-004
	,3.896302668e-004
	,3.982250296e-004
	,4.067853598e-004
	,4.153157319e-004
	,4.238213477e-004
	,4.323068581e-004
	,4.407749630e-004
	,4.492253952e-004
	,4.576542022e-004
	,4.660527918e-004
	,4.744056961e-004
	,4.826842677e-004
	,4.908259903e-004
	,4.986477059e-004
	,5.054042445e-004
	,5.100870857e-004
	,5.146708196e-004
	,5.197034976e-004
	,5.250006045e-004
	,5.304361043e-004
	,5.359386781e-004
	,5.414702641e-004
	,5.470121009e-004
	,5.525542732e-004
	,5.580897333e-004
	,5.636121018e-004
	,5.691152415e-004
	,5.745934593e-004
	,5.800421388e-004
	,5.854583495e-004
	,5.908401331e-004
	,5.961850934e-004
	,6.014900975e-004
	,6.067516944e-004
	,6.119664423e-004
	,6.171310280e-004
	,6.222422697e-004
	,6.272970651e-004
	,6.322923107e-004
	,6.372247986e-004
	,6.420910830e-004
	,6.468872907e-004
	,6.516087989e-004
	,6.562495424e-004
	,6.608001707e-004
	,6.652425262e-004
	,6.695361207e-004
	,6.736265313e-004
	,6.775350600e-004
	,6.813308250e-004
	,6.850505932e-004
	,6.887089205e-004
	,6.923126326e-004
	,6.958655158e-004
	,6.993693706e-004
	,7.028239743e-004
	,7.062271719e-004
	,7.095755740e-004
	,7.128658227e-004
	,7.161011515e-004
	,7.192982414e-004
	,7.224764191e-004
	,7.256468010e-004
	,7.288135429e-004
	,7.319773479e-004
	,7.351371914e-004
	,7.382906943e-004
	,7.414337837e-004
	,7.445604045e-004
	,7.476639414e-004
	,7.507410318e-004
	,7.537934821e-004
	,7.568256627e-004
	,7.598416796e-004
	,7.628446049e-004
	,7.658366973e-004
	,7.688197380e-004
	,7.717952724e-004
	,7.747647621e-004
	,7.777296651e-004
	,7.806914451e-004
	,7.836514969e-004
	,7.866110302e-004
	,7.895710120e-004
	,7.925322193e-004
	,7.954953344e-004
	,7.984609623e-004
	,8.014297139e-004
	,8.044023064e-004
	,8.073791661e-004
	,8.103602764e-004
	,8.133445412e-004
	,8.163274495e-004
	,8.192894207e-004
	,8.221321726e-004
	,8.247107637e-004
	,8.272100658e-004
	,8.297377364e-004
	,8.323013515e-004
	,8.348955145e-004
	,8.375147693e-004
	,8.401549203e-004
	,8.428128958e-004
	,8.454864932e-004
	,8.481741890e-004
	,8.508750302e-004
	,8.535885923e-004
	,8.563149841e-004
	,8.590548613e-004
	,8.618093604e-004
	,8.645798616e-004
	,8.673677046e-004
	,8.701742079e-004
	,8.730010980e-004
	,8.758510006e-004
	,8.787277827e-004
	,8.816368011e-004
	,8.845851645e-004
	,8.875820656e-004
	,8.906392345e-004
	,8.937716784e-004
	,8.969988467e-004
	,9.003434512e-004
	,9.038299656e-004
	,9.074876934e-004
	,-7.722921965e-004
	,-7.525534420e-004
	,-7.328715472e-004
	,-7.133002852e-004
	,-6.937567024e-004
	,-6.740763861e-004
	,-6.540747165e-004
	,-6.337247931e-004
	,-6.130881834e-004
	,-5.921852290e-004
	,-5.710685831e-004
	,-5.499408466e-004
	,-5.289944524e-004
	,-5.083478485e-004
	,-4.880701328e-004
	,-4.681931795e-004
	,-4.487221926e-004
	,-4.296365409e-004
	,-4.108824046e-004
	,-3.923570821e-004
	,-3.738973270e-004
	,-3.553044752e-004
	,-3.364235598e-004
	,-3.172476675e-004
	,-2.979327612e-004
	,-2.786440722e-004
	,-2.594895981e-004
	,-2.405125537e-004
	,-2.216830164e-004
	,-2.029418211e-004
	,-1.842602792e-004
	,-1.656443975e-004
	,-1.470813250e-004
	,-1.285094175e-004
	,-1.098305515e-004
	,-9.103071269e-005
	,-7.226294640e-005
	,-5.368452810e-005
	,-3.539829707e-005
	,-1.748623821e-005
	,3.091192098e-017
	,1.702895526e-005
	,3.355647973e-005
	,4.951480042e-005
	,6.485897645e-005
	,7.960863138e-005
	,9.382137931e-005
	,1.075588431e-004
	,1.208750378e-004
	,1.338160823e-004
	,1.464250653e-004
	,1.587461915e-004
	,1.708221220e-004
	,1.826892717e-004
	,1.943757527e-004
	,2.058999149e-004
	,2.172694268e-004
	,2.284858513e-004
	,2.395558592e-004
	,2.504941483e-004
	,2.613146757e-004
	,2.720211389e-004
	,2.825954244e-004
	,2.929805208e-004
	,3.031094565e-004
	,3.130080499e-004
	,3.227496252e-004
	,3.323833266e-004
	,3.419455327e-004
	,3.514626074e-004
	,3.609503196e-004
	,3.704176202e-004
	,3.798699329e-004
	,3.893109012e-004
	,3.987431938e-004
	,4.081688520e-004
	,4.175894171e-004
	,4.270059395e-004
	,4.364189149e-004
	,4.458281558e-004
	,4.552326076e-004
	,4.646301141e-004
	,4.740171415e-004
	,4.833884504e-004
	,4.927366479e-004
	,5.020514080e-004
	,5.113177644e-004
	,5.205117584e-004
	,5.295877177e-004
	,5.384326298e-004
	,5.466356229e-004
	,5.524080089e-004
	,5.564832455e-004
	,5.614379666e-004
	,5.669583286e-004
	,5.727866670e-004
	,5.787928632e-004
	,5.849026693e-004
	,5.910682944e-004
	,5.972553824e-004
	,6.034363548e-004
	,6.095864873e-004
	,6.156814245e-004
	,6.216960870e-004
	,6.276058752e-004
	,6.333906727e-004
	,6.390395296e-004
	,6.445532280e-004
	,6.499434999e-004
	,6.552285373e-004
	,6.604272878e-004
	,6.655557324e-004
	,6.706257506e-004
	,6.756454958e-004
	,6.806202531e-004
	,6.855532708e-004
	,6.904464155e-004
	,6.953006428e-004
	,7.001163252e-004
	,7.048934760e-004
	,7.096319009e-004
	,7.143313004e-004
	,7.189913375e-004
	,7.236116827e-004
	,7.281920394e-004
	,7.327321566e-004
	,7.372318278e-004
	,7.416908750e-004
	,7.461091115e-004
	,7.504862698e-004
	,7.548218634e-004
	,7.591149110e-004
	,7.633633430e-004
	,7.675625906e-004
	,7.717018653e-004
	,7.757543053e-004
	,7.796642581e-004
	,7.833924037e-004
	,7.869775391e-004
	,7.904663405e-004
	,7.938936021e-004
	,7.972919501e-004
	,8.006816622e-004
	,8.040701445e-004
	,8.074580079e-004
	,8.108429301e-004
	,8.142210618e-004
	,8.175874488e-004
	,8.209367995e-004
	,8.242653691e-004
	,8.275727280e-004
	,8.308613569e-004
	,8.341346784e-004
	,8.373955946e-004
	,8.406460998e-004
	,8.438874281e-004
	,8.471203135e-004
	,8.503452106e-004
	,8.535624445e-004
	,8.567722989e-004
	,8.599750640e-004
	,8.631710610e-004
	,8.663606538e-004
	,8.695442524e-004
	,8.727223099e-004
	,8.758953155e-004
	,8.790637796e-004
	,8.822282104e-004
	,8.853890720e-004
	,8.885467054e-004
	,8.917011618e-004
	,8.948518045e-004
	,8.979962109e-004
	,9.011265201e-004
	,9.042137385e-004
	,9.071331766e-004
	,9.097054630e-004
	,9.121812647e-004
	,9.147043447e-004
	,9.172778837e-004
	,9.198905758e-004
	,9.225329653e-004
	,9.251981873e-004
	,9.278812912e-004
	,9.305786254e-004
	,9.332872919e-004
	,9.360040050e-004
	,9.387218167e-004
	,9.414406463e-004
	,9.441697438e-004
	,9.469120678e-004
	,9.496667586e-004
	,9.524323345e-004
	,9.552083071e-004
	,9.579951438e-004
	,9.607940574e-004
	,9.636069559e-004
	,9.664365020e-004
	,9.692862413e-004
	,9.721607866e-004
	,9.750660475e-004
	,-7.939597816e-004
	,-7.739734611e-004
	,-7.540191649e-004
	,-7.340652218e-004
	,-7.140206471e-004
	,-6.937300923e-004
	,-6.730468270e-004
	,-6.520161074e-004
	,-6.306980992e-004
	,-6.091259809e-004
	,-5.874629556e-004
	,-5.659375065e-004
	,-5.446828701e-004
	,-5.237860507e-004
	,-5.032895763e-004
	,-4.831952101e-004
	,-4.634731602e-004
	,-4.440577834e-004
	,-4.248337604e-004
	,-4.056272406e-004
	,-3.862460117e-004
	,-3.665920827e-004
	,-3.467169332e-004
	,-3.267796444e-004
	,-3.069390112e-004
	,-2.873021261e-004
	,-2.679321430e-004
	,-2.488273865e-004
	,-2.299328281e-004
	,-2.111594605e-004
	,-1.923898101e-004
	,-1.734764655e-004
	,-1.542603085e-004
	,-1.346837268e-004
	,-1.149144625e-004
	,-9.517933373e-005
	,-7.561462552e-005
	,-5.628326042e-005
	,-3.721611740e-005
	,-1.843982363e-005
	,-6.266134088e-018
	,1.802287546e-005
	,3.552969917e-005
	,5.245442180e-005
	,6.878878355e-005
	,8.455682509e-005
	,9.979047500e-005
	,1.145203772e-004
	,1.287770133e-004
	,1.425950975e-004
	,1.560143355e-004
	,1.690777797e-004
	,1.818273068e-004
	,1.943001014e-004
	,2.065280212e-004
	,2.185386731e-004
	,2.303577808e-004
	,2.420109719e-004
	,2.535227600e-004
	,2.649143866e-004
	,2.762025407e-004
	,2.873988242e-004
	,2.985110420e-004
	,3.095417252e-004
	,3.204902711e-004
	,3.313632007e-004
	,3.421811447e-004
	,3.529624273e-004
	,3.637000437e-004
	,3.743478850e-004
	,3.848260170e-004
	,3.950999622e-004
	,4.052339828e-004
	,4.153046866e-004
	,4.253554813e-004
	,4.354071913e-004
	,4.454696946e-004
	,4.555473432e-004
	,4.656412370e-004
	,4.757501903e-004
	,4.858711430e-004
	,4.959993107e-004
	,5.061281744e-004
	,5.162493095e-004
	,5.263519690e-004
	,5.364221956e-004
	,5.464409446e-004
	,5.563798812e-004
	,5.661908560e-004
	,5.757738711e-004
	,5.848396651e-004
	,5.919009307e-004
	,5.950859181e-004
	,5.995647797e-004
	,6.049558431e-004
	,6.107322801e-004
	,6.166644311e-004
	,6.226370493e-004
	,6.285960248e-004
	,6.345231677e-004
	,6.404172052e-004
	,6.462813721e-004
	,6.521179233e-004
	,6.579271565e-004
	,6.637090112e-004
	,6.694656026e-004
	,6.752016439e-004
	,6.809217189e-004
	,6.866278908e-004
	,6.923196082e-004
	,6.979946434e-004
	,7.036498994e-004
	,7.092818511e-004
	,7.148867291e-004
	,7.204605865e-004
	,7.259993783e-004
	,7.314991969e-004
	,7.369567877e-004
	,7.423702751e-004
	,7.477396647e-004
	,7.530666200e-004
	,7.583535787e-004
	,7.636028324e-004
	,7.688160255e-004
	,7.739940702e-004
	,7.791372714e-004
	,7.842455018e-004
	,7.893183537e-004
	,7.943552521e-004
	,7.993555301e-004
	,8.043184766e-004
	,8.092433597e-004
	,8.141294319e-004
	,8.189759145e-004
	,8.237819590e-004
	,8.285465746e-004
	,8.332685061e-004
	,8.379460380e-004
	,8.425766940e-004
	,8.471568386e-004
	,8.516813415e-004
	,8.561438927e-004
	,8.605389669e-004
	,8.648652041e-004
	,8.691267647e-004
	,8.733301346e-004
	,8.774791860e-004
	,8.815706168e-004
	,8.855865069e-004
	,8.894844783e-004
	,8.932333195e-004
	,8.968766245e-004
	,9.004671589e-004
	,9.040267605e-004
	,9.075626437e-004
	,9.110780462e-004
	,9.145751367e-004
	,9.180554444e-004
	,9.215199447e-004
	,9.249692133e-004
	,9.284036104e-004
	,9.318234654e-004
	,9.352292718e-004
	,9.386218782e-004
	,9.420024828e-004
	,9.453722137e-004
	,9.487316865e-004
	,9.520810510e-004
	,9.554202565e-004
	,9.587491926e-004
	,9.620677097e-004
	,9.653756084e-004
	,9.686726326e-004
	,9.719584386e-004
	,9.752324880e-004
	,9.784937790e-004
	,9.817401865e-004
	,9.849666267e-004
	,9.881587461e-004
	,9.912640118e-004
	,9.940662738e-004
	,9.964474345e-004
	,9.988186836e-004
	,1.001274766e-003
	,1.003796145e-003
	,1.006363353e-003
	,1.008963084e-003
	,1.011585788e-003
	,1.014224994e-003
	,1.016877259e-003
	,1.019539630e-003
	,1.022209883e-003
	,1.024886393e-003
	,1.027567971e-003
	,1.030253710e-003
	,1.032942882e-003
	,1.035634897e-003
	,1.038329322e-003
	,1.041025918e-003
	,1.043724677e-003
	,1.046425828e-003
	,-8.132272737e-004
	,-7.929686320e-004
	,-7.726936896e-004
	,-7.523495458e-004
	,-7.318290040e-004
	,-7.109292507e-004
	,-6.895856714e-004
	,-6.679238223e-004
	,-6.460164895e-004
	,-6.239565020e-004
	,-6.019617092e-004
	,-5.802012019e-004
	,-5.587650068e-004
	,-5.377157595e-004
	,-5.170668770e-004
	,-4.967897104e-004
	,-4.768162492e-004
	,-4.570283112e-004
	,-4.372493400e-004
	,-4.172893080e-004
	,-3.970723714e-004
	,-3.766659591e-004
	,-3.562040736e-004
	,-3.358360467e-004
	,-3.156730677e-004
	,-2.957898467e-004
	,-2.762021808e-004
	,-2.568638650e-004
	,-2.376814109e-004
	,-2.185119649e-004
	,-1.991521889e-004
	,-1.793870353e-004
	,-1.592167821e-004
	,-1.388742191e-004
	,-1.185481836e-004
	,-9.831734590e-005
	,-7.821185466e-005
	,-5.826419176e-005
	,-3.852943230e-005
	,-1.908236417e-005
	,4.329520106e-015
	,1.865969384e-005
	,3.687154923e-005
	,5.463087118e-005
	,7.192404271e-005
	,8.870336876e-005
	,1.049109989e-004
	,1.205435548e-004
	,1.356438966e-004
	,1.502622967e-004
	,1.644443884e-004
	,1.782311160e-004
	,1.916596711e-004
	,2.047643308e-004
	,2.175783713e-004
	,2.301361926e-004
	,2.424724405e-004
	,2.546190459e-004
	,2.666034332e-004
	,2.784479490e-004
	,2.901693026e-004
	,3.017774539e-004
	,3.132747277e-004
	,3.246599803e-004
	,3.359459936e-004
	,3.471748942e-004
	,3.583976380e-004
	,3.696468857e-004
	,3.809362605e-004
	,3.922691011e-004
	,4.036435263e-004
	,4.150547522e-004
	,4.264976964e-004
	,4.379624464e-004
	,4.494299627e-004
	,4.608645253e-004
	,4.722039145e-004
	,4.833738693e-004
	,4.943566113e-004
	,5.052109225e-004
	,5.160000424e-004
	,5.267565792e-004
	,5.374891258e-004
	,5.481910851e-004
	,5.588434548e-004
	,5.694120242e-004
	,5.798386989e-004
	,5.900294182e-004
	,5.998607035e-004
	,6.092377476e-004
	,6.181068654e-004
	,6.261345580e-004
	,6.298556879e-004
	,6.321294795e-004
	,6.365840205e-004
	,6.418120967e-004
	,6.474214383e-004
	,6.532510888e-004
	,6.592177781e-004
	,6.652715464e-004
	,6.713788312e-004
	,6.775148573e-004
	,6.836600111e-004
	,6.897986548e-004
	,6.959202624e-004
	,7.020219991e-004
	,7.081088551e-004
	,7.141888340e-004
	,7.202677162e-004
	,7.263475627e-004
	,7.324276918e-004
	,7.385059532e-004
	,7.445795653e-004
	,7.506455550e-004
	,7.567009632e-004
	,7.627429287e-004
	,7.687687146e-004
	,7.747757076e-004
	,7.807614049e-004
	,7.867233947e-004
	,7.926593330e-004
	,7.985669177e-004
	,8.044438585e-004
	,8.102878441e-004
	,8.160965091e-004
	,8.218674096e-004
	,8.275980298e-004
	,8.332858602e-004
	,8.389286021e-004
	,8.445245202e-004
	,8.500728420e-004
	,8.555739513e-004
	,8.610291629e-004
	,8.664401631e-004
	,8.718084436e-004
	,8.771349584e-004
	,8.824200145e-004
	,8.876632841e-004
	,8.928638415e-004
	,8.980201714e-004
	,9.031301453e-004
	,9.081910139e-004
	,9.131995342e-004
	,9.181524176e-004
	,9.230471817e-004
	,9.278830817e-004
	,9.326614155e-004
	,9.373848820e-004
	,9.420565209e-004
	,9.466789225e-004
	,9.512538994e-004
	,9.557824452e-004
	,9.602647804e-004
	,9.647003855e-004
	,9.690880147e-004
	,9.734257565e-004
	,9.777112354e-004
	,9.819419445e-004
	,9.861154242e-004
	,9.902287350e-004
	,9.942764863e-004
	,9.982461072e-004
	,1.002111010e-003
	,1.005845653e-003
	,1.009472426e-003
	,1.013036227e-003
	,1.016562319e-003
	,1.020060739e-003
	,1.023535287e-003
	,1.026987348e-003
	,1.030417328e-003
	,1.033825228e-003
	,1.037210900e-003
	,1.040574190e-003
	,1.043915021e-003
	,1.047233476e-003
	,1.050529890e-003
	,1.053804965e-003
	,1.057059766e-003
	,1.060295190e-003
	,1.063510661e-003
	,1.066702850e-003
	,1.069863804e-003
	,1.072972347e-003
	,1.075948199e-003
	,1.078466439e-003
	,1.080564595e-003
	,1.082760510e-003
	,1.085073019e-003
	,1.087461131e-003
	,1.089898393e-003
	,1.092368420e-003
	,1.094860540e-003
	,1.097367449e-003
	,1.099883944e-003
	,1.102406205e-003
	,1.104931351e-003
	,1.107457170e-003
	,1.109981881e-003
	,1.112503484e-003
	,1.115019180e-003
	,-8.307609053e-004
	,-8.102041312e-004
	,-7.895738668e-004
	,-7.687907711e-004
	,-7.476998265e-004
	,-7.261447105e-004
	,-7.042187838e-004
	,-6.820499143e-004
	,-6.596891975e-004
	,-6.372916236e-004
	,-6.150726219e-004
	,-5.931433015e-004
	,-5.715696100e-004
	,-5.503889006e-004
	,-5.295863186e-004
	,-5.091013938e-004
	,-4.888231027e-004
	,-4.685808256e-004
	,-4.481809266e-004
	,-4.275366882e-004
	,-4.067110762e-004
	,-3.858168627e-004
	,-3.649826434e-004
	,-3.443297882e-004
	,-3.239492361e-004
	,-3.038808030e-004
	,-2.840922507e-004
	,-2.644881891e-004
	,-2.449059438e-004
	,-2.250905392e-004
	,-2.047694467e-004
	,-1.839746566e-004
	,-1.629955123e-004
	,-1.420460752e-004
	,-1.212130445e-004
	,-1.005175029e-004
	,-7.996798663e-005
	,-5.958427048e-005
	,-3.941019101e-005
	,-1.952157155e-005
	,3.877585900e-016
	,1.910363924e-005
	,3.777647057e-005
	,5.602783379e-005
	,7.387077211e-005
	,9.131225912e-005
	,1.083536643e-004
	,1.249800298e-004
	,1.411381096e-004
	,1.567587537e-004
	,1.718323860e-004
	,1.864089829e-004
	,2.005460885e-004
	,2.142943380e-004
	,2.277010850e-004
	,2.408106905e-004
	,2.536628121e-004
	,2.662918417e-004
	,2.787267121e-004
	,2.909901127e-004
	,3.030967675e-004
	,3.150512691e-004
	,3.268497953e-004
	,3.384979384e-004
	,3.500412065e-004
	,3.615553066e-004
	,3.730999443e-004
	,3.847044646e-004
	,3.963795948e-004
	,4.081280796e-004
	,4.199496133e-004
	,4.318426115e-004
	,4.438046705e-004
	,4.558325198e-004
	,4.679217735e-004
	,4.800665713e-004
	,4.922590959e-004
	,5.044888473e-004
	,5.167413942e-004
	,5.289959131e-004
	,5.412203148e-004
	,5.533638349e-004
	,5.653386992e-004
	,5.769932160e-004
	,5.881308286e-004
	,5.986633134e-004
	,6.087126787e-004
	,6.184568137e-004
	,6.280076409e-004
	,6.374097690e-004
	,6.466547616e-004
	,6.556571011e-004
	,6.640396204e-004
	,6.665284754e-004
	,6.672311638e-004
	,6.714598711e-004
	,6.766593651e-004
	,6.823335492e-004
	,6.882869611e-004
	,6.944186784e-004
	,7.006676950e-004
	,7.069925828e-004
	,7.133623551e-004
	,7.197524143e-004
	,7.261443466e-004
	,7.325289911e-004
	,7.389085380e-004
	,7.452919283e-004
	,7.516867480e-004
	,7.580953795e-004
	,7.645159014e-004
	,7.709442744e-004
	,7.773759858e-004
	,7.838069145e-004
	,7.902336241e-004
	,7.966533249e-004
	,8.030636981e-004
	,8.094627119e-004
	,8.158484840e-004
	,8.222191993e-004
	,8.285730687e-004
	,8.349083127e-004
	,8.412231574e-004
	,8.475158359e-004
	,8.537845925e-004
	,8.600276850e-004
	,8.662433868e-004
	,8.724299881e-004
	,8.785857942e-004
	,8.847091226e-004
	,8.907982981e-004
	,8.968516453e-004
	,9.028674777e-004
	,9.088440844e-004
	,9.147797120e-004
	,9.206725436e-004
	,9.265206765e-004
	,9.323221019e-004
	,9.380746988e-004
	,9.437762578e-004
	,9.494245569e-004
	,9.550174991e-004
	,9.605532892e-004
	,9.660305905e-004
	,9.714486094e-004
	,9.768071253e-004
	,9.821065033e-004
	,9.873476602e-004
	,9.925319118e-004
	,9.976607080e-004
	,1.002735359e-003
	,1.007756848e-003
	,1.012725757e-003
	,1.017642262e-003
	,1.022506172e-003
	,1.027316968e-003
	,1.032073843e-003
	,1.036775737e-003
	,1.041421394e-003
	,1.046009450e-003
	,1.050538554e-003
	,1.055007514e-003
	,1.059415409e-003
	,1.063761622e-003
	,1.068045806e-003
	,1.072267798e-003
	,1.076427533e-003
	,1.080524970e-003
	,1.084560024e-003
	,1.088532504e-003
	,1.092442005e-003
	,1.096287705e-003
	,1.100067905e-003
	,1.103778926e-003
	,1.107412399e-003
	,1.110950659e-003
	,1.114373192e-003
	,1.117690137e-003
	,1.120935387e-003
	,1.124131056e-003
	,1.127286453e-003
	,1.130405259e-003
	,1.133488895e-003
	,1.136537744e-003
	,1.139551503e-003
	,1.142529049e-003
	,1.145467732e-003
	,1.148361121e-003
	,1.151190972e-003
	,1.153887238e-003
	,1.156108783e-003
	,1.157807398e-003
	,1.159668279e-003
	,1.161678130e-003
	,1.163774375e-003
	,1.165922987e-003
	,1.168104088e-003
	,1.170304956e-003
	,1.172516967e-003
	,1.174734033e-003
	,1.176951699e-003
	,-8.470199302e-004
	,-8.261020551e-004
	,-8.050312269e-004
	,-7.837344949e-004
	,-7.620735171e-004
	,-7.399866120e-004
	,-7.176091712e-004
	,-6.950156161e-004
	,-6.722921521e-004
	,-6.496516567e-004
	,-6.272665406e-004
	,-6.052021762e-004
	,-5.835071840e-004
	,-5.621934195e-004
	,-5.412175442e-004
	,-5.204830392e-004
	,-4.998321910e-004
	,-4.790679635e-004
	,-4.580741293e-004
	,-4.368930472e-004
	,-4.156288773e-004
	,-3.943842074e-004
	,-3.732778455e-004
	,-3.524185287e-004
	,-3.318748981e-004
	,-3.116392527e-004
	,-2.916273505e-004
	,-2.716767117e-004
	,-2.514959444e-004
	,-2.307304592e-004
	,-2.093794734e-004
	,-1.877635831e-004
	,-1.661287156e-004
	,-1.445950478e-004
	,-1.232303528e-004
	,-1.020694921e-004
	,-8.112323816e-005
	,-6.040480998e-005
	,-3.994826637e-005
	,-1.980026326e-005
	,-2.814464012e-016
	,1.942759808e-005
	,3.846813129e-005
	,5.711460029e-005
	,7.536684349e-005
	,9.323634956e-005
	,1.107448430e-004
	,1.279129360e-004
	,1.447515973e-004
	,1.612547247e-004
	,1.773870777e-004
	,1.930732426e-004
	,2.082273516e-004
	,2.228360910e-004
	,2.369675676e-004
	,2.507035312e-004
	,2.641087774e-004
	,2.772320830e-004
	,2.901103150e-004
	,3.027694666e-004
	,3.152230145e-004
	,3.274703187e-004
	,3.395057453e-004
	,3.513548602e-004
	,3.631032092e-004
	,3.748509272e-004
	,3.866602418e-004
	,3.985572847e-004
	,4.105503400e-004
	,4.226407569e-004
	,4.348273074e-004
	,4.471075598e-004
	,4.594780979e-004
	,4.719342981e-004
	,4.844698950e-004
	,4.970763336e-004
	,5.097417073e-004
	,5.224487437e-004
	,5.351705104e-004
	,5.478606939e-004
	,5.604329304e-004
	,5.727367614e-004
	,5.846164901e-004
	,5.960856403e-004
	,6.072911017e-004
	,6.183467676e-004
	,6.293063153e-004
	,6.401882268e-004
	,6.509911412e-004
	,6.616979542e-004
	,6.722720347e-004
	,6.826473547e-004
	,6.927102834e-004
	,7.022396393e-004
	,7.100230437e-004
	,7.041892205e-004
	,7.073922871e-004
	,7.121918163e-004
	,7.176728028e-004
	,7.235396112e-004
	,7.296507614e-004
	,7.359235587e-004
	,7.423023637e-004
	,7.487454535e-004
	,7.552202418e-004
	,7.617049206e-004
	,7.681938529e-004
	,7.746974247e-004
	,7.812310577e-004
	,7.878041827e-004
	,7.944180004e-004
	,8.010683546e-004
	,8.077487288e-004
	,8.144519937e-004
	,8.211711981e-004
	,8.278998582e-004
	,8.346320345e-004
	,8.413623446e-004
	,8.480859823e-004
	,8.547987605e-004
	,8.614971644e-004
	,8.681783713e-004
	,8.748402021e-004
	,8.814809980e-004
	,8.880994535e-004
	,8.946944511e-004
	,9.012649311e-004
	,9.078098078e-004
	,9.143279251e-004
	,9.208180402e-004
	,9.272788223e-004
	,9.337088595e-004
	,9.401066675e-004
	,9.464706978e-004
	,9.527993435e-004
	,9.590909426e-004
	,9.653437782e-004
	,9.715560749e-004
	,9.777259932e-004
	,9.838516213e-004
	,9.899309669e-004
	,9.959619519e-004
	,1.001942417e-003
	,1.007870140e-003
	,1.013742884e-003
	,1.019558471e-003
	,1.025314879e-003
	,1.031010335e-003
	,1.036643378e-003
	,1.042212862e-003
	,1.047717903e-003
	,1.053157812e-003
	,1.058532038e-003
	,1.063840156e-003
	,1.069081881e-003
	,1.074257090e-003
	,1.079365789e-003
	,1.084408024e-003
	,1.089383759e-003
	,1.094292763e-003
	,1.099134553e-003
	,1.103908398e-003
	,1.108613362e-003
	,1.113248376e-003
	,1.117812319e-003
	,1.122304087e-003
	,1.126722653e-003
	,1.131067100e-003
	,1.135336632e-003
	,1.139530569e-003
	,1.143648332e-003
	,1.147689427e-003
	,1.151653421e-003
	,1.155539935e-003
	,1.159348623e-003
	,1.163079162e-003
	,1.166731244e-003
	,1.170304569e-003
	,1.173798851e-003
	,1.177213837e-003
	,1.180549342e-003
	,1.183805314e-003
	,1.186981890e-003
	,1.190079442e-003
	,1.193098505e-003
	,1.196039461e-003
	,1.198901644e-003
	,1.201681180e-003
	,1.204367931e-003
	,1.206952936e-003
	,1.209449911e-003
	,1.211881827e-003
	,1.214259732e-003
	,1.216582340e-003
	,1.218829429e-003
	,1.220896719e-003
	,1.222292803e-003
	,1.223526956e-003
	,1.224999892e-003
	,1.226593840e-003
	,1.228252607e-003
	,-3.996147636e-006
	,-3.284640955e-006
	,-2.691283929e-006
	,-2.198171798e-006
	,-1.787252263e-006
	,-1.445829303e-006
	,-1.164374584e-006
	,-9.350659274e-007
	,-7.485950783e-007
	,-5.956611076e-007
	,-4.706915551e-007
	,-3.706892067e-007
	,-2.917763721e-007
	,-2.295670256e-007
	,-1.803840803e-007
	,-1.414378431e-007
	,-1.105030292e-007
	,-8.593218568e-008
	,-6.649649897e-008
	,-5.126776631e-008
	,-3.946298306e-008
	,-3.038447903e-008
	,-2.342278721e-008
	,-1.807730016e-008
	,-1.395696142e-008
	,-1.076759018e-008
	,-8.289191140e-009
	,-6.362267246e-009
	,-4.867879832e-009
	,-3.709631934e-009
	,-2.812658319e-009
	,-2.118315417e-009
	,-1.580899871e-009
	,-1.166801592e-009
	,-8.496705315e-010
	,-6.072841496e-010
	,-4.213138816e-010
	,-2.773214431e-010
	,-1.642797911e-010
	,-7.390278146e-011
	,-1.472518593e-017
	,6.200109277e-011
	,1.154737951e-010
	,1.630797593e-010
	,2.069991121e-010
	,2.489634972e-010
	,2.904024902e-010
	,3.325345334e-010
	,3.763163750e-010
	,4.223632598e-010
	,4.708793716e-010
	,5.218533802e-010
	,5.755046881e-010
	,6.322454928e-010
	,6.923449598e-010
	,7.559080222e-010
	,8.233229201e-010
	,8.955873555e-010
	,9.739775100e-010
	,1.059698718e-009
	,1.153823978e-009
	,1.257300678e-009
	,1.370894841e-009
	,1.495195895e-009
	,1.631028892e-009
	,1.779844138e-009
	,1.943427453e-009
	,2.123720753e-009
	,2.323069181e-009
	,2.544322751e-009
	,2.790817363e-009
	,3.066478703e-009
	,3.375986230e-009
	,3.724919887e-009
	,4.119807845e-009
	,4.567866007e-009
	,5.076165870e-009
	,5.650568463e-009
	,6.298658578e-009
	,7.035666607e-009
	,7.882942867e-009
	,8.864103602e-009
	,1.000242812e-008
	,1.131533871e-008
	,1.280548622e-008
	,1.445851953e-008
	,1.630434333e-008
	,1.842525742e-008
	,2.090428107e-008
	,2.381711472e-008
	,2.725123950e-008
	,3.133189006e-008
	,3.620535842e-008
	,4.203726720e-008
	,4.904613196e-008
	,5.748932826e-008
	,6.768894642e-008
	,8.008601771e-008
	,9.520845433e-008
	,1.137043720e-007
	,1.363516697e-007
	,1.639341846e-007
	,1.972617970e-007
	,2.380800321e-007
	,2.882249197e-007
	,3.486249751e-007
	,4.222348662e-007
	,5.110285160e-007
	,6.139346923e-007
	,7.308229473e-007
	,8.700570961e-007
	,1.039595186e-006
	,1.246929223e-006
	,1.500965892e-006
	,1.812728799e-006
	,2.195717508e-006
	,2.666393145e-006
	,3.239274358e-006
	,3.941775218e-006
	,4.803912275e-006
	,5.850414510e-006
	,7.114759975e-006
	,8.655287119e-006
	,1.053274763e-005
	,1.280168766e-005
	,1.540720765e-005
	,1.832617583e-005
	,2.150588750e-005
	,2.496646244e-005
	,2.900972330e-005
	,3.375060723e-005
	,3.929142069e-005
	,4.574065621e-005
	,5.321511224e-005
	,6.183641494e-005
	,7.171908699e-005
	,8.287172985e-005
	,9.540820242e-005
	,1.094570001e-004
	,1.250119249e-004
	,1.420109136e-004
	,1.605861564e-004
	,1.806983392e-004
	,2.022182375e-004
	,2.245920887e-004
	,2.480303287e-004
	,2.721867575e-004
	,2.957836929e-004
	,3.195447884e-004
	,3.447468456e-004
	,3.716593654e-004
	,4.002403456e-004
	,4.303974668e-004
	,4.620407561e-004
	,4.950899375e-004
	,5.294752230e-004
	,5.651342137e-004
	,6.020136142e-004
	,6.400664862e-004
	,6.792513591e-004
	,7.195321373e-004
	,7.608775723e-004
	,8.032380458e-004
	,8.465752520e-004
	,8.909077878e-004
	,9.362189409e-004
	,9.824855247e-004
	,1.029682344e-003
	,1.077815530e-003
	,1.126878371e-003
	,1.176861697e-003
	,1.227756514e-003
	,1.279144302e-003
	,1.330874530e-003
	,1.383397242e-003
	,1.436698304e-003
	,1.490762033e-003
	,1.545570835e-003
	,1.601104841e-003
	,1.657341542e-003
	,1.714255432e-003
	,1.771814290e-003
	,1.829986131e-003
	,1.888737782e-003
	,1.948028161e-003
	,2.007811369e-003
	,2.068036338e-003
	,2.128646476e-003
	,2.189577322e-003
	,2.250751865e-003
	,2.312104657e-003
	,2.373553911e-003
	,2.435011127e-003
	,2.496326132e-003
	,2.557346266e-003
	,2.617970778e-003
	,2.678110790e-003
	,2.737664885e-003
	,2.796507864e-003
	,2.854513571e-003
	,2.911556953e-003
	,-1.007514447e-005
	,-8.442391229e-006
	,-7.019057437e-006
	,-5.802384618e-006
	,-4.772465116e-006
	,-3.909119280e-006
	,-3.185530526e-006
	,-2.574928064e-006
	,-2.064968051e-006
	,-1.645787927e-006
	,-1.307449005e-006
	,-1.038381380e-006
	,-8.246954959e-007
	,-6.533619040e-007
	,-5.145695584e-007
	,-4.026898858e-007
	,-3.134763307e-007
	,-2.430502161e-007
	,-1.882033217e-007
	,-1.458426617e-007
	,-1.131679835e-007
	,-8.789848417e-008
	,-6.824817664e-008
	,-5.285668782e-008
	,-4.077697617e-008
	,-3.135054142e-008
	,-2.401295684e-008
	,-1.828995624e-008
	,-1.385320141e-008
	,-1.045693374e-008
	,-7.877128385e-009
	,-5.920795288e-009
	,-4.434685575e-009
	,-3.301465202e-009
	,-2.432452618e-009
	,-1.760844843e-009
	,-1.236362991e-009
	,-8.217091714e-010
	,-4.901445476e-010
	,-2.216638371e-010
	,-1.655275886e-017
	,1.877298706e-010
	,3.509983114e-010
	,4.964041096e-010
	,6.283814858e-010
	,7.503710493e-010
	,8.660409651e-010
	,9.790747612e-010
	,1.092892428e-009
	,1.210628696e-009
	,1.334970519e-009
	,1.468174033e-009
	,1.612227854e-009
	,1.768986414e-009
	,1.940196614e-009
	,2.127419524e-009
	,2.331812240e-009
	,2.554103893e-009
	,2.795599146e-009
	,3.058858210e-009
	,3.346847054e-009
	,3.662218867e-009
	,4.007376503e-009
	,4.385179489e-009
	,4.799238900e-009
	,5.253560029e-009
	,5.752074050e-009
	,6.297897350e-009
	,6.892245165e-009
	,7.534255609e-009
	,8.224309734e-009
	,8.967475865e-009
	,9.770864136e-009
	,1.063926085e-008
	,1.157246199e-008
	,1.256426448e-008
	,1.360623788e-008
	,1.469874236e-008
	,1.585853586e-008
	,1.711192979e-008
	,1.848637696e-008
	,2.000878685e-008
	,2.170698338e-008
	,2.361082594e-008
	,2.575240318e-008
	,2.816842001e-008
	,3.091013925e-008
	,3.404547351e-008
	,3.765564676e-008
	,4.183873580e-008
	,4.671225740e-008
	,5.241601352e-008
	,5.911765674e-008
	,6.701841340e-008
	,7.636456990e-008
	,8.746813776e-008
	,1.007039053e-007
	,1.165014723e-007
	,1.352891501e-007
	,1.574341179e-007
	,1.836265080e-007
	,2.147857305e-007
	,2.518898646e-007
	,2.963731693e-007
	,3.494293729e-007
	,4.111240454e-007
	,4.803222566e-007
	,5.595359117e-007
	,6.537281841e-007
	,7.672763215e-007
	,9.051582957e-007
	,1.073147809e-006
	,1.278293893e-006
	,1.529257900e-006
	,1.835608591e-006
	,2.208731254e-006
	,2.666194645e-006
	,3.228393244e-006
	,3.919450513e-006
	,4.758789928e-006
	,5.776165767e-006
	,7.020375045e-006
	,8.540613949e-006
	,1.035680879e-005
	,1.247762605e-005
	,1.485041726e-005
	,1.743241308e-005
	,2.031840329e-005
	,2.371452552e-005
	,2.772011091e-005
	,3.242796498e-005
	,3.793728672e-005
	,4.435523900e-005
	,5.179286428e-005
	,6.035864995e-005
	,7.009117164e-005
	,8.108099990e-005
	,9.344459933e-005
	,1.071247180e-004
	,1.221969192e-004
	,1.387494038e-004
	,1.567594652e-004
	,1.761111998e-004
	,1.963663668e-004
	,2.175259675e-004
	,2.390686780e-004
	,2.602428104e-004
	,2.819234504e-004
	,3.050854519e-004
	,3.297422394e-004
	,3.559824418e-004
	,3.837272098e-004
	,4.129002683e-004
	,4.434327316e-004
	,4.752628228e-004
	,5.083037834e-004
	,5.424745325e-004
	,5.777849680e-004
	,6.142002436e-004
	,6.516883509e-004
	,6.902195445e-004
	,7.297678191e-004
	,7.703105632e-004
	,8.118282242e-004
	,8.543022856e-004
	,8.977192864e-004
	,9.420673608e-004
	,9.873358401e-004
	,1.033515454e-003
	,1.080597990e-003
	,1.128575956e-003
	,1.177442227e-003
	,1.227189694e-003
	,1.277167020e-003
	,1.327483153e-003
	,1.378551154e-003
	,1.430358578e-003
	,1.482891619e-003
	,1.536134794e-003
	,1.590067855e-003
	,1.644671410e-003
	,1.699925704e-003
	,1.755805418e-003
	,1.812281942e-003
	,1.869323058e-003
	,1.926892608e-003
	,1.984950177e-003
	,2.043450763e-003
	,2.102344461e-003
	,2.161576141e-003
	,2.221081382e-003
	,2.280789188e-003
	,2.340634659e-003
	,2.400473996e-003
	,2.460252523e-003
	,2.519874983e-003
	,2.579239521e-003
	,2.638238944e-003
	,2.696761521e-003
	,2.754692014e-003
	,2.811893096e-003
	,-2.316266047e-005
	,-1.993370688e-005
	,-1.698612319e-005
	,-1.429433598e-005
	,-1.191377421e-005
	,-9.877606938e-006
	,-8.167557361e-006
	,-6.726391305e-006
	,-5.489166957e-006
	,-4.432246917e-006
	,-3.556636998e-006
	,-2.845338689e-006
	,-2.270849265e-006
	,-1.809381577e-006
	,-1.438518602e-006
	,-1.137466245e-006
	,-8.938328726e-007
	,-7.001536558e-007
	,-5.478334121e-007
	,-4.281609453e-007
	,-3.336404881e-007
	,-2.587988523e-007
	,-1.999961640e-007
	,-1.541593355e-007
	,-1.185087001e-007
	,-9.078374347e-008
	,-6.932620764e-008
	,-5.286599473e-008
	,-4.030437539e-008
	,-3.072179159e-008
	,-2.339450272e-008
	,-1.776944616e-008
	,-1.342533746e-008
	,-1.004713346e-008
	,-7.413359012e-009
	,-5.360964131e-009
	,-3.754559696e-009
	,-2.484986199e-009
	,-1.471505638e-009
	,-6.576477402e-010
	,3.968274343e-018
	,5.406825590e-010
	,9.987865049e-010
	,1.402102164e-009
	,1.772295974e-009
	,2.126182418e-009
	,2.476955967e-009
	,2.835131699e-009
	,3.209177509e-009
	,3.605743464e-009
	,4.029236242e-009
	,4.481829030e-009
	,4.966513672e-009
	,5.489653544e-009
	,6.058717138e-009
	,6.679921828e-009
	,7.357584249e-009
	,8.094401744e-009
	,8.892608248e-009
	,9.752652842e-009
	,1.067002195e-008
	,1.163906051e-008
	,1.266066155e-008
	,1.373894098e-008
	,1.487401268e-008
	,1.606189355e-008
	,1.730331834e-008
	,1.861161822e-008
	,2.000726714e-008
	,2.150996330e-008
	,2.313679917e-008
	,2.490328013e-008
	,2.682447553e-008
	,2.891559036e-008
	,3.119145532e-008
	,3.366495689e-008
	,3.634581457e-008
	,3.924459162e-008
	,4.238138606e-008
	,4.578562279e-008
	,4.948963241e-008
	,5.352623924e-008
	,5.793090559e-008
	,6.274641729e-008
	,6.802454218e-008
	,7.382550633e-008
	,8.021919514e-008
	,8.728760257e-008
	,9.512734562e-008
	,1.038510020e-007
	,1.135845295e-007
	,1.244558365e-007
	,1.365775286e-007
	,1.500643430e-007
	,1.651415196e-007
	,1.821951550e-007
	,2.017007557e-007
	,2.241794969e-007
	,2.501626266e-007
	,2.800700403e-007
	,3.139379408e-007
	,3.513079596e-007
	,3.923420073e-007
	,4.389352469e-007
	,4.931221405e-007
	,5.568860638e-007
	,6.321202128e-007
	,7.213465754e-007
	,8.277949127e-007
	,9.550952971e-007
	,1.107500916e-006
	,1.290641571e-006
	,1.511139989e-006
	,1.778054188e-006
	,2.102481455e-006
	,2.498134884e-006
	,2.979939450e-006
	,3.564061259e-006
	,4.265126707e-006
	,5.117179362e-006
	,6.155092797e-006
	,7.401176578e-006
	,8.871132466e-006
	,1.056722629e-005
	,1.244830230e-005
	,1.450125476e-005
	,1.690604701e-005
	,1.976060805e-005
	,2.314278197e-005
	,2.713581595e-005
	,3.183161256e-005
	,3.732819368e-005
	,4.372818419e-005
	,5.112954236e-005
	,5.957187239e-005
	,6.916100094e-005
	,7.996161049e-005
	,9.191524572e-005
	,1.051894996e-004
	,1.198281635e-004
	,1.358114954e-004
	,1.530237100e-004
	,1.710717214e-004
	,1.897439422e-004
	,2.086912716e-004
	,2.273177902e-004
	,2.468604573e-004
	,2.678826615e-004
	,2.904632151e-004
	,3.145485095e-004
	,3.400554390e-004
	,3.666257348e-004
	,3.944871833e-004
	,4.235912316e-004
	,4.538933971e-004
	,4.853527072e-004
	,5.179311021e-004
	,5.515943729e-004
	,5.863114276e-004
	,6.220537000e-004
	,6.587927881e-004
	,6.965092735e-004
	,7.351834247e-004
	,7.747979752e-004
	,8.153379138e-004
	,8.567902620e-004
	,8.991438419e-004
	,9.423890363e-004
	,9.865175429e-004
	,1.031522120e-003
	,1.077396326e-003
	,1.124134251e-003
	,1.171730238e-003
	,1.220178592e-003
	,1.268393630e-003
	,1.317074150e-003
	,1.366460976e-003
	,1.416544863e-003
	,1.467313890e-003
	,1.518754769e-003
	,1.570852583e-003
	,1.623590505e-003
	,1.676949530e-003
	,1.730908191e-003
	,1.785442286e-003
	,1.840524591e-003
	,1.896124581e-003
	,1.952208149e-003
	,2.008737315e-003
	,2.065669945e-003
	,2.122959468e-003
	,2.180554598e-003
	,2.238404388e-003
	,2.296415043e-003
	,2.354518841e-003
	,2.412639164e-003
	,2.470693786e-003
	,2.528595027e-003
	,2.586250026e-003
	,2.643561137e-003
	,2.700426488e-003
	,-4.740355667e-005
	,-4.171698233e-005
	,-3.652109711e-005
	,-3.165752017e-005
	,-2.711392816e-005
	,-2.302352074e-005
	,-1.946412448e-005
	,-1.638692977e-005
	,-1.367726867e-005
	,-1.127712236e-005
	,-9.218421796e-006
	,-7.503090068e-006
	,-6.092080254e-006
	,-4.939819181e-006
	,-3.990825709e-006
	,-3.195824088e-006
	,-2.534713035e-006
	,-1.998216600e-006
	,-1.568201965e-006
	,-1.227228059e-006
	,-9.596140692e-007
	,-7.504490003e-007
	,-5.869894945e-007
	,-4.582241761e-007
	,-3.558513504e-007
	,-2.750588327e-007
	,-2.122057462e-007
	,-1.635558810e-007
	,-1.257686092e-007
	,-9.620119199e-008
	,-7.303774651e-008
	,-5.503730936e-008
	,-4.114461750e-008
	,-3.047114434e-008
	,-2.228906005e-008
	,-1.599172711e-008
	,-1.110893534e-008
	,-7.304466326e-009
	,-4.318744877e-009
	,-1.939783863e-009
	,-1.592616243e-017
	,1.630456350e-009
	,3.051403803e-009
	,4.339079947e-009
	,5.550010958e-009
	,6.723298194e-009
	,7.888133519e-009
	,9.074452525e-009
	,1.031094802e-008
	,1.161766364e-008
	,1.300091846e-008
	,1.444957594e-008
	,1.593808526e-008
	,1.745101274e-008
	,1.900449873e-008
	,2.063020432e-008
	,2.236220132e-008
	,2.423259745e-008
	,2.626726775e-008
	,2.848605704e-008
	,3.090634266e-008
	,3.354729021e-008
	,3.643163761e-008
	,3.958427173e-008
	,4.303001776e-008
	,4.679144342e-008
	,5.088491891e-008
	,5.531634409e-008
	,6.008660974e-008
	,6.521495102e-008
	,7.074868290e-008
	,7.674480034e-008
	,8.325618461e-008
	,9.032788825e-008
	,9.799708192e-008
	,1.063002153e-007
	,1.152837694e-007
	,1.250033356e-007
	,1.355135350e-007
	,1.468510385e-007
	,1.590145671e-007
	,1.719725235e-007
	,1.857295911e-007
	,2.003712280e-007
	,2.160111036e-007
	,2.327249190e-007
	,2.505095897e-007
	,2.692471445e-007
	,2.886986229e-007
	,3.086211335e-007
	,3.290095371e-007
	,3.501756647e-007
	,3.725634546e-007
	,3.965898063e-007
	,4.226204635e-007
	,4.510014586e-007
	,4.820931099e-007
	,5.162948120e-007
	,5.540590414e-007
	,5.959002603e-007
	,6.424382452e-007
	,6.945226314e-007
	,7.532868318e-007
	,8.201131123e-007
	,8.966818122e-007
	,9.850467038e-007
	,1.087668216e-006
	,1.207476417e-006
	,1.348024282e-006
	,1.513648369e-006
	,1.709615534e-006
	,1.942329379e-006
	,2.219491734e-006
	,2.549459648e-006
	,2.940650123e-006
	,3.400160954e-006
	,3.944712134e-006
	,4.594127855e-006
	,5.362879504e-006
	,6.267389183e-006
	,7.321506468e-006
	,8.498730002e-006
	,9.786116463e-006
	,1.124511919e-005
	,1.296277782e-005
	,1.500721925e-005
	,1.744091996e-005
	,2.033093884e-005
	,2.374574402e-005
	,2.776856127e-005
	,3.249058005e-005
	,3.800179376e-005
	,4.437343124e-005
	,5.167494197e-005
	,5.999383006e-005
	,6.929342775e-005
	,7.969409790e-005
	,9.128507356e-005
	,1.040970543e-004
	,1.180924953e-004
	,1.331042510e-004
	,1.487569295e-004
	,1.647191669e-004
	,1.807872617e-004
	,1.971138798e-004
	,2.145809101e-004
	,2.334073527e-004
	,2.535971658e-004
	,2.751659711e-004
	,2.980798171e-004
	,3.223048831e-004
	,3.478085535e-004
	,3.745555416e-004
	,4.020862969e-004
	,4.307332187e-004
	,4.604659156e-004
	,4.912557591e-004
	,5.230758420e-004
	,5.559009632e-004
	,5.897086648e-004
	,6.244780816e-004
	,6.601903128e-004
	,6.968261343e-004
	,7.343701744e-004
	,7.728106718e-004
	,8.121357569e-004
	,8.523350431e-004
	,8.933991805e-004
	,9.353203930e-004
	,9.780918026e-004
	,1.021707352e-003
	,1.066161637e-003
	,1.111449700e-003
	,1.157566821e-003
	,1.204419135e-003
	,1.250497704e-003
	,1.297244974e-003
	,1.344652276e-003
	,1.392710116e-003
	,1.441408295e-003
	,1.490735632e-003
	,1.540679750e-003
	,1.591226854e-003
	,1.642361508e-003
	,1.694066410e-003
	,1.746322158e-003
	,1.799107017e-003
	,1.852396685e-003
	,1.906164053e-003
	,1.960378962e-003
	,2.015007958e-003
	,2.070071289e-003
	,2.125479373e-003
	,2.181162311e-003
	,2.237067710e-003
	,2.293132118e-003
	,2.349295820e-003
	,2.405496523e-003
	,2.461663094e-003
	,2.517719584e-003
	,2.573585292e-003
	,-8.735719182e-005
	,-7.842938317e-005
	,-6.995148954e-005
	,-6.201323772e-005
	,-5.463709539e-005
	,-4.787631247e-005
	,-4.172297441e-005
	,-3.607073575e-005
	,-3.088977152e-005
	,-2.621113681e-005
	,-2.205664406e-005
	,-1.846938588e-005
	,-1.543064400e-005
	,-1.284152321e-005
	,-1.058337544e-005
	,-8.618004921e-006
	,-6.943833485e-006
	,-5.554295645e-006
	,-4.433314432e-006
	,-3.540739738e-006
	,-2.830639749e-006
	,-2.260523603e-006
	,-1.794487418e-006
	,-1.411011230e-006
	,-1.099778463e-006
	,-8.502783437e-007
	,-6.528527001e-007
	,-4.991015942e-007
	,-3.809990942e-007
	,-2.908336217e-007
	,-2.219734160e-007
	,-1.691534010e-007
	,-1.283124520e-007
	,-9.641459978e-008
	,-7.137429810e-008
	,-5.172306376e-008
	,-3.630424675e-008
	,-2.414168856e-008
	,-1.442485239e-008
	,-6.527053727e-009
	,1.070418600e-017
	,5.481512140e-009
	,1.019407816e-008
	,1.436529043e-008
	,1.815495536e-008
	,2.168679479e-008
	,2.508261371e-008
	,2.844498926e-008
	,3.184144574e-008
	,3.533505460e-008
	,3.900765496e-008
	,4.294121583e-008
	,4.720786238e-008
	,5.187429019e-008
	,5.700560187e-008
	,6.266658086e-008
	,6.892038267e-008
	,7.582268910e-008
	,8.340814314e-008
	,9.167531730e-008
	,1.006112663e-007
	,1.102610448e-007
	,1.207276260e-007
	,1.321232887e-007
	,1.445500569e-007
	,1.580886103e-007
	,1.727779291e-007
	,1.885747994e-007
	,2.053257275e-007
	,2.228028890e-007
	,2.408621453e-007
	,2.595666737e-007
	,2.790510203e-007
	,2.993878612e-007
	,3.205833053e-007
	,3.426668858e-007
	,3.658028215e-007
	,3.902404090e-007
	,4.161970024e-007
	,4.438336547e-007
	,4.732981535e-007
	,5.047613551e-007
	,5.384145880e-007
	,5.744507821e-007
	,6.130541217e-007
	,6.543930334e-007
	,6.986065044e-007
	,7.457971778e-007
	,7.960866200e-007
	,8.497198027e-007
	,9.070595966e-007
	,9.684980662e-007
	,1.034414258e-006
	,1.105187803e-006
	,1.181244655e-006
	,1.263085128e-006
	,1.351272388e-006
	,1.446424033e-006
	,1.549220447e-006
	,1.660418695e-006
	,1.780866963e-006
	,1.911512633e-006
	,2.053394776e-006
	,2.207600217e-006
	,2.375157402e-006
	,2.556923891e-006
	,2.753790933e-006
	,2.967553297e-006
	,3.201514483e-006
	,3.460085694e-006
	,3.748622442e-006
	,4.073710660e-006
	,4.442773965e-006
	,4.863068725e-006
	,5.339030769e-006
	,5.867911350e-006
	,6.440840192e-006
	,7.063385827e-006
	,7.762475854e-006
	,8.570653107e-006
	,9.515653157e-006
	,1.062442107e-005
	,1.193178889e-005
	,1.347417618e-005
	,1.529442318e-005
	,1.744507784e-005
	,1.998400349e-005
	,2.297629107e-005
	,2.649273827e-005
	,3.060599333e-005
	,3.537799398e-005
	,4.087866448e-005
	,4.716017252e-005
	,5.422006229e-005
	,6.218380271e-005
	,7.113146107e-005
	,8.110575262e-005
	,9.209353197e-005
	,1.039726040e-004
	,1.163839662e-004
	,1.291392628e-004
	,1.421410614e-004
	,1.554431593e-004
	,1.696426225e-004
	,1.850222758e-004
	,2.016322668e-004
	,2.194653147e-004
	,2.385176114e-004
	,2.587793604e-004
	,2.802357629e-004
	,3.028717500e-004
	,3.266718118e-004
	,3.516199807e-004
	,3.776999937e-004
	,4.048954489e-004
	,4.326211094e-004
	,4.613180354e-004
	,4.909962476e-004
	,5.216373479e-004
	,5.532235735e-004
	,5.857379962e-004
	,6.191653552e-004
	,6.534911404e-004
	,6.887019841e-004
	,7.247849942e-004
	,7.617278872e-004
	,7.995211320e-004
	,8.381556969e-004
	,8.776245053e-004
	,9.179205344e-004
	,9.590375725e-004
	,1.000970102e-003
	,1.043713166e-003
	,1.087262225e-003
	,1.131612997e-003
	,1.176224279e-003
	,1.220018461e-003
	,1.264428024e-003
	,1.309445243e-003
	,1.355061910e-003
	,1.401269467e-003
	,1.448058803e-003
	,1.495420093e-003
	,1.543342636e-003
	,1.591814690e-003
	,1.640823296e-003
	,1.690354102e-003
	,1.740391181e-003
	,1.790916840e-003
	,1.841911584e-003
	,1.893493213e-003
	,1.945491839e-003
	,1.997878372e-003
	,2.050620915e-003
	,2.103684308e-003
	,2.157030278e-003
	,2.210617155e-003
	,2.264399706e-003
	,2.318324501e-003
	,2.372336973e-003
	,2.426385718e-003
	,-1.469480823e-004
	,-1.343288797e-004
	,-1.221516997e-004
	,-1.104801595e-004
	,-9.940476434e-005
	,-8.903978353e-005
	,-7.948227043e-005
	,-7.076476129e-005
	,-6.279143610e-005
	,-5.531777436e-005
	,-4.823011823e-005
	,-4.166127864e-005
	,-3.572111320e-005
	,-3.040315443e-005
	,-2.573064686e-005
	,-2.169223661e-005
	,-1.815171593e-005
	,-1.499607065e-005
	,-1.227576612e-005
	,-1.000943229e-005
	,-8.128180495e-006
	,-6.551787321e-006
	,-5.242918856e-006
	,-4.176712712e-006
	,-3.312164777e-006
	,-2.607661242e-006
	,-2.041328508e-006
	,-1.594655129e-006
	,-1.243546997e-006
	,-9.667506991e-007
	,-7.470706706e-007
	,-5.723738009e-007
	,-4.351479082e-007
	,-3.278588234e-007
	,-2.430963955e-007
	,-1.756070990e-007
	,-1.222108763e-007
	,-8.026774597e-008
	,-4.734349600e-008
	,-2.121289027e-008
	,4.469704253e-017
	,1.776589906e-008
	,3.318723891e-008
	,4.704570690e-008
	,5.989497707e-008
	,7.220738722e-008
	,8.441444763e-008
	,9.684191573e-008
	,1.097509221e-007
	,1.233207709e-007
	,1.376866973e-007
	,1.529114258e-007
	,1.690836963e-007
	,1.864985878e-007
	,2.055284079e-007
	,2.263817899e-007
	,2.489856648e-007
	,2.729508361e-007
	,2.977201930e-007
	,3.229578873e-007
	,3.486769405e-007
	,3.750984066e-007
	,4.026738741e-007
	,4.319681983e-007
	,4.634873999e-007
	,4.976442501e-007
	,5.347905598e-007
	,5.752610273e-007
	,6.193912114e-007
	,6.675159575e-007
	,7.199674163e-007
	,7.770620873e-007
	,8.390620610e-007
	,9.060947102e-007
	,9.780468473e-007
	,1.054622116e-006
	,1.135800718e-006
	,1.222164754e-006
	,1.314630905e-006
	,1.414107282e-006
	,1.521365627e-006
	,1.636992336e-006
	,1.761368293e-006
	,1.894751924e-006
	,2.037437799e-006
	,2.189802569e-006
	,2.352138950e-006
	,2.524338819e-006
	,2.705696319e-006
	,2.895231754e-006
	,3.092602511e-006
	,3.298541448e-006
	,3.514223398e-006
	,3.740506397e-006
	,3.977475559e-006
	,4.224049350e-006
	,4.477546863e-006
	,4.733588436e-006
	,4.987496304e-006
	,5.237549748e-006
	,5.486717659e-006
	,5.740471373e-006
	,6.003975081e-006
	,6.281121909e-006
	,6.574731558e-006
	,6.886949709e-006
	,7.219534504e-006
	,7.573990396e-006
	,7.951628788e-006
	,8.353725921e-006
	,8.782019196e-006
	,9.239384987e-006
	,9.729971835e-006
	,1.025908036e-005
	,1.083322630e-005
	,1.146050409e-005
	,1.215109992e-005
	,1.291784513e-005
	,1.377675877e-005
	,1.474752947e-005
	,1.585389146e-005
	,1.712386318e-005
	,1.858984291e-005
	,2.028868709e-005
	,2.226134887e-005
	,2.455540998e-005
	,2.722243975e-005
	,3.031134878e-005
	,3.385377042e-005
	,3.787367878e-005
	,4.245279456e-005
	,4.767141038e-005
	,5.359410615e-005
	,6.026099493e-005
	,6.766697129e-005
	,7.571134366e-005
	,8.414138286e-005
	,9.294153695e-005
	,1.020819444e-004
	,1.115892004e-004
	,1.218711778e-004
	,1.331009492e-004
	,1.453374144e-004
	,1.586019232e-004
	,1.729044014e-004
	,1.882507044e-004
	,2.046447134e-004
	,2.220889399e-004
	,2.405846671e-004
	,2.601320453e-004
	,2.807257399e-004
	,3.023700189e-004
	,3.250634899e-004
	,3.488020176e-004
	,3.735803957e-004
	,3.993925960e-004
	,4.262319257e-004
	,4.535433334e-004
	,4.815599775e-004
	,5.104789737e-004
	,5.402800768e-004
	,5.709631899e-004
	,6.025155466e-004
	,6.349254149e-004
	,6.681818415e-004
	,7.022745729e-004
	,7.371942681e-004
	,7.729325166e-004
	,8.094793100e-004
	,8.468301095e-004
	,8.849780187e-004
	,9.239174731e-004
	,9.636448940e-004
	,1.004156121e-003
	,1.045447350e-003
	,1.087515013e-003
	,1.129690800e-003
	,1.170570132e-003
	,1.212013090e-003
	,1.254024360e-003
	,1.296582853e-003
	,1.339681773e-003
	,1.383314173e-003
	,1.427472862e-003
	,1.472150299e-003
	,1.517338493e-003
	,1.563028885e-003
	,1.609212227e-003
	,1.655960383e-003
	,1.703305498e-003
	,1.751110596e-003
	,1.799360166e-003
	,1.848037217e-003
	,1.897123233e-003
	,1.946597926e-003
	,1.996439002e-003
	,2.046623404e-003
	,2.097143409e-003
	,2.147951978e-003
	,2.199017650e-003
	,2.250306284e-003
	,-2.205653701e-004
	,-2.062637720e-004
	,-1.923851256e-004
	,-1.786461868e-004
	,-1.650384248e-004
	,-1.517730193e-004
	,-1.390856222e-004
	,-1.270998317e-004
	,-1.157546362e-004
	,-1.048592293e-004
	,-9.413559946e-005
	,-8.358359981e-005
	,-7.357087802e-005
	,-6.444431073e-005
	,-5.634987500e-005
	,-4.926243867e-005
	,-4.297001563e-005
	,-3.715936040e-005
	,-3.166117153e-005
	,-2.654724343e-005
	,-2.200889345e-005
	,-1.815410125e-005
	,-1.494733881e-005
	,-1.228436345e-005
	,-1.004118273e-005
	,-8.130706329e-006
	,-6.539126882e-006
	,-5.227419420e-006
	,-4.129177694e-006
	,-3.219547661e-006
	,-2.489119767e-006
	,-1.915243831e-006
	,-1.466459573e-006
	,-1.110918822e-006
	,-8.275691830e-007
	,-6.041114176e-007
	,-4.281963098e-007
	,-2.879617113e-007
	,-1.737771031e-007
	,-7.909032484e-008
	,4.532363897e-017
	,6.713564470e-008
	,1.259888526e-007
	,1.792906794e-007
	,2.284159850e-007
	,2.740152520e-007
	,3.170603870e-007
	,3.587918745e-007
	,4.005798263e-007
	,4.440174789e-007
	,4.906102569e-007
	,5.412429192e-007
	,5.952219334e-007
	,6.516563089e-007
	,7.100912117e-007
	,7.718017182e-007
	,8.387171167e-007
	,9.118981669e-007
	,9.919055615e-007
	,1.079397461e-006
	,1.175250450e-006
	,1.280150911e-006
	,1.394311235e-006
	,1.517512866e-006
	,1.649851154e-006
	,1.792496966e-006
	,1.947072466e-006
	,2.114767139e-006
	,2.296250093e-006
	,2.491636710e-006
	,2.699969023e-006
	,2.918464588e-006
	,3.142468684e-006
	,3.367981410e-006
	,3.594770096e-006
	,3.825111537e-006
	,4.060471238e-006
	,4.300468654e-006
	,4.544297274e-006
	,4.792929262e-006
	,5.049669663e-006
	,5.318886645e-006
	,5.604322356e-006
	,5.908553841e-006
	,6.233310934e-006
	,6.579714829e-006
	,6.948335277e-006
	,7.339198449e-006
	,7.751989293e-006
	,8.186477346e-006
	,8.642645903e-006
	,9.120611194e-006
	,9.620941846e-006
	,1.014459575e-005
	,1.069214886e-005
	,1.126356903e-005
	,1.185897906e-005
	,1.247944189e-005
	,1.312679704e-005
	,1.380290745e-005
	,1.450917262e-005
	,1.524665129e-005
	,1.601653102e-005
	,1.682038712e-005
	,1.766013562e-005
	,1.853772338e-005
	,1.945480543e-005
	,2.041253437e-005
	,2.141135866e-005
	,2.245070597e-005
	,2.352863049e-005
	,2.464223180e-005
	,2.578934289e-005
	,2.697086153e-005
	,2.819108054e-005
	,2.945602670e-005
	,3.077203731e-005
	,3.214541463e-005
	,3.358263908e-005
	,3.509061573e-005
	,3.667784017e-005
	,3.835455141e-005
	,4.013248767e-005
	,4.202458829e-005
	,4.404394523e-005
	,4.620105640e-005
	,4.850150756e-005
	,5.094778475e-005
	,5.355521488e-005
	,5.635888530e-005
	,5.939696624e-005
	,6.269593602e-005
	,6.630563521e-005
	,7.032807261e-005
	,7.486964778e-005
	,8.001475055e-005
	,8.582691638e-005
	,9.235613921e-005
	,9.964356249e-005
	,1.077239008e-004
	,1.166260572e-004
	,1.263691152e-004
	,1.369790582e-004
	,1.484734786e-004
	,1.608668156e-004
	,1.741706326e-004
	,1.883938764e-004
	,2.035430249e-004
	,2.196225105e-004
	,2.366342333e-004
	,2.545774907e-004
	,2.734489436e-004
	,2.932502475e-004
	,3.139715056e-004
	,3.356029820e-004
	,3.581436046e-004
	,3.816121017e-004
	,4.059884069e-004
	,4.312807172e-004
	,4.574983703e-004
	,4.836715909e-004
	,5.106807067e-004
	,5.385279291e-004
	,5.672349690e-004
	,5.967713129e-004
	,6.271254792e-004
	,6.582888955e-004
	,6.902532009e-004
	,7.230101667e-004
	,7.565518385e-004
	,7.908707568e-004
	,8.259600762e-004
	,8.618119988e-004
	,8.984215477e-004
	,9.357847902e-004
	,9.738965440e-004
	,1.012752970e-003
	,1.052421351e-003
	,1.090737499e-003
	,1.128407052e-003
	,1.166553116e-003
	,1.205167414e-003
	,1.244242235e-003
	,1.283770263e-003
	,1.323744547e-003
	,1.364158519e-003
	,1.405006069e-003
	,1.446528543e-003
	,1.488734393e-003
	,1.531423970e-003
	,1.574421164e-003
	,1.617670103e-003
	,1.661109246e-003
	,1.704689921e-003
	,1.748412784e-003
	,1.792583699e-003
	,1.837110116e-003
	,1.881842277e-003
	,1.927020141e-003
	,1.972856821e-003
	,2.019432777e-003
	,-3.099821931e-004
	,-2.938285158e-004
	,-2.780269963e-004
	,-2.624894191e-004
	,-2.471401700e-004
	,-2.319561694e-004
	,-2.169409176e-004
	,-2.020694881e-004
	,-1.873023979e-004
	,-1.727630516e-004
	,-1.586328015e-004
	,-1.450810680e-004
	,-1.321375106e-004
	,-1.198135810e-004
	,-1.081472122e-004
	,-9.710263525e-005
	,-8.669838510e-005
	,-7.705416859e-005
	,-6.830524368e-005
	,-6.048362945e-005
	,-5.337499746e-005
	,-4.665295060e-005
	,-4.022817244e-005
	,-3.418259333e-005
	,-2.863487497e-005
	,-2.366248016e-005
	,-1.936553051e-005
	,-1.577439935e-005
	,-1.282850431e-005
	,-1.040972093e-005
	,-8.385536376e-006
	,-6.691963481e-006
	,-5.286194939e-006
	,-4.104279898e-006
	,-3.116816044e-006
	,-2.305426930e-006
	,-1.643571087e-006
	,-1.105189478e-006
	,-6.648188282e-007
	,-3.026595083e-007
	,1.780561225e-017
	,2.585614297e-007
	,4.841133852e-007
	,6.857169577e-007
	,8.715964367e-007
	,1.049693319e-006
	,1.224848494e-006
	,1.398880132e-006
	,1.575381545e-006
	,1.761262236e-006
	,1.963083437e-006
	,2.184478336e-006
	,2.425008686e-006
	,2.681106948e-006
	,2.946782314e-006
	,3.217999718e-006
	,3.495935400e-006
	,3.781683619e-006
	,4.070901098e-006
	,4.349840897e-006
	,4.627108407e-006
	,4.917051717e-006
	,5.224319080e-006
	,5.553318668e-006
	,5.909019177e-006
	,6.295117680e-006
	,6.713425694e-006
	,7.163803280e-006
	,7.645239214e-006
	,8.158400508e-006
	,8.705691697e-006
	,9.288642918e-006
	,9.906800017e-006
	,1.055860277e-005
	,1.124401446e-005
	,1.196549838e-005
	,1.272570545e-005
	,1.352592960e-005
	,1.436642043e-005
	,1.524680744e-005
	,1.616673098e-005
	,1.712657300e-005
	,1.812677628e-005
	,1.916605642e-005
	,2.023959509e-005
	,2.133862774e-005
	,2.245432462e-005
	,2.358043796e-005
	,2.471799932e-005
	,2.587643629e-005
	,2.706799976e-005
	,2.830288634e-005
	,2.958787963e-005
	,3.092678747e-005
	,3.232085643e-005
	,3.376804221e-005
	,3.526137247e-005
	,3.678794821e-005
	,3.833021170e-005
	,3.987014219e-005
	,4.139398716e-005
	,4.289309060e-005
	,4.436083042e-005
	,4.579095364e-005
	,4.718042142e-005
	,4.853351679e-005
	,4.986257978e-005
	,5.118363078e-005
	,5.251032213e-005
	,5.385170161e-005
	,5.521357768e-005
	,5.660089603e-005
	,5.801864350e-005
	,5.947112483e-005
	,6.096128123e-005
	,6.249089894e-005
	,6.406172758e-005
	,6.567584142e-005
	,6.733563678e-005
	,6.904357058e-005
	,7.080205028e-005
	,7.261362570e-005
	,7.448127408e-005
	,7.640861273e-005
	,7.839998383e-005
	,8.045998689e-005
	,8.259318996e-005
	,8.480971442e-005
	,8.712196103e-005
	,8.954457420e-005
	,9.209595370e-005
	,9.479916110e-005
	,9.768268483e-005
	,1.007810389e-004
	,1.041349924e-004
	,1.077912981e-004
	,1.118016407e-004
	,1.162206698e-004
	,1.211031683e-004
	,1.265009926e-004
	,1.324621270e-004
	,1.390410991e-004
	,1.462777776e-004
	,1.542198193e-004
	,1.629115771e-004
	,1.723900627e-004
	,1.826838032e-004
	,1.938135323e-004
	,2.057934184e-004
	,2.186322115e-004
	,2.323341622e-004
	,2.468996774e-004
	,2.623257567e-004
	,2.786061820e-004
	,2.957316204e-004
	,3.136897611e-004
	,3.324698603e-004
	,3.520505564e-004
	,3.724179012e-004
	,3.937352853e-004
	,4.158446888e-004
	,4.387498359e-004
	,4.624816230e-004
	,4.867004767e-004
	,5.110092884e-004
	,5.361208110e-004
	,5.620302307e-004
	,5.887281158e-004
	,6.162015381e-004
	,6.444349635e-004
	,6.734109802e-004
	,7.031118239e-004
	,7.335224500e-004
	,7.648875346e-004
	,7.969244959e-004
	,8.295737367e-004
	,8.628251340e-004
	,8.966890680e-004
	,9.311907158e-004
	,9.663653078e-004
	,1.002266048e-003
	,1.035802487e-003
	,1.069161983e-003
	,1.103212581e-003
	,1.137769754e-003
	,1.173014617e-003
	,1.209024360e-003
	,1.245489232e-003
	,1.282420941e-003
	,1.319853450e-003
	,1.357826849e-003
	,1.396376384e-003
	,1.435522633e-003
	,1.475272335e-003
	,1.515622903e-003
	,1.556566573e-003
	,1.598093086e-003
	,1.640191179e-003
	,1.682849251e-003
	,1.726055308e-003
	,1.769797309e-003
	,-4.047517361e-004
	,-3.861536863e-004
	,-3.677528530e-004
	,-3.497129871e-004
	,-3.320637053e-004
	,-3.148458340e-004
	,-2.981623915e-004
	,-2.821569572e-004
	,-2.669625583e-004
	,-2.526094456e-004
	,-2.388354777e-004
	,-2.250044653e-004
	,-2.107087522e-004
	,-1.961476302e-004
	,-1.816755926e-004
	,-1.675141339e-004
	,-1.537684575e-004
	,-1.405239917e-004
	,-1.279293699e-004
	,-1.161492712e-004
	,-1.051919862e-004
	,-9.480488417e-005
	,-8.458090457e-005
	,-7.457920694e-005
	,-6.523429625e-005
	,-5.678763515e-005
	,-4.918602881e-005
	,-4.222812371e-005
	,-3.593469944e-005
	,-3.038122253e-005
	,-2.548925546e-005
	,-2.109040936e-005
	,-1.706096970e-005
	,-1.351689674e-005
	,-1.054214507e-005
	,-8.060270216e-006
	,-5.958797539e-006
	,-4.158097307e-006
	,-2.601062845e-006
	,-1.232721973e-006
	,2.093859442e-017
	,1.123495951e-006
	,2.121812298e-006
	,2.965049278e-006
	,3.693210957e-006
	,4.371847036e-006
	,5.044653891e-006
	,5.741220593e-006
	,6.484112519e-006
	,7.287163615e-006
	,8.145694821e-006
	,9.028318122e-006
	,9.904051680e-006
	,1.077606217e-005
	,1.166230440e-005
	,1.256788019e-005
	,1.349709823e-005
	,1.446806588e-005
	,1.550061428e-005
	,1.661161847e-005
	,1.781132831e-005
	,1.909896917e-005
	,2.045867675e-005
	,2.185095061e-005
	,2.323196385e-005
	,2.459956443e-005
	,2.594541365e-005
	,2.731516447e-005
	,2.872584913e-005
	,3.016762742e-005
	,3.163156876e-005
	,3.311238996e-005
	,3.460542879e-005
	,3.610880532e-005
	,3.762181199e-005
	,3.914244017e-005
	,4.066771165e-005
	,4.219667308e-005
	,4.373423979e-005
	,4.529150333e-005
	,4.688100410e-005
	,4.851358324e-005
	,5.019925149e-005
	,5.194549145e-005
	,5.375509305e-005
	,5.562616142e-005
	,5.755289948e-005
	,5.952723352e-005
	,6.154038622e-005
	,6.358284426e-005
	,6.565380754e-005
	,6.775996644e-005
	,6.990221025e-005
	,7.207751153e-005
	,7.428240103e-005
	,7.651380588e-005
	,7.876791006e-005
	,8.103909061e-005
	,8.332028409e-005
	,8.560484160e-005
	,8.788913212e-005
	,9.017463018e-005
	,9.246826136e-005
	,9.478078647e-005
	,9.712431464e-005
	,9.951012823e-005
	,1.019472601e-004
	,1.044417932e-004
	,1.069964851e-004
	,1.096103805e-004
	,1.122811621e-004
	,1.150091455e-004
	,1.177937684e-004
	,1.206316937e-004
	,1.235177121e-004
	,1.264457312e-004
	,1.294098580e-004
	,1.324052160e-004
	,1.354279200e-004
	,1.384744161e-004
	,1.415410190e-004
	,1.446227957e-004
	,1.477127175e-004
	,1.508019205e-004
	,1.538807398e-004
	,1.569398845e-004
	,1.599709641e-004
	,1.629660608e-004
	,1.659172168e-004
	,1.688170483e-004
	,1.716605632e-004
	,1.744447946e-004
	,1.771714407e-004
	,1.798647532e-004
	,1.825495357e-004
	,1.852493185e-004
	,1.879883634e-004
	,1.907920661e-004
	,1.936870680e-004
	,1.967018535e-004
	,1.998675506e-004
	,2.032189204e-004
	,2.067952085e-004
	,2.106405825e-004
	,2.148039703e-004
	,2.193385706e-004
	,2.243008836e-004
	,2.297490156e-004
	,2.357406010e-004
	,2.423306001e-004
	,2.495690393e-004
	,2.574990181e-004
	,2.661551701e-004
	,2.755627586e-004
	,2.857376445e-004
	,2.966875012e-004
	,3.084548731e-004
	,3.210189109e-004
	,3.343767739e-004
	,3.485400523e-004
	,3.635272718e-004
	,3.793606409e-004
	,3.960623578e-004
	,4.136523170e-004
	,4.321473951e-004
	,4.515616102e-004
	,4.719069225e-004
	,4.931940896e-004
	,5.149402273e-004
	,5.369006485e-004
	,5.597164620e-004
	,5.833710218e-004
	,6.078475532e-004
	,6.331302611e-004
	,6.593384543e-004
	,6.865625069e-004
	,7.145863140e-004
	,7.434071509e-004
	,7.730361802e-004
	,8.034898710e-004
	,8.347842051e-004
	,8.669312641e-004
	,8.999380160e-004
	,9.338067566e-004
	,9.685363475e-004
	,1.002223804e-003
	,1.034277047e-003
	,1.066916084e-003
	,1.100133534e-003
	,1.133921086e-003
	,1.168269917e-003
	,1.203173721e-003
	,1.238624954e-003
	,1.274616252e-003
	,1.311140445e-003
	,1.348196507e-003
	,1.385795082e-003
	,1.423908696e-003
	,1.462530909e-003
	,1.501655100e-003
	,1.541274521e-003
	,-4.968582752e-004
	,-4.775430832e-004
	,-4.583451688e-004
	,-4.393519495e-004
	,-4.206443849e-004
	,-4.022836409e-004
	,-3.843281563e-004
	,-3.668482265e-004
	,-3.498907434e-004
	,-3.334097821e-004
	,-3.172721177e-004
	,-3.014755448e-004
	,-2.859491115e-004
	,-2.705413135e-004
	,-2.551011431e-004
	,-2.396159677e-004
	,-2.242444817e-004
	,-2.091809102e-004
	,-1.945743528e-004
	,-1.805137367e-004
	,-1.670175619e-004
	,-1.540435075e-004
	,-1.415499387e-004
	,-1.295613262e-004
	,-1.181900331e-004
	,-1.075520609e-004
	,-9.767288218e-005
	,-8.846420395e-005
	,-7.969484877e-005
	,-7.098043179e-005
	,-6.207945897e-005
	,-5.312400837e-005
	,-4.451003689e-005
	,-3.647455731e-005
	,-2.914827082e-005
	,-2.265484842e-005
	,-1.698166406e-005
	,-1.201184279e-005
	,-7.605742573e-006
	,-3.638480466e-006
	,-1.091339097e-017
	,3.414477552e-006
	,6.693011234e-006
	,9.885068678e-006
	,1.300384366e-005
	,1.607693150e-005
	,1.907690163e-005
	,2.190330748e-005
	,2.464782915e-005
	,2.740508018e-005
	,3.019189318e-005
	,3.300567954e-005
	,3.583904834e-005
	,3.867670742e-005
	,4.154538401e-005
	,4.448482721e-005
	,4.745385710e-005
	,5.037261969e-005
	,5.319806812e-005
	,5.592621134e-005
	,5.866133906e-005
	,6.152435981e-005
	,6.456169776e-005
	,6.777561869e-005
	,7.114550808e-005
	,7.462042383e-005
	,7.807753755e-005
	,8.133114445e-005
	,8.435333131e-005
	,8.726552680e-005
	,9.007992907e-005
	,9.271438441e-005
	,9.511282258e-005
	,9.747245333e-005
	,9.986167284e-005
	,1.022901773e-004
	,1.047732629e-004
	,1.073345982e-004
	,1.099878320e-004
	,1.127312475e-004
	,1.155571538e-004
	,1.184585195e-004
	,1.214348319e-004
	,1.244878656e-004
	,1.276074493e-004
	,1.307630006e-004
	,1.339063025e-004
	,1.369876831e-004
	,1.399767946e-004
	,1.428711803e-004
	,1.456880488e-004
	,1.484483877e-004
	,1.511619639e-004
	,1.538326670e-004
	,1.564980706e-004
	,1.591997364e-004
	,1.619581673e-004
	,1.647819835e-004
	,1.676737687e-004
	,1.706318784e-004
	,1.736505963e-004
	,1.767202741e-004
	,1.798288986e-004
	,1.829648893e-004
	,1.861184526e-004
	,1.892801536e-004
	,1.924387933e-004
	,1.955811480e-004
	,1.986944751e-004
	,2.017696840e-004
	,2.048013859e-004
	,2.077851159e-004
	,2.107154948e-004
	,2.135870406e-004
	,2.164016731e-004
	,2.191709373e-004
	,2.219061369e-004
	,2.246175694e-004
	,2.273159215e-004
	,2.300119630e-004
	,2.327161562e-004
	,2.354381949e-004
	,2.381862403e-004
	,2.409671514e-004
	,2.437877600e-004
	,2.466542050e-004
	,2.495710942e-004
	,2.525416716e-004
	,2.555681836e-004
	,2.586521634e-004
	,2.617946270e-004
	,2.649962003e-004
	,2.682571936e-004
	,2.715776254e-004
	,2.749571326e-004
	,2.783944005e-004
	,2.818834185e-004
	,2.853984358e-004
	,2.889335691e-004
	,2.925100554e-004
	,2.961312054e-004
	,2.997958703e-004
	,3.035027611e-004
	,3.072513816e-004
	,3.110423677e-004
	,3.148778546e-004
	,3.187623472e-004
	,3.227030691e-004
	,3.267112573e-004
	,3.308030218e-004
	,3.350000686e-004
	,3.393306587e-004
	,3.438288096e-004
	,3.485365917e-004
	,3.535048067e-004
	,3.587941287e-004
	,3.644649691e-004
	,3.705845699e-004
	,3.772247348e-004
	,3.844513777e-004
	,3.923341447e-004
	,4.009304391e-004
	,4.102893404e-004
	,4.204533586e-004
	,4.314579660e-004
	,4.433325136e-004
	,4.561012839e-004
	,4.697847927e-004
	,4.844009452e-004
	,4.999660383e-004
	,5.164956101e-004
	,5.340051883e-004
	,5.525111887e-004
	,5.720329525e-004
	,5.916227343e-004
	,6.119312636e-004
	,6.331875793e-004
	,6.553870804e-004
	,6.785256377e-004
	,7.025995678e-004
	,7.276053746e-004
	,7.535572890e-004
	,7.804689149e-004
	,8.082992238e-004
	,8.370424639e-004
	,8.666922508e-004
	,8.972417765e-004
	,9.286834896e-004
	,9.610092108e-004
	,9.942101623e-004
	,1.028061213e-003
	,1.058637278e-003
	,1.089790216e-003
	,1.121509579e-003
	,1.153787056e-003
	,1.186612320e-003
	,1.219974599e-003
	,1.253862913e-003
	,1.288385159e-003
	,1.323458508e-003
	,1.359061028e-003
	,-5.812555915e-004
	,-5.619572788e-004
	,-5.425661849e-004
	,-5.231206400e-004
	,-5.037607495e-004
	,-4.846107872e-004
	,-4.657479894e-004
	,-4.471841828e-004
	,-4.288823602e-004
	,-4.108236795e-004
	,-3.930229033e-004
	,-3.755302363e-004
	,-3.584327218e-004
	,-3.417371215e-004
	,-3.252785243e-004
	,-3.088189746e-004
	,-2.922639778e-004
	,-2.756472049e-004
	,-2.590448868e-004
	,-2.425226165e-004
	,-2.261195249e-004
	,-2.099561912e-004
	,-1.942579206e-004
	,-1.791689968e-004
	,-1.647756874e-004
	,-1.511154224e-004
	,-1.381839233e-004
	,-1.259651432e-004
	,-1.144524553e-004
	,-1.036242756e-004
	,-9.338494800e-005
	,-8.344436781e-005
	,-7.327282059e-005
	,-6.273360505e-005
	,-5.223127453e-005
	,-4.212987261e-005
	,-3.266344108e-005
	,-2.382045044e-005
	,-1.548738621e-005
	,-7.560279823e-006
	,-1.791038448e-017
	,7.183250451e-006
	,1.400256830e-005
	,2.049252328e-005
	,2.671760879e-005
	,3.274783822e-005
	,3.861220198e-005
	,4.437089659e-005
	,4.994708586e-005
	,5.501140725e-005
	,5.966101303e-005
	,6.422630493e-005
	,6.882781839e-005
	,7.349556360e-005
	,7.822458665e-005
	,8.299930005e-005
	,8.778919701e-005
	,9.253669000e-005
	,9.725549212e-005
	,1.020083079e-004
	,1.068196729e-004
	,1.116866279e-004
	,1.165938545e-004
	,1.215211721e-004
	,1.264505791e-004
	,1.313750623e-004
	,1.362995407e-004
	,1.412245093e-004
	,1.461206413e-004
	,1.508853254e-004
	,1.553129380e-004
	,1.593906599e-004
	,1.633459699e-004
	,1.672779376e-004
	,1.711567433e-004
	,1.748751421e-004
	,1.782932675e-004
	,1.812786119e-004
	,1.841672756e-004
	,1.870696860e-004
	,1.899850122e-004
	,1.929148056e-004
	,1.958687736e-004
	,1.988507025e-004
	,2.018534063e-004
	,2.048640091e-004
	,2.078711029e-004
	,2.108694551e-004
	,2.138592019e-004
	,2.168419329e-004
	,2.198195558e-004
	,2.227977696e-004
	,2.257822914e-004
	,2.287732633e-004
	,2.317741626e-004
	,2.347735915e-004
	,2.377349297e-004
	,2.406627540e-004
	,2.436016271e-004
	,2.465731145e-004
	,2.495826854e-004
	,2.526304750e-004
	,2.557151523e-004
	,2.588349817e-004
	,2.619877565e-004
	,2.651710151e-004
	,2.683823286e-004
	,2.716191360e-004
	,2.748781893e-004
	,2.781553386e-004
	,2.814457008e-004
	,2.847440231e-004
	,2.880452723e-004
	,2.913453569e-004
	,2.946414606e-004
	,2.979311808e-004
	,3.012101013e-004
	,3.044738425e-004
	,3.077319692e-004
	,3.110011454e-004
	,3.142916847e-004
	,3.176086372e-004
	,3.209545192e-004
	,3.243309814e-004
	,3.277393984e-004
	,3.311800546e-004
	,3.346514229e-004
	,3.381523085e-004
	,3.416837234e-004
	,3.452466970e-004
	,3.488410339e-004
	,3.524656593e-004
	,3.561190411e-004
	,3.597992477e-004
	,3.635036926e-004
	,3.672288706e-004
	,3.709701114e-004
	,3.747212542e-004
	,3.784742423e-004
	,3.822187292e-004
	,3.859417852e-004
	,3.896268807e-004
	,3.932434365e-004
	,3.967506653e-004
	,4.001863903e-004
	,4.035904942e-004
	,4.069924796e-004
	,4.104183323e-004
	,4.138881399e-004
	,4.174165753e-004
	,4.210151000e-004
	,4.246937506e-004
	,4.284622817e-004
	,4.323312678e-004
	,4.363132520e-004
	,4.404237998e-004
	,4.446824052e-004
	,4.491132485e-004
	,4.537457896e-004
	,4.586151455e-004
	,4.637621776e-004
	,4.692332080e-004
	,4.750793106e-004
	,4.813551697e-004
	,4.881175719e-004
	,4.954236654e-004
	,5.033291498e-004
	,5.118866482e-004
	,5.211443727e-004
	,5.311452204e-004
	,5.419262930e-004
	,5.535187916e-004
	,5.659481574e-004
	,5.792342908e-004
	,5.933916406e-004
	,6.084293450e-004
	,6.243495378e-004
	,6.411468791e-004
	,6.588197621e-004
	,6.773750956e-004
	,6.956490643e-004
	,7.147133008e-004
	,7.345572198e-004
	,7.551697122e-004
	,7.765938000e-004
	,7.988372922e-004
	,8.219653502e-004
	,8.460124578e-004
	,8.710070501e-004
	,8.969737539e-004
	,9.239168901e-004
	,9.518000300e-004
	,9.804975119e-004
	,1.009756227e-003
	,1.039575373e-003
	,1.070271196e-003
	,1.101059183e-003
	,1.129149934e-003
	,1.157772203e-003
	,1.186938673e-003
	,1.216652265e-003
	,-6.346484169e-004
	,-6.166670938e-004
	,-5.987172577e-004
	,-5.806924526e-004
	,-5.626116898e-004
	,-5.445303188e-004
	,-5.264501734e-004
	,-5.083878309e-004
	,-4.903948847e-004
	,-4.725103444e-004
	,-4.547299925e-004
	,-4.370217051e-004
	,-4.193401834e-004
	,-4.015472695e-004
	,-3.834303289e-004
	,-3.648622270e-004
	,-3.459591395e-004
	,-3.269908591e-004
	,-3.082026910e-004
	,-2.897460344e-004
	,-2.717021514e-004
	,-2.541222659e-004
	,-2.370379743e-004
	,-2.204628053e-004
	,-2.044034980e-004
	,-1.888804229e-004
	,-1.739252600e-004
	,-1.595516411e-004
	,-1.457321625e-004
	,-1.323476488e-004
	,-1.191362823e-004
	,-1.058603196e-004
	,-9.246065413e-005
	,-7.919141105e-005
	,-6.638674596e-005
	,-5.417716003e-005
	,-4.250208319e-005
	,-3.121223084e-005
	,-2.033753666e-005
	,-9.949993792e-006
	,6.787958285e-018
	,9.580229075e-006
	,1.884268942e-005
	,2.785335138e-005
	,3.669103480e-005
	,4.542393151e-005
	,5.409584049e-005
	,6.271347122e-005
	,7.119364391e-005
	,7.927139349e-005
	,8.680849863e-005
	,9.402954233e-005
	,1.010599935e-004
	,1.078700212e-004
	,1.143846816e-004
	,1.205592416e-004
	,1.263777061e-004
	,1.319732915e-004
	,1.375579045e-004
	,1.432385972e-004
	,1.490431945e-004
	,1.549707072e-004
	,1.610109844e-004
	,1.671503905e-004
	,1.733724746e-004
	,1.796563283e-004
	,1.859736052e-004
	,1.922858098e-004
	,1.985453170e-004
	,2.047120977e-004
	,2.107214430e-004
	,2.163781608e-004
	,2.213794410e-004
	,2.257917915e-004
	,2.300316718e-004
	,2.342992875e-004
	,2.386263317e-004
	,2.429955155e-004
	,2.473740519e-004
	,2.517152217e-004
	,2.558993434e-004
	,2.595414697e-004
	,2.627890376e-004
	,2.660657732e-004
	,2.694045090e-004
	,2.727785974e-004
	,2.761670749e-004
	,2.795593688e-004
	,2.829529084e-004
	,2.863479931e-004
	,2.897441510e-004
	,2.931384707e-004
	,2.965226197e-004
	,2.998755892e-004
	,3.031697183e-004
	,3.064178916e-004
	,3.096520550e-004
	,3.128777426e-004
	,3.160684549e-004
	,3.191635796e-004
	,3.221581082e-004
	,3.251281360e-004
	,3.281143166e-004
	,3.311253459e-004
	,3.341609745e-004
	,3.372192182e-004
	,3.402980824e-004
	,3.433954625e-004
	,3.465092922e-004
	,3.496399563e-004
	,3.527876015e-004
	,3.559518765e-004
	,3.591321562e-004
	,3.623267535e-004
	,3.655324990e-004
	,3.687503645e-004
	,3.719828520e-004
	,3.752282284e-004
	,3.784812043e-004
	,3.817311071e-004
	,3.849602352e-004
	,3.881622981e-004
	,3.913523455e-004
	,3.945414849e-004
	,3.977322607e-004
	,4.009235186e-004
	,4.041128636e-004
	,4.072976142e-004
	,4.104748017e-004
	,4.136406683e-004
	,4.167919140e-004
	,4.199301038e-004
	,4.230611184e-004
	,4.261905341e-004
	,4.293226228e-004
	,4.324609668e-004
	,4.356089081e-004
	,4.387697256e-004
	,4.419464412e-004
	,4.451411184e-004
	,4.483544619e-004
	,4.515865333e-004
	,4.548375877e-004
	,4.581083229e-004
	,4.613998084e-004
	,4.647132235e-004
	,4.680489337e-004
	,4.714018133e-004
	,4.747365599e-004
	,4.780180450e-004
	,4.812976184e-004
	,4.845956703e-004
	,4.879152083e-004
	,4.912567065e-004
	,4.946202107e-004
	,4.980062150e-004
	,5.014161875e-004
	,5.048527430e-004
	,5.083198142e-004
	,5.118229363e-004
	,5.153696827e-004
	,5.189700295e-004
	,5.226368305e-004
	,5.263861967e-004
	,5.302378432e-004
	,5.342157537e-004
	,5.383490116e-004
	,5.426723085e-004
	,5.472260877e-004
	,5.520563552e-004
	,5.572141592e-004
	,5.627548026e-004
	,5.687363742e-004
	,5.752181334e-004
	,5.822590803e-004
	,5.899163825e-004
	,5.982442197e-004
	,6.072930394e-004
	,6.171085206e-004
	,6.277312214e-004
	,6.391967814e-004
	,6.515371970e-004
	,6.647818669e-004
	,6.789582814e-004
	,6.940927380e-004
	,7.102104231e-004
	,7.269027916e-004
	,7.438331805e-004
	,7.617114446e-004
	,7.805381560e-004
	,8.003120104e-004
	,8.210320554e-004
	,8.426984383e-004
	,8.653093744e-004
	,8.888608555e-004
	,9.133481624e-004
	,9.387667848e-004
	,9.651107005e-004
	,9.923748709e-004
	,1.020553688e-003
	,1.049641167e-003
	,-6.721754927e-004
	,-6.542431285e-004
	,-6.364423558e-004
	,-6.187829700e-004
	,-6.012241173e-004
	,-5.836985479e-004
	,-5.662310467e-004
	,-5.489173546e-004
	,-5.318178040e-004
	,-5.148719590e-004
	,-4.979060557e-004
	,-4.806413208e-004
	,-4.628307666e-004
	,-4.443543980e-004
	,-4.252519821e-004
	,-4.057861387e-004
	,-3.862508420e-004
	,-3.668009071e-004
	,-3.474496258e-004
	,-3.282059285e-004
	,-3.091612619e-004
	,-2.904033641e-004
	,-2.720023973e-004
	,-2.540228425e-004
	,-2.365014471e-004
	,-2.194362334e-004
	,-2.027890757e-004
	,-1.864937200e-004
	,-1.704570142e-004
	,-1.545520243e-004
	,-1.386427145e-004
	,-1.227942917e-004
	,-1.072692077e-004
	,-9.226490136e-005
	,-7.784497192e-005
	,-6.398337394e-005
	,-5.059515420e-005
	,-3.754034195e-005
	,-2.467505781e-005
	,-1.209873000e-005
	,8.563314846e-018
	,1.160551811e-005
	,2.278655807e-005
	,3.363329765e-005
	,4.423428991e-005
	,5.466203641e-005
	,6.495085946e-005
	,7.504034117e-005
	,8.470568046e-005
	,9.383712791e-005
	,1.026489526e-004
	,1.112847649e-004
	,1.197883307e-004
	,1.281790400e-004
	,1.364616506e-004
	,1.446269255e-004
	,1.526623280e-004
	,1.605757380e-004
	,1.684000994e-004
	,1.761700975e-004
	,1.839069545e-004
	,1.916168946e-004
	,1.992918239e-004
	,2.069078837e-004
	,2.144234298e-004
	,2.217874866e-004
	,2.289837184e-004
	,2.360744706e-004
	,2.431434803e-004
	,2.502178581e-004
	,2.572416644e-004
	,2.640896736e-004
	,2.707059046e-004
	,2.771688974e-004
	,2.835507885e-004
	,2.898730641e-004
	,2.961272216e-004
	,3.022895615e-004
	,3.083309495e-004
	,3.142264302e-004
	,3.199598250e-004
	,3.255079999e-004
	,3.308151864e-004
	,3.358507488e-004
	,3.403936917e-004
	,3.439677757e-004
	,3.471660153e-004
	,3.504050242e-004
	,3.537164274e-004
	,3.570887956e-004
	,3.605074551e-004
	,3.639598495e-004
	,3.674363681e-004
	,3.709303290e-004
	,3.744378189e-004
	,3.779569195e-004
	,3.814863399e-004
	,3.850240116e-004
	,3.885652788e-004
	,3.920988523e-004
	,3.955975368e-004
	,3.990138057e-004
	,4.023282816e-004
	,4.055796100e-004
	,4.088032511e-004
	,4.120143780e-004
	,4.152187144e-004
	,4.184184547e-004
	,4.216143765e-004
	,4.248065899e-004
	,4.279946949e-004
	,4.311774626e-004
	,4.343517718e-004
	,4.375113951e-004
	,4.406535497e-004
	,4.437899238e-004
	,4.469333793e-004
	,4.500892972e-004
	,4.532592274e-004
	,4.564434102e-004
	,4.596413548e-004
	,4.628509444e-004
	,4.660653439e-004
	,4.692697429e-004
	,4.724523239e-004
	,4.756234201e-004
	,4.787993957e-004
	,4.819874403e-004
	,4.851898902e-004
	,4.884071576e-004
	,4.916382711e-004
	,4.948800027e-004
	,4.981248241e-004
	,5.013610922e-004
	,5.045844447e-004
	,5.078060276e-004
	,5.110377898e-004
	,5.142843187e-004
	,5.175471798e-004
	,5.208273565e-004
	,5.241260619e-004
	,5.274450372e-004
	,5.307856805e-004
	,5.341476999e-004
	,5.375299744e-004
	,5.409319808e-004
	,5.443539920e-004
	,5.477968629e-004
	,5.512618810e-004
	,5.547506574e-004
	,5.582648814e-004
	,5.618054205e-004
	,5.653684474e-004
	,5.689235205e-004
	,5.723803112e-004
	,5.757815090e-004
	,5.791959285e-004
	,5.826352132e-004
	,5.861005848e-004
	,5.895918148e-004
	,5.931078185e-004
	,5.966476725e-004
	,6.002114176e-004
	,6.037999816e-004
	,6.074151117e-004
	,6.110594646e-004
	,6.147368052e-004
	,6.184522923e-004
	,6.222128399e-004
	,6.260275713e-004
	,6.299083671e-004
	,6.338704903e-004
	,6.379331756e-004
	,6.421198749e-004
	,6.464582290e-004
	,6.509804733e-004
	,6.557242727e-004
	,6.607332887e-004
	,6.660569837e-004
	,6.717497162e-004
	,6.778697080e-004
	,6.844776986e-004
	,6.916350544e-004
	,6.994017753e-004
	,7.078357104e-004
	,7.169913015e-004
	,7.269189942e-004
	,7.376651405e-004
	,7.492724901e-004
	,7.617809689e-004
	,7.752260206e-004
	,7.896417044e-004
	,8.047464544e-004
	,8.199752517e-004
	,8.361592827e-004
	,8.533098945e-004
	,8.714310749e-004
	,8.905250636e-004
	,9.105933211e-004
	,9.316366541e-004
	,9.536554544e-004
	,-7.081183489e-004
	,-6.898004276e-004
	,-6.714884308e-004
	,-6.531532028e-004
	,-6.347686610e-004
	,-6.164339247e-004
	,-5.983022570e-004
	,-5.804477280e-004
	,-5.627941049e-004
	,-5.451717436e-004
	,-5.273362786e-004
	,-5.090802017e-004
	,-4.903446595e-004
	,-4.712100342e-004
	,-4.518850576e-004
	,-4.325604134e-004
	,-4.132855140e-004
	,-3.940514406e-004
	,-3.748988828e-004
	,-3.558849713e-004
	,-3.370562061e-004
	,-3.184431402e-004
	,-3.000388262e-004
	,-2.817809857e-004
	,-2.635454097e-004
	,-2.452635468e-004
	,-2.269848619e-004
	,-2.087430698e-004
	,-1.905042589e-004
	,-1.723221094e-004
	,-1.543988178e-004
	,-1.369261248e-004
	,-1.199985411e-004
	,-1.036341109e-004
	,-8.780416002e-005
	,-7.244729907e-005
	,-5.747338550e-005
	,-4.276411610e-005
	,-2.821338877e-005
	,-1.390080505e-005
	,-2.349906376e-018
	,1.344471424e-005
	,2.646665780e-005
	,3.912110247e-005
	,5.145462686e-005
	,6.346254269e-005
	,7.506388221e-005
	,8.609443734e-005
	,9.651854475e-005
	,1.065425815e-004
	,1.163373425e-004
	,1.259948085e-004
	,1.355676149e-004
	,1.450877064e-004
	,1.545740596e-004
	,1.640361304e-004
	,1.734754314e-004
	,1.828864082e-004
	,1.922574014e-004
	,2.015718601e-004
	,2.108089060e-004
	,2.199430011e-004
	,2.289460100e-004
	,2.377955003e-004
	,2.464832616e-004
	,2.550123475e-004
	,2.633899853e-004
	,2.716258812e-004
	,2.797217871e-004
	,2.876524430e-004
	,2.953849125e-004
	,3.029390272e-004
	,3.103625070e-004
	,3.176803646e-004
	,3.248961805e-004
	,3.320099228e-004
	,3.390362638e-004
	,3.460061846e-004
	,3.529502236e-004
	,3.598875776e-004
	,3.668262393e-004
	,3.737657266e-004
	,3.806983319e-004
	,3.876077142e-004
	,3.944615699e-004
	,4.011819348e-004
	,4.075004747e-004
	,4.126293589e-004
	,4.169076350e-004
	,4.212941474e-004
	,4.258493090e-004
	,4.305051990e-004
	,4.352089992e-004
	,4.399223414e-004
	,4.446097410e-004
	,4.492190735e-004
	,4.536935575e-004
	,4.580619177e-004
	,4.623696468e-004
	,4.666260390e-004
	,4.708234070e-004
	,4.749508530e-004
	,4.790080765e-004
	,4.830080708e-004
	,4.869661157e-004
	,4.908921774e-004
	,4.947913106e-004
	,4.986660629e-004
	,5.025181103e-004
	,5.063489852e-004
	,5.101601551e-004
	,5.139528901e-004
	,5.177282200e-004
	,5.214869889e-004
	,5.252299283e-004
	,5.289577110e-004
	,5.326709823e-004
	,5.363703754e-004
	,5.400565184e-004
	,5.437300346e-004
	,5.473915233e-004
	,5.510414720e-004
	,5.546799796e-004
	,5.583061044e-004
	,5.619165371e-004
	,5.655034398e-004
	,5.690556253e-004
	,5.725730645e-004
	,5.760716335e-004
	,5.795643118e-004
	,5.830560935e-004
	,5.865479361e-004
	,5.900389437e-004
	,5.935266103e-004
	,5.970061546e-004
	,6.004695489e-004
	,6.039028551e-004
	,6.072902177e-004
	,6.106315505e-004
	,6.139423608e-004
	,6.172344008e-004
	,6.205026552e-004
	,6.237558674e-004
	,6.270179242e-004
	,6.302949922e-004
	,6.335881965e-004
	,6.368972576e-004
	,6.402214858e-004
	,6.435604001e-004
	,6.469139298e-004
	,6.502823848e-004
	,6.536663775e-004
	,6.570667508e-004
	,6.604845020e-004
	,6.639206533e-004
	,6.673759306e-004
	,6.708497709e-004
	,6.743357995e-004
	,6.777918591e-004
	,6.810889420e-004
	,6.842813180e-004
	,6.874792817e-004
	,6.907014664e-004
	,6.939480051e-004
	,6.972168839e-004
	,7.005064128e-004
	,7.038157068e-004
	,7.071448935e-004
	,7.104952263e-004
	,7.138685422e-004
	,7.172657559e-004
	,7.206865729e-004
	,7.241311595e-004
	,7.276012182e-004
	,7.311001215e-004
	,7.346329327e-004
	,7.382065813e-004
	,7.418301876e-004
	,7.455155011e-004
	,7.492774237e-004
	,7.531345686e-004
	,7.571097955e-004
	,7.612306536e-004
	,7.655297165e-004
	,7.700448285e-004
	,7.748192383e-004
	,7.799016048e-004
	,7.853457260e-004
	,7.912101537e-004
	,7.975564990e-004
	,8.044454571e-004
	,8.119358710e-004
	,8.200853970e-004
	,8.289496934e-004
	,8.385812845e-004
	,8.490295636e-004
	,8.603397817e-004
	,8.725559814e-004
	,8.854955636e-004
	,8.984660196e-004
	,9.123551838e-004
	,-7.412072508e-004
	,-7.221547927e-004
	,-7.029371109e-004
	,-6.835759758e-004
	,-6.642271992e-004
	,-6.450751963e-004
	,-6.261978069e-004
	,-6.074842490e-004
	,-5.886913609e-004
	,-5.696319262e-004
	,-5.502113397e-004
	,-5.304167147e-004
	,-5.103153189e-004
	,-4.901145007e-004
	,-4.700870903e-004
	,-4.504110225e-004
	,-4.311425351e-004
	,-4.122659703e-004
	,-3.937433437e-004
	,-3.755162898e-004
	,-3.574606378e-004
	,-3.393794264e-004
	,-3.211238882e-004
	,-3.026667736e-004
	,-2.839855017e-004
	,-2.650292169e-004
	,-2.457925973e-004
	,-2.263847535e-004
	,-2.069840566e-004
	,-1.877371448e-004
	,-1.687838508e-004
	,-1.502496428e-004
	,-1.321863156e-004
	,-1.145870050e-004
	,-9.741174995e-005
	,-8.059781235e-005
	,-6.405460607e-005
	,-4.766352571e-005
	,-3.140857640e-005
	,-1.547478978e-005
	,1.153964791e-017
	,1.499761422e-005
	,2.955082234e-005
	,4.369908339e-005
	,5.745233080e-005
	,7.074152602e-005
	,8.344222587e-005
	,9.558018199e-005
	,1.073166796e-004
	,1.187755305e-004
	,1.300099401e-004
	,1.409930409e-004
	,1.516997557e-004
	,1.622172772e-004
	,1.726174635e-004
	,1.829302131e-004
	,1.931621827e-004
	,2.033047143e-004
	,2.133427959e-004
	,2.232673789e-004
	,2.330813196e-004
	,2.427951365e-004
	,2.524199988e-004
	,2.619637781e-004
	,2.714298602e-004
	,2.808160524e-004
	,2.901110798e-004
	,2.992884585e-004
	,3.083108012e-004
	,3.171675236e-004
	,3.258941941e-004
	,3.345353562e-004
	,3.431239583e-004
	,3.516829475e-004
	,3.602284253e-004
	,3.687714958e-004
	,3.773193800e-004
	,3.858759494e-004
	,3.944417017e-004
	,4.030131556e-004
	,4.115815282e-004
	,4.201304224e-004
	,4.286323586e-004
	,4.370454332e-004
	,4.453155347e-004
	,4.533876169e-004
	,4.611951984e-004
	,4.685197215e-004
	,4.744550370e-004
	,4.788913715e-004
	,4.834715944e-004
	,4.883585027e-004
	,4.934347755e-004
	,4.986202640e-004
	,5.038655711e-004
	,5.091388245e-004
	,5.144183385e-004
	,5.196886769e-004
	,5.249384508e-004
	,5.301590352e-004
	,5.353438242e-004
	,5.404878815e-004
	,5.455878825e-004
	,5.506417999e-004
	,5.556476573e-004
	,5.606024625e-004
	,5.655018051e-004
	,5.703381726e-004
	,5.750945208e-004
	,5.797276720e-004
	,5.841820959e-004
	,5.884901157e-004
	,5.927170341e-004
	,5.968903303e-004
	,6.010174693e-004
	,6.050986076e-004
	,6.091310307e-004
	,6.131135955e-004
	,6.170517848e-004
	,6.209561216e-004
	,6.248358802e-004
	,6.286967412e-004
	,6.325417736e-004
	,6.363726347e-004
	,6.401901453e-004
	,6.439943429e-004
	,6.477841425e-004
	,6.515564740e-004
	,6.553046809e-004
	,6.590178059e-004
	,6.626884748e-004
	,6.663266126e-004
	,6.699506373e-004
	,6.735719249e-004
	,6.771946235e-004
	,6.808193711e-004
	,6.844450532e-004
	,6.880689452e-004
	,6.916857619e-004
	,6.952862216e-004
	,6.988581818e-004
	,7.023946296e-004
	,7.058998983e-004
	,7.093835761e-004
	,7.128536041e-004
	,7.163151578e-004
	,7.197715897e-004
	,7.232252575e-004
	,7.266779940e-004
	,7.301313582e-004
	,7.335867631e-004
	,7.370456190e-004
	,7.405098311e-004
	,7.439820237e-004
	,7.474657736e-004
	,7.509632002e-004
	,7.544723393e-004
	,7.579834543e-004
	,7.614953700e-004
	,7.650224888e-004
	,7.685678639e-004
	,7.721290275e-004
	,7.756938900e-004
	,7.792050015e-004
	,7.824857188e-004
	,7.856005397e-004
	,7.887248166e-004
	,7.918879748e-004
	,7.950879241e-004
	,7.983190879e-004
	,8.015763183e-004
	,8.048555276e-004
	,8.081536611e-004
	,8.114685227e-004
	,8.147986111e-004
	,8.181430103e-004
	,8.215013391e-004
	,8.248737621e-004
	,8.282610984e-004
	,8.316651607e-004
	,8.350890635e-004
	,8.385354651e-004
	,8.420067063e-004
	,8.455070454e-004
	,8.490427007e-004
	,8.526218792e-004
	,8.562551030e-004
	,8.599556725e-004
	,8.637401798e-004
	,8.676290376e-004
	,8.716469812e-004
	,8.758236214e-004
	,8.801935018e-004
	,8.847965601e-004
	,8.896781935e-004
	,8.948892278e-004
	,9.004846770e-004
	,9.065207910e-004
	,9.130524259e-004
	,9.201334661e-004
	,9.278179313e-004
	,-7.690011044e-004
	,-7.492484686e-004
	,-7.293983293e-004
	,-7.095553885e-004
	,-6.898825206e-004
	,-6.704351948e-004
	,-6.510822114e-004
	,-6.315472120e-004
	,-6.116673571e-004
	,-5.914423727e-004
	,-5.708901077e-004
	,-5.500464769e-004
	,-5.290560076e-004
	,-5.081682555e-004
	,-4.875643873e-004
	,-4.673107942e-004
	,-4.474254631e-004
	,-4.279344617e-004
	,-4.088616465e-004
	,-3.902040975e-004
	,-3.719143631e-004
	,-3.538763744e-004
	,-3.358811572e-004
	,-3.176266611e-004
	,-2.987998852e-004
	,-2.793186710e-004
	,-2.594193208e-004
	,-2.394220738e-004
	,-2.195767798e-004
	,-2.000328037e-004
	,-1.808405017e-004
	,-1.619833612e-004
	,-1.433999919e-004
	,-1.249955243e-004
	,-1.066938826e-004
	,-8.846571102e-005
	,-7.026000508e-005
	,-5.213170196e-005
	,-3.429578787e-005
	,-1.690375554e-005
	,-6.422783196e-018
	,1.642015621e-005
	,3.236972999e-005
	,4.783483316e-005
	,6.274492339e-005
	,7.703018336e-005
	,9.073513937e-005
	,1.039707172e-004
	,1.168336280e-004
	,1.293935800e-004
	,1.416988337e-004
	,1.537821490e-004
	,1.656685579e-004
	,1.773803710e-004
	,1.889332102e-004
	,2.003277302e-004
	,2.115351314e-004
	,2.224797864e-004
	,2.331364177e-004
	,2.436055921e-004
	,2.539711788e-004
	,2.642720158e-004
	,2.745259801e-004
	,2.847401484e-004
	,2.949129362e-004
	,3.050324669e-004
	,3.150760579e-004
	,3.250269243e-004
	,3.348981319e-004
	,3.447155243e-004
	,3.544904810e-004
	,3.642142710e-004
	,3.738614181e-004
	,3.834057036e-004
	,3.928442914e-004
	,4.021954117e-004
	,4.114792667e-004
	,4.207109862e-004
	,4.299019263e-004
	,4.390610684e-004
	,4.481948615e-004
	,4.573063999e-004
	,4.663946937e-004
	,4.754539816e-004
	,4.844723754e-004
	,4.934281154e-004
	,5.022780616e-004
	,5.109154499e-004
	,5.189622652e-004
	,5.249947258e-004
	,5.295160338e-004
	,5.345667370e-004
	,5.400492036e-004
	,5.457666039e-004
	,5.516061052e-004
	,5.575027163e-004
	,5.634208854e-004
	,5.693434666e-004
	,5.752623198e-004
	,5.811720914e-004
	,5.870676948e-004
	,5.929438864e-004
	,5.987957673e-004
	,6.046198268e-004
	,6.104143535e-004
	,6.161780605e-004
	,6.219088235e-004
	,6.276038122e-004
	,6.332600269e-004
	,6.388746258e-004
	,6.444450546e-004
	,6.499690775e-004
	,6.554447695e-004
	,6.608704914e-004
	,6.662448559e-004
	,6.715666830e-004
	,6.768349339e-004
	,6.820486024e-004
	,6.872065116e-004
	,6.923068849e-004
	,6.973463318e-004
	,7.023171489e-004
	,7.071996503e-004
	,7.119459970e-004
	,7.164994445e-004
	,7.208922993e-004
	,7.251969672e-004
	,7.294494098e-004
	,7.336621235e-004
	,7.378383117e-004
	,7.419762692e-004
	,7.460696998e-004
	,7.501068837e-004
	,7.540740900e-004
	,7.579710187e-004
	,7.618203720e-004
	,7.656481817e-004
	,7.694683633e-004
	,7.732850658e-004
	,7.770975618e-004
	,7.809025607e-004
	,7.846947194e-004
	,7.884664016e-004
	,7.922080369e-004
	,7.959109527e-004
	,7.995714606e-004
	,8.031909542e-004
	,8.067724382e-004
	,8.103182804e-004
	,8.138299481e-004
	,8.173084244e-004
	,8.207546277e-004
	,8.241696963e-004
	,8.275551484e-004
	,8.309129461e-004
	,8.342454888e-004
	,8.375555510e-004
	,8.408461677e-004
	,8.441204613e-004
	,8.473814280e-004
	,8.506317574e-004
	,8.538737562e-004
	,8.571093442e-004
	,8.603399651e-004
	,8.635665176e-004
	,8.667888205e-004
	,8.700033327e-004
	,8.731953833e-004
	,8.762993937e-004
	,8.791273327e-004
	,8.817659883e-004
	,8.844173237e-004
	,8.871095496e-004
	,8.898323150e-004
	,8.925801510e-004
	,8.953542057e-004
	,8.981510101e-004
	,9.009670560e-004
	,9.037998313e-004
	,9.066476243e-004
	,9.095093178e-004
	,9.123842664e-004
	,9.152722387e-004
	,9.181734084e-004
	,9.210883851e-004
	,9.240182835e-004
	,9.269648306e-004
	,9.299304958e-004
	,9.329186077e-004
	,9.359333742e-004
	,9.389797764e-004
	,9.420635400e-004
	,9.451914695e-004
	,9.483721140e-004
	,9.516164475e-004
	,9.549384250e-004
	,9.583554735e-004
	,9.618889763e-004
	,9.655647370e-004
	,9.694135328e-004
	,9.734720326e-004
	,-7.939383477e-004
	,-7.738733864e-004
	,-7.537279817e-004
	,-7.336571745e-004
	,-7.137220269e-004
	,-6.938216413e-004
	,-6.737467032e-004
	,-6.533095937e-004
	,-6.325128231e-004
	,-6.114089998e-004
	,-5.900208373e-004
	,-5.684186731e-004
	,-5.468152032e-004
	,-5.254072716e-004
	,-5.043109558e-004
	,-4.835879589e-004
	,-4.632720222e-004
	,-4.433735421e-004
	,-4.238744560e-004
	,-4.047180244e-004
	,-3.857921685e-004
	,-3.669170700e-004
	,-3.478613284e-004
	,-3.284501564e-004
	,-3.087176205e-004
	,-2.888606506e-004
	,-2.690458430e-004
	,-2.493543836e-004
	,-2.298042906e-004
	,-2.103606028e-004
	,-1.909951086e-004
	,-1.717223386e-004
	,-1.525491318e-004
	,-1.334158204e-004
	,-1.141795744e-004
	,-9.474442311e-005
	,-7.524972210e-005
	,-5.590660200e-005
	,-3.685643952e-005
	,-1.820110174e-005
	,9.920940451e-018
	,1.771571315e-005
	,3.490464245e-005
	,5.150154046e-005
	,6.746649134e-005
	,8.282353496e-005
	,9.762790197e-005
	,1.119378702e-004
	,1.258125649e-004
	,1.393100319e-004
	,1.524817488e-004
	,1.653703403e-004
	,1.780108173e-004
	,1.904348398e-004
	,2.026750674e-004
	,2.147636959e-004
	,2.267287771e-004
	,2.385926220e-004
	,2.503713487e-004
	,2.620737483e-004
	,2.736980132e-004
	,2.852236718e-004
	,2.965938623e-004
	,3.077033744e-004
	,3.184868443e-004
	,3.290102876e-004
	,3.393655793e-004
	,3.496179296e-004
	,3.598094227e-004
	,3.699640865e-004
	,3.800951948e-004
	,3.902105242e-004
	,4.003150482e-004
	,4.104121879e-004
	,4.205043745e-004
	,4.305932819e-004
	,4.406798838e-004
	,4.507644007e-004
	,4.608461620e-004
	,4.709234000e-004
	,4.809929887e-004
	,4.910501335e-004
	,5.010879717e-004
	,5.110969391e-004
	,5.210634900e-004
	,5.309670021e-004
	,5.407712121e-004
	,5.503961083e-004
	,5.595948414e-004
	,5.671674246e-004
	,5.713601899e-004
	,5.761191250e-004
	,5.817321877e-004
	,5.877950352e-004
	,5.941158090e-004
	,6.005937908e-004
	,6.071692928e-004
	,6.138034275e-004
	,6.204687565e-004
	,6.271444015e-004
	,6.338132258e-004
	,6.404602802e-004
	,6.470726459e-004
	,6.536408461e-004
	,6.601598957e-004
	,6.666279102e-004
	,6.730447106e-004
	,6.794117200e-004
	,6.857312061e-004
	,6.920047725e-004
	,6.982323231e-004
	,7.044118089e-004
	,7.105393613e-004
	,7.166094619e-004
	,7.226150332e-004
	,7.285474993e-004
	,7.343969788e-004
	,7.401528581e-004
	,7.458050000e-004
	,7.513456027e-004
	,7.567711830e-004
	,7.620836696e-004
	,7.672898703e-004
	,7.723995932e-004
	,7.774234704e-004
	,7.823713623e-004
	,7.872515760e-004
	,7.920706938e-004
	,7.968337056e-004
	,8.015442235e-004
	,8.062046423e-004
	,8.108161566e-004
	,8.153785261e-004
	,8.198893715e-004
	,8.243424564e-004
	,8.287235127e-004
	,8.330001447e-004
	,8.371078995e-004
	,8.409967282e-004
	,8.447301490e-004
	,8.484003191e-004
	,8.520529581e-004
	,8.557033737e-004
	,8.593545339e-004
	,8.630046435e-004
	,8.666496784e-004
	,8.702842448e-004
	,8.739025866e-004
	,8.775005374e-004
	,8.810772949e-004
	,8.846353057e-004
	,8.881785331e-004
	,8.917106085e-004
	,8.952340246e-004
	,8.987502429e-004
	,9.022600400e-004
	,9.057637944e-004
	,9.092616879e-004
	,9.127538347e-004
	,9.162403556e-004
	,9.197214151e-004
	,9.231972373e-004
	,9.266681080e-004
	,9.301343672e-004
	,9.335963916e-004
	,9.370545635e-004
	,9.405092167e-004
	,9.439605363e-004
	,9.474083590e-004
	,9.508517200e-004
	,9.542876619e-004
	,9.577074174e-004
	,9.610804681e-004
	,9.642749656e-004
	,9.670455092e-004
	,9.696751320e-004
	,9.723694576e-004
	,9.751322550e-004
	,9.779478926e-004
	,9.808037919e-004
	,9.836910155e-004
	,9.866031860e-004
	,9.895356697e-004
	,9.924850509e-004
	,9.954487905e-004
	,9.984249965e-004
	,1.001412257e-003
	,1.004409472e-003
	,1.007415444e-003
	,1.010426819e-003
	,1.013437432e-003
	,1.016454913e-003
	,1.019487508e-003
	,1.022539561e-003
	,1.025613234e-003
	,1.028708933e-003
	,1.031827824e-003
	,1.034972773e-003
	,1.038148248e-003
	,1.041360299e-003
	,1.044616718e-003
	,-8.163066661e-004
	,-7.959706047e-004
	,-7.755975382e-004
	,-7.552772426e-004
	,-7.349590054e-004
	,-7.145143383e-004
	,-6.937683842e-004
	,-6.726167590e-004
	,-6.511204554e-004
	,-6.293248743e-004
	,-6.072571022e-004
	,-5.850857016e-004
	,-5.630462835e-004
	,-5.412873654e-004
	,-5.198980804e-004
	,-4.989184157e-004
	,-4.783516715e-004
	,-4.581686923e-004
	,-4.383002685e-004
	,-4.186228475e-004
	,-3.989498569e-004
	,-3.790665658e-004
	,-3.588697370e-004
	,-3.384493375e-004
	,-3.179919628e-004
	,-2.976582995e-004
	,-2.775390892e-004
	,-2.576802365e-004
	,-2.380695163e-004
	,-2.186397482e-004
	,-1.992870020e-004
	,-1.798687536e-004
	,-1.601875526e-004
	,-1.400749054e-004
	,-1.196271853e-004
	,-9.912218863e-005
	,-7.875691338e-005
	,-5.862436051e-005
	,-3.876673080e-005
	,-1.921194390e-005
	,3.383603767e-017
	,1.879337414e-005
	,3.705872063e-005
	,5.471054562e-005
	,7.172977821e-005
	,8.814410886e-005
	,1.039986832e-004
	,1.193414744e-004
	,1.342181967e-004
	,1.486703997e-004
	,1.627362563e-004
	,1.764551299e-004
	,1.898698895e-004
	,2.030217359e-004
	,2.159438841e-004
	,2.286592015e-004
	,2.411846560e-004
	,2.535398086e-004
	,2.657466771e-004
	,2.778242143e-004
	,2.897870417e-004
	,3.016460726e-004
	,3.134091460e-004
	,3.250799076e-004
	,3.366670494e-004
	,3.481963957e-004
	,3.596965149e-004
	,3.711731779e-004
	,3.825970655e-004
	,3.938959606e-004
	,4.049894344e-004
	,4.158910567e-004
	,4.266882978e-004
	,4.374479521e-004
	,4.482035281e-004
	,4.589704001e-004
	,4.697550866e-004
	,4.805592977e-004
	,4.913816698e-004
	,5.022185406e-004
	,5.130642977e-004
	,5.239114832e-004
	,5.347506712e-004
	,5.455699875e-004
	,5.563539050e-004
	,5.670803391e-004
	,5.777131233e-004
	,5.881791552e-004
	,5.982761727e-004
	,6.070461422e-004
	,6.108067064e-004
	,6.149805666e-004
	,6.206076958e-004
	,6.268851394e-004
	,6.335083548e-004
	,6.403345212e-004
	,6.472854257e-004
	,6.543130077e-004
	,6.613842976e-004
	,6.684738820e-004
	,6.755598376e-004
	,6.826219094e-004
	,6.896420204e-004
	,6.966059196e-004
	,7.035014696e-004
	,7.103131539e-004
	,7.170203890e-004
	,7.236035736e-004
	,7.300535747e-004
	,7.363764682e-004
	,7.425893419e-004
	,7.487119456e-004
	,7.547608003e-004
	,7.607473354e-004
	,7.666784395e-004
	,7.725579107e-004
	,7.783881032e-004
	,7.841713480e-004
	,7.899106724e-004
	,7.956096195e-004
	,8.012715705e-004
	,8.068991792e-004
	,8.124941772e-004
	,8.180574602e-004
	,8.235892818e-004
	,8.290894480e-004
	,8.345574738e-004
	,8.399926935e-004
	,8.453943339e-004
	,8.507615557e-004
	,8.560934689e-004
	,8.613891242e-004
	,8.666474759e-004
	,8.718673112e-004
	,8.770471299e-004
	,8.821849581e-004
	,8.872780848e-004
	,8.923227582e-004
	,8.973140462e-004
	,9.022463856e-004
	,9.071154426e-004
	,9.119207004e-004
	,9.166662623e-004
	,9.213586363e-004
	,9.260037604e-004
	,9.306053675e-004
	,9.351644162e-004
	,9.396783845e-004
	,9.441390462e-004
	,9.485264357e-004
	,9.527994432e-004
	,9.569186698e-004
	,9.609137642e-004
	,9.648431000e-004
	,9.687383921e-004
	,9.726126011e-004
	,9.764711165e-004
	,9.803162537e-004
	,9.841489742e-004
	,9.879696221e-004
	,9.917782839e-004
	,9.955749961e-004
	,9.993599040e-004
	,1.003133423e-003
	,1.006896402e-003
	,1.010650124e-003
	,1.014395857e-003
	,1.018134215e-003
	,1.021865100e-003
	,1.025588095e-003
	,1.029302698e-003
	,1.033008294e-003
	,1.036703964e-003
	,1.040388082e-003
	,1.044057320e-003
	,1.047703704e-003
	,1.051303744e-003
	,1.054763924e-003
	,1.057732960e-003
	,1.060288347e-003
	,1.062931889e-003
	,1.065693329e-003
	,1.068537702e-003
	,1.071440302e-003
	,1.074385274e-003
	,1.077362119e-003
	,1.080363593e-003
	,1.083384468e-003
	,1.086420208e-003
	,1.089466902e-003
	,1.092524214e-003
	,1.095591139e-003
	,1.098666711e-003
	,1.101750288e-003
	,1.104841531e-003
	,1.107940369e-003
	,1.111046953e-003
	,1.114161615e-003
	,1.117284850e-003
	,1.120417342e-003
	,1.123560033e-003
	,-8.361892796e-004
	,-8.155784599e-004
	,-7.949518512e-004
	,-7.743135446e-004
	,-7.535827573e-004
	,-7.326326982e-004
	,-7.112739302e-004
	,-6.894747629e-004
	,-6.673359117e-004
	,-6.449149180e-004
	,-6.223182282e-004
	,-5.997790534e-004
	,-5.774747074e-004
	,-5.555091978e-004
	,-5.339441364e-004
	,-5.127904190e-004
	,-4.920183709e-004
	,-4.715563015e-004
	,-4.512787887e-004
	,-4.309998006e-004
	,-4.105133242e-004
	,-3.897378008e-004
	,-3.687733610e-004
	,-3.477809712e-004
	,-3.269119079e-004
	,-3.062650005e-004
	,-2.858977813e-004
	,-2.658181485e-004
	,-2.459705139e-004
	,-2.262411024e-004
	,-2.064351299e-004
	,-1.862631110e-004
	,-1.655597358e-004
	,-1.445240930e-004
	,-1.234259840e-004
	,-1.023970874e-004
	,-8.148833207e-005
	,-6.073866131e-005
	,-4.019644693e-005
	,-1.992352576e-005
	,6.161361848e-018
	,1.949552191e-005
	,3.852302403e-005
	,5.707889271e-005
	,7.515498642e-005
	,9.270397350e-005
	,1.096737504e-004
	,1.260655709e-004
	,1.419083699e-004
	,1.572344219e-004
	,1.720861094e-004
	,1.865149551e-004
	,2.005719659e-004
	,2.143033210e-004
	,2.277500311e-004
	,2.409480719e-004
	,2.539283552e-004
	,2.667171953e-004
	,2.793378413e-004
	,2.918113676e-004
	,3.041542538e-004
	,3.163744455e-004
	,3.284726958e-004
	,3.404598599e-004
	,3.523800282e-004
	,3.642938382e-004
	,3.762428889e-004
	,3.882451273e-004
	,4.003054994e-004
	,4.124231759e-004
	,4.245937992e-004
	,4.368103829e-004
	,4.490648562e-004
	,4.613419472e-004
	,4.736127998e-004
	,4.858248917e-004
	,4.978987962e-004
	,5.097743907e-004
	,5.214786517e-004
	,5.330854939e-004
	,5.446473147e-004
	,5.561867208e-004
	,5.677081871e-004
	,5.792059044e-004
	,5.906667889e-004
	,6.020699344e-004
	,6.133815890e-004
	,6.245392339e-004
	,6.353941331e-004
	,6.453833602e-004
	,6.496309777e-004
	,6.517946814e-004
	,6.569580960e-004
	,6.631548210e-004
	,6.698482913e-004
	,6.768075134e-004
	,6.838999093e-004
	,6.910317179e-004
	,6.981279905e-004
	,7.051312976e-004
	,7.120095840e-004
	,7.187593818e-004
	,7.253981099e-004
	,7.319537259e-004
	,7.384564705e-004
	,7.449314833e-004
	,7.513950957e-004
	,7.578558152e-004
	,7.643170060e-004
	,7.707791030e-004
	,7.772409809e-004
	,7.837007169e-004
	,7.901560029e-004
	,7.966043657e-004
	,8.030432863e-004
	,8.094702620e-004
	,8.158828377e-004
	,8.222786171e-004
	,8.286552618e-004
	,8.350104802e-004
	,8.413420068e-004
	,8.476475755e-004
	,8.539248882e-004
	,8.601715877e-004
	,8.663852526e-004
	,8.725634482e-004
	,8.787038805e-004
	,8.848046856e-004
	,8.908648041e-004
	,8.968842498e-004
	,9.028640426e-004
	,9.088057703e-004
	,9.147110117e-004
	,9.205808936e-004
	,9.264158722e-004
	,9.322156777e-004
	,9.379793232e-004
	,9.437051227e-004
	,9.493907185e-004
	,9.550331874e-004
	,9.606293513e-004
	,9.661763885e-004
	,9.716726240e-004
	,9.771180505e-004
	,9.825141677e-004
	,9.878632535e-004
	,9.931675812e-004
	,9.984289343e-004
	,1.003648428e-003
	,1.008826492e-003
	,1.013962908e-003
	,1.019056832e-003
	,1.024106850e-003
	,1.029111088e-003
	,1.034067483e-003
	,1.038974144e-003
	,1.043829676e-003
	,1.048633231e-003
	,1.053384260e-003
	,1.058082023e-003
	,1.062724889e-003
	,1.067309054e-003
	,1.071825685e-003
	,1.076255061e-003
	,1.080566097e-003
	,1.084752887e-003
	,1.088855331e-003
	,1.092910061e-003
	,1.096934017e-003
	,1.100933883e-003
	,1.104912248e-003
	,1.108870059e-003
	,1.112807567e-003
	,1.116724729e-003
	,1.120621360e-003
	,1.124497161e-003
	,1.128351637e-003
	,1.132183837e-003
	,1.135991641e-003
	,1.139769645e-003
	,1.143501574e-003
	,1.147124942e-003
	,1.150323906e-003
	,1.152730294e-003
	,1.155205281e-003
	,1.157886695e-003
	,1.160699200e-003
	,1.163596976e-003
	,1.166553478e-003
	,1.169552176e-003
	,1.172582099e-003
	,1.175635608e-003
	,1.178707188e-003
	,1.181792756e-003
	,1.184889228e-003
	,1.187994245e-003
	,1.191105992e-003
	,1.194223069e-003
	,1.197344404e-003
	,1.200469154e-003
	,1.203596424e-003
	,-8.542471177e-004
	,-8.333618866e-004
	,-8.124493438e-004
	,-7.914586213e-004
	,-7.702921423e-004
	,-7.487758358e-004
	,-7.267542871e-004
	,-7.043336416e-004
	,-6.816389950e-004
	,-6.587288722e-004
	,-6.357706856e-004
	,-6.129848568e-004
	,-5.904934101e-004
	,-5.683748198e-004
	,-5.466629871e-004
	,-5.253397801e-004
	,-5.043413342e-004
	,-4.835508590e-004
	,-4.627908570e-004
	,-4.418550213e-004
	,-4.206440465e-004
	,-3.992451276e-004
	,-3.778038882e-004
	,-3.564555514e-004
	,-3.353125021e-004
	,-3.144484301e-004
	,-2.938950207e-004
	,-2.736133257e-004
	,-2.534828604e-004
	,-2.332628883e-004
	,-2.125847923e-004
	,-1.912730763e-004
	,-1.695963873e-004
	,-1.478721193e-004
	,-1.262513532e-004
	,-1.047754484e-004
	,-8.344005626e-005
	,-6.223848349e-005
	,-4.120316030e-005
	,-2.042249828e-005
	,2.662773592e-015
	,1.999843250e-005
	,3.955500770e-005
	,5.868017062e-005
	,7.739283385e-005
	,9.570733275e-005
	,1.136173178e-004
	,1.310756159e-004
	,1.479918227e-004
	,1.642970562e-004
	,1.800163646e-004
	,1.952236998e-004
	,2.099875094e-004
	,2.243630750e-004
	,2.383964575e-004
	,2.521273840e-004
	,2.655916401e-004
	,2.788231695e-004
	,2.918530411e-004
	,3.047049394e-004
	,3.173905183e-004
	,3.299088284e-004
	,3.422618550e-004
	,3.544916713e-004
	,3.666832089e-004
	,3.789106297e-004
	,3.912119408e-004
	,4.036012154e-004
	,4.160821998e-004
	,4.286547758e-004
	,4.413172783e-004
	,4.540671241e-004
	,4.669008290e-004
	,4.798138283e-004
	,4.928002495e-004
	,5.058526765e-004
	,5.189618813e-004
	,5.321164319e-004
	,5.453019715e-004
	,5.584996740e-004
	,5.716832182e-004
	,5.848154300e-004
	,5.978396162e-004
	,6.106731960e-004
	,6.232347870e-004
	,6.354992797e-004
	,6.474857176e-004
	,6.591817892e-004
	,6.704889276e-004
	,6.811620919e-004
	,6.904045027e-004
	,6.892073544e-004
	,6.916589021e-004
	,6.966520156e-004
	,7.024769851e-004
	,7.086953327e-004
	,7.151318749e-004
	,7.217025047e-004
	,7.283599291e-004
	,7.350726702e-004
	,7.418163399e-004
	,7.485706356e-004
	,7.553206837e-004
	,7.620615873e-004
	,7.688002656e-004
	,7.755489854e-004
	,7.823165882e-004
	,7.891055677e-004
	,7.959138917e-004
	,8.027375737e-004
	,8.095723664e-004
	,8.164145286e-004
	,8.232609983e-004
	,8.301092822e-004
	,8.369572721e-004
	,8.438030900e-004
	,8.506449881e-004
	,8.574812936e-004
	,8.643103811e-004
	,8.711306597e-004
	,8.779405663e-004
	,8.847385610e-004
	,8.915231237e-004
	,8.982927504e-004
	,9.050459493e-004
	,9.117812363e-004
	,9.184971301e-004
	,9.251921452e-004
	,9.318647844e-004
	,9.385135280e-004
	,9.451368210e-004
	,9.517330561e-004
	,9.583005533e-004
	,9.648375351e-004
	,9.713421000e-004
	,9.778121990e-004
	,9.842456244e-004
	,9.906400316e-004
	,9.969930155e-004
	,1.003302265e-003
	,1.009565795e-003
	,1.015782198e-003
	,1.021950854e-003
	,1.028071990e-003
	,1.034146580e-003
	,1.040176075e-003
	,1.046162066e-003
	,1.052105970e-003
	,1.058008830e-003
	,1.063871225e-003
	,1.069693269e-003
	,1.075474639e-003
	,1.081214632e-003
	,1.086912201e-003
	,1.092566009e-003
	,1.098174474e-003
	,1.103735844e-003
	,1.109248300e-003
	,1.114710075e-003
	,1.120119563e-003
	,1.125475391e-003
	,1.130776432e-003
	,1.136021769e-003
	,1.141210647e-003
	,1.146342413e-003
	,1.151416486e-003
	,1.156432325e-003
	,1.161389418e-003
	,1.166287268e-003
	,1.171125374e-003
	,1.175903201e-003
	,1.180620126e-003
	,1.185275325e-003
	,1.189867548e-003
	,1.194394601e-003
	,1.198852127e-003
	,1.203230709e-003
	,1.207511421e-003
	,1.211673835e-003
	,1.215729432e-003
	,1.219712715e-003
	,1.223645787e-003
	,1.227536535e-003
	,1.231384209e-003
	,1.235178319e-003
	,1.238881872e-003
	,1.242322733e-003
	,1.244690560e-003
	,1.246740226e-003
	,1.249185350e-003
	,1.251846967e-003
	,1.254633926e-003
	,1.257500944e-003
	,1.260422383e-003
	,1.263382378e-003
	,1.266370592e-003
	,1.269380106e-003
	,1.272406112e-003
	,1.275444895e-003
	,1.278493209e-003
	,1.281548206e-003
	,-8.710063658e-004
	,-8.498399310e-004
	,-8.285942203e-004
	,-8.071811503e-004
	,-7.854851424e-004
	,-7.633455714e-004
	,-7.407427189e-004
	,-7.178336690e-004
	,-6.946905228e-004
	,-6.713996550e-004
	,-6.481803199e-004
	,-6.252098700e-004
	,-6.025708237e-004
	,-5.803196502e-004
	,-5.584629482e-004
	,-5.369534189e-004
	,-5.156901967e-004
	,-4.945107706e-004
	,-4.732083332e-004
	,-4.516471014e-004
	,-4.298808704e-004
	,-4.080505148e-004
	,-3.862763340e-004
	,-3.646716865e-004
	,-3.433298384e-004
	,-3.223092885e-004
	,-3.015996103e-004
	,-2.810914834e-004
	,-2.605263359e-004
	,-2.394681704e-004
	,-2.176643219e-004
	,-1.953932709e-004
	,-1.730248359e-004
	,-1.507481488e-004
	,-1.286251867e-004
	,-1.066625856e-004
	,-8.485993766e-005
	,-6.323794296e-005
	,-4.184484274e-005
	,-2.074635564e-005
	,1.805433021e-015
	,2.035861354e-005
	,4.031341163e-005
	,5.986497741e-005
	,7.902512792e-005
	,9.780654429e-005
	,1.162158010e-004
	,1.342581791e-004
	,1.519398093e-004
	,1.692506037e-004
	,1.861406097e-004
	,2.025127890e-004
	,2.182886784e-004
	,2.334935604e-004
	,2.482129032e-004
	,2.625269761e-004
	,2.765003099e-004
	,2.901846884e-004
	,3.036187197e-004
	,3.168256204e-004
	,3.298108719e-004
	,3.425681884e-004
	,3.551150519e-004
	,3.675374325e-004
	,3.799530148e-004
	,3.924408939e-004
	,4.050352371e-004
	,4.177471178e-004
	,4.305787373e-004
	,4.435291440e-004
	,4.565960565e-004
	,4.697762460e-004
	,4.830654485e-004
	,4.964581697e-004
	,5.099475140e-004
	,5.235250760e-004
	,5.371808897e-004
	,5.509033995e-004
	,5.646793809e-004
	,5.784936947e-004
	,5.923286552e-004
	,6.061625892e-004
	,6.199666475e-004
	,6.336977103e-004
	,6.472827608e-004
	,6.605903951e-004
	,6.734231589e-004
	,6.856522250e-004
	,6.973606391e-004
	,7.086732832e-004
	,7.195724423e-004
	,7.297137647e-004
	,7.294484957e-004
	,7.289205388e-004
	,7.331133674e-004
	,7.384577341e-004
	,7.443798894e-004
	,7.506518278e-004
	,7.571535484e-004
	,7.638104197e-004
	,7.705696461e-004
	,7.773900054e-004
	,7.842388881e-004
	,7.910960364e-004
	,7.979602226e-004
	,8.048471125e-004
	,8.117751067e-004
	,8.187540676e-004
	,8.257845615e-004
	,8.328616901e-004
	,8.399783659e-004
	,8.471270769e-004
	,8.543006474e-004
	,8.614925117e-004
	,8.686968020e-004
	,8.759083954e-004
	,8.831229700e-004
	,8.903370582e-004
	,8.975480506e-004
	,9.047541105e-004
	,9.119540007e-004
	,9.191468698e-004
	,9.263320530e-004
	,9.335089245e-004
	,9.406768080e-004
	,9.478349339e-004
	,9.549824267e-004
	,9.621183080e-004
	,9.692415063e-004
	,9.763508671e-004
	,9.834451615e-004
	,9.905230913e-004
	,9.975832905e-004
	,1.004624322e-003
	,1.011644674e-003
	,1.018642747e-003
	,1.025616847e-003
	,1.032565174e-003
	,1.039485820e-003
	,1.046376776e-003
	,1.053235962e-003
	,1.060061287e-003
	,1.066850728e-003
	,1.073602434e-003
	,1.080314808e-003
	,1.086986543e-003
	,1.093616605e-003
	,1.100204162e-003
	,1.106748498e-003
	,1.113248948e-003
	,1.119704865e-003
	,1.126115627e-003
	,1.132480659e-003
	,1.138799451e-003
	,1.145071536e-003
	,1.151296426e-003
	,1.157473510e-003
	,1.163601976e-003
	,1.169680756e-003
	,1.175708527e-003
	,1.181683757e-003
	,1.187604763e-003
	,1.193469791e-003
	,1.199277075e-003
	,1.205024890e-003
	,1.210711581e-003
	,1.216335581e-003
	,1.221895422e-003
	,1.227389732e-003
	,1.232817242e-003
	,1.238176788e-003
	,1.243467315e-003
	,1.248687877e-003
	,1.253837647e-003
	,1.258915914e-003
	,1.263922087e-003
	,1.268855691e-003
	,1.273716362e-003
	,1.278503837e-003
	,1.283217942e-003
	,1.287858571e-003
	,1.292425661e-003
	,1.296919150e-003
	,1.301338919e-003
	,1.305684682e-003
	,1.309955779e-003
	,1.314150762e-003
	,1.318266448e-003
	,1.322295575e-003
	,1.326219865e-003
	,1.329983369e-003
	,1.333313002e-003
	,1.334995916e-003
	,1.336832681e-003
	,1.339133697e-003
	,1.341649942e-003
	,1.344289741e-003
	,1.347008243e-003
	,1.349779456e-003
	,1.352586726e-003
	,1.355418654e-003
	
    };
	
// --------------------------------------------------    IDS_FINISH	    --------------------------------------------------

// --------------------------------------------------    Cgs_START	    --------------------------------------------------
    localparam integer vgs_width_int_Cgs = 41;
    parameter real vgs_points_Cgs[0:vgs_width_int_Cgs-1] =  // Vgs range in volts
	{
		-4.000000000e-001
		,-3.500000000e-001
		,-3.000000000e-001
		,-2.500000000e-001
		,-2.000000000e-001
		,-1.500000000e-001
		,-1.000000000e-001
		,-5.000000000e-002
		,0
		,5.000000000e-002
		,1.000000000e-001
		,1.500000000e-001
		,2.000000000e-001
		,2.500000000e-001
		,3.000000000e-001
		,3.500000000e-001
		,4.000000000e-001
		,4.500000000e-001
		,5.000000000e-001
		,5.500000000e-001
		,6.000000000e-001
		,6.500000000e-001
		,7.000000000e-001
		,7.500000000e-001
		,8.000000000e-001
		,8.500000000e-001
		,9.000000000e-001
		,9.500000000e-001
		,1.000000000e+000
		,1.050000000e+000
		,1.100000000e+000
		,1.150000000e+000
		,1.200000000e+000
		,1.250000000e+000
		,1.300000000e+000
		,1.350000000e+000
		,1.400000000e+000
		,1.450000000e+000
		,1.500000000e+000
		,1.550000000e+000
		,1.600000000e+000
	};

	localparam integer vds_width_int_Cgs = 21;
    parameter real vds_points_Cgs[0:vds_width_int_Cgs-1] =	// Vds range in volts
	{
		-0.4,
		-0.3,
		-0.2,
		-0.1,
		0.0,
		0.1,
		0.2,
		0.3,
		0.4,
		0.5,
		0.6,
		0.7,
		0.8,
		0.9,
		1.0,
		1.1,
		1.2,
		1.3,
		1.4,
		1.5,
		1.6
	};
	localparam integer vgd_width_int_Cgs = 21;
    parameter real vgd_points_Cgs[0:vgd_width_int_Cgs-1] = // Vgd range in volts
	{
		-0.4,
		-0.3,
		-0.2,
		-0.1,
		0.0,
		0.1,
		0.2,
		0.3,
		0.4,
		0.5,
		0.6,
		0.7,
		0.8,
		0.9,
		1.0,
		1.1,
		1.2,
		1.3,
		1.4,
		1.5,
		1.6
	};

	// Sample Cgs data: Each row corresponds to a fixed Vds, columns vary Vgs
    parameter real table_Cgs[0 : vgs_width_int_Cgs*vds_width_int_Cgs*vgd_width_int_Cgs-1] = 
	{
		1.793334026e-016
		,1.766114396e-016
		,1.750151579e-016
		,1.739230925e-016
		,1.730959345e-016
		,1.724299782e-016
		,1.718748084e-016
		,1.714015947e-016
		,1.709923577e-016
		,1.706341398e-016
		,1.703165053e-016
		,1.700324553e-016
		,1.697766016e-016
		,1.695434605e-016
		,1.693309690e-016
		,1.691403134e-016
		,1.689717147e-016
		,1.688232365e-016
		,1.687231937e-016
		,1.687281911e-016
		,1.690008495e-016
		,1.701304955e-016
		,1.741838812e-016
		,1.870138398e-016
		,2.182161515e-016
		,2.664294777e-016
		,3.133250149e-016
		,3.483885134e-016
		,3.728299842e-016
		,3.902633797e-016
		,4.032228922e-016
		,4.131494330e-016
		,4.209184217e-016
		,4.271246218e-016
		,4.321901574e-016
		,4.364105205e-016
		,4.399911222e-016
		,4.430760358e-016
		,4.457685165e-016
		,4.481444485e-016
		,4.502609949e-016
		,1.782853542e-016
		,1.758988585e-016
		,1.744839118e-016
		,1.735009243e-016
		,1.727456114e-016
		,1.721321691e-016
		,1.716176507e-016
		,1.711775841e-016
		,1.707953728e-016
		,1.704589233e-016
		,1.701588792e-016
		,1.698879538e-016
		,1.696406528e-016
		,1.694130341e-016
		,1.692023169e-016
		,1.690066134e-016
		,1.688256057e-016
		,1.686627454e-016
		,1.685322533e-016
		,1.684836703e-016
		,1.686966206e-016
		,1.698121139e-016
		,1.740304500e-016
		,1.876923013e-016
		,2.207198171e-016
		,2.700875155e-016
		,3.166377689e-016
		,3.509676507e-016
		,3.748567681e-016
		,3.919079319e-016
		,4.045713101e-016
		,4.142525300e-016
		,4.218229641e-016
		,4.278759560e-016
		,4.328256077e-016
		,4.369573556e-016
		,4.404689902e-016
		,4.434995738e-016
		,4.461490265e-016
		,4.484909346e-016
		,4.505807794e-016
		,1.773924493e-016
		,1.752844086e-016
		,1.740181164e-016
		,1.731252318e-016
		,1.724313823e-016
		,1.718637566e-016
		,1.713859526e-016
		,1.709760107e-016
		,1.706188181e-016
		,1.703029263e-016
		,1.700195441e-016
		,1.697619463e-016
		,1.695251622e-016
		,1.693056474e-016
		,1.691009864e-016
		,1.689097259e-016
		,1.687317594e-016
		,1.685704178e-016
		,1.684403523e-016
		,1.683955924e-016
		,1.686306869e-016
		,1.698436297e-016
		,1.744387467e-016
		,1.892372961e-016
		,2.240769986e-016
		,2.741686545e-016
		,3.200953800e-016
		,3.536015758e-016
		,3.768990339e-016
		,3.935504295e-016
		,4.059049599e-016
		,4.153329930e-016
		,4.227031759e-016
		,4.286037870e-016
		,4.334385375e-016
		,4.374828146e-016
		,4.409266510e-016
		,4.439037445e-016
		,4.465104507e-016
		,4.488179279e-016
		,4.508799120e-016
		,1.766226057e-016
		,1.747464407e-016
		,1.736030750e-016
		,1.727857451e-016
		,1.721450182e-016
		,1.716180919e-016
		,1.711731306e-016
		,1.707902175e-016
		,1.704552326e-016
		,1.701574380e-016
		,1.698886055e-016
		,1.696425876e-016
		,1.694149562e-016
		,1.692026535e-016
		,1.690036614e-016
		,1.688168495e-016
		,1.686424078e-016
		,1.684841286e-016
		,1.683578991e-016
		,1.683222244e-016
		,1.685889821e-016
		,1.699227990e-016
		,1.749572968e-016
		,1.909988579e-016
		,2.276314072e-016
		,2.782656136e-016
		,3.234882304e-016
		,3.561798621e-016
		,3.789036794e-016
		,3.951562431e-016
		,4.071988114e-016
		,4.163769901e-016
		,4.235544260e-016
		,4.293102795e-016
		,4.340362117e-016
		,4.379974927e-016
		,4.413768431e-016
		,4.443029855e-016
		,4.468689055e-016
		,4.491434090e-016
		,4.511785039e-016
		,1.759547020e-016
		,1.742729951e-016
		,1.732328288e-016
		,1.724800883e-016
		,1.718856923e-016
		,1.713948814e-016
		,1.709790180e-016
		,1.706198177e-016
		,1.703040326e-016
		,1.700215996e-016
		,1.697649147e-016
		,1.695284195e-016
		,1.693082292e-016
		,1.691017477e-016
		,1.689073251e-016
		,1.687241200e-016
		,1.685525976e-016
		,1.683970144e-016
		,1.682746302e-016
		,1.682489836e-016
		,1.685514072e-016
		,1.700209847e-016
		,1.755428922e-016
		,1.929128134e-016
		,2.313017758e-016
		,2.823227786e-016
		,3.267892787e-016
		,3.586831989e-016
		,3.808501000e-016
		,3.967062547e-016
		,4.084391708e-016
		,4.173752669e-016
		,4.243693851e-016
		,4.299888274e-016
		,4.346123123e-016
		,4.384953567e-016
		,4.418138315e-016
		,4.446918393e-016
		,4.472192087e-016
		,4.494624985e-016
		,4.514720260e-016
		,1.753800698e-016
		,1.738619074e-016
		,1.729096660e-016
		,1.722130241e-016
		,1.716594133e-016
		,1.712009208e-016
		,1.708110826e-016
		,1.704719656e-016
		,1.701716165e-016
		,1.699011696e-016
		,1.696536841e-016
		,1.694242331e-016
		,1.692094261e-016
		,1.690070402e-016
		,1.688157395e-016
		,1.686349212e-016
		,1.684652914e-016
		,1.683115741e-016
		,1.681925196e-016
		,1.681772506e-016
		,1.685188272e-016
		,1.701393504e-016
		,1.761989314e-016
		,1.949776021e-016
		,2.350657025e-016
		,2.863221793e-016
		,3.299934116e-016
		,3.611093643e-016
		,3.827335417e-016
		,3.981963414e-016
		,4.096244918e-016
		,4.183286800e-016
		,4.251491155e-016
		,4.306400597e-016
		,4.351671306e-016
		,4.389764382e-016
		,4.422374655e-016
		,4.450700075e-016
		,4.475609123e-016
		,4.497745746e-016
		,4.517596520e-016
		,1.749808792e-016
		,1.735723324e-016
		,1.726859295e-016
		,1.720321918e-016
		,1.715068859e-016
		,1.710737638e-016
		,1.707223267e-016
		,1.704084045e-016
		,1.701198021e-016
		,1.698489914e-016
		,1.695984671e-016
		,1.693654715e-016
		,1.691477020e-016
		,1.689431333e-016
		,1.687500249e-016
		,1.685677028e-016
		,1.683968495e-016
		,1.682424977e-016
		,1.681249096e-016
		,1.681193453e-016
		,1.685031576e-016
		,1.702911374e-016
		,1.769432367e-016
		,1.972087570e-016
		,2.389211178e-016
		,2.902657328e-016
		,3.331098046e-016
		,3.634653644e-016
		,3.845567017e-016
		,3.996292008e-016
		,4.107599098e-016
		,4.192409835e-016
		,4.258973611e-016
		,4.312670744e-016
		,4.357031125e-016
		,4.394427029e-016
		,4.426493431e-016
		,4.454387757e-016
		,4.478950012e-016
		,4.500803109e-016
		,4.520417330e-016
		,1.757645906e-016
		,1.739573872e-016
		,1.730842730e-016
		,1.722920099e-016
		,1.717254797e-016
		,1.710917921e-016
		,1.708942947e-016
		,1.708172096e-016
		,1.707277029e-016
		,1.705163099e-016
		,1.701862191e-016
		,1.698615691e-016
		,1.695502969e-016
		,1.692635431e-016
		,1.690041559e-016
		,1.687685164e-016
		,1.685545647e-016
		,1.683657267e-016
		,1.682223155e-016
		,1.682054204e-016
		,1.686194003e-016
		,1.705846018e-016
		,1.778937917e-016
		,1.997436829e-016
		,2.430015899e-016
		,2.942703288e-016
		,3.362303276e-016
		,3.658171475e-016
		,3.863668897e-016
		,4.010419822e-016
		,4.118754182e-016
		,4.201375563e-016
		,4.266344068e-016
		,4.318864936e-016
		,4.362341622e-016
		,4.399059896e-016
		,4.430596855e-016
		,4.458070422e-016
		,4.482292453e-016
		,4.503864836e-016
		,4.523241609e-016
		,1.816583899e-016
		,1.767394204e-016
		,1.757788042e-016
		,1.744124299e-016
		,1.734277578e-016
		,1.726967279e-016
		,1.718606487e-016
		,1.722189975e-016
		,1.727065578e-016
		,1.728269120e-016
		,1.727421419e-016
		,1.722701203e-016
		,1.717099812e-016
		,1.711595980e-016
		,1.706461565e-016
		,1.701933998e-016
		,1.698050022e-016
		,1.694701447e-016
		,1.692077618e-016
		,1.691034906e-016
		,1.694973382e-016
		,1.716529112e-016
		,1.797925400e-016
		,2.035538018e-016
		,2.483647603e-016
		,2.992159698e-016
		,3.400031087e-016
		,3.686361098e-016
		,3.885137916e-016
		,4.027006312e-016
		,4.131777295e-016
		,4.211825320e-016
		,4.274935817e-016
		,4.326091265e-016
		,4.368543076e-016
		,4.404475263e-016
		,4.435397051e-016
		,4.462379713e-016
		,4.486201650e-016
		,4.507439859e-016
		,4.526529565e-016
		,1.931895708e-016
		,1.868478202e-016
		,1.822693915e-016
		,1.807302269e-016
		,1.783553731e-016
		,1.777249607e-016
		,1.772923916e-016
		,1.755372527e-016
		,1.755327033e-016
		,1.762483391e-016
		,1.762013416e-016
		,1.759586119e-016
		,1.754991369e-016
		,1.747077104e-016
		,1.738794888e-016
		,1.730410569e-016
		,1.722665484e-016
		,1.716050316e-016
		,1.710996962e-016
		,1.708178182e-016
		,1.711729760e-016
		,1.736637040e-016
		,1.831785360e-016
		,2.097582875e-016
		,2.563469990e-016
		,3.062328567e-016
		,3.452927384e-016
		,3.725731248e-016
		,3.914901153e-016
		,4.049860982e-016
		,4.149720287e-016
		,4.226253419e-016
		,4.286843851e-016
		,4.336148529e-016
		,4.377209320e-016
		,4.412071749e-016
		,4.442152054e-016
		,4.468456854e-016
		,4.491718051e-016
		,4.512478716e-016
		,4.531149700e-016
		,2.071216112e-016
		,2.027611859e-016
		,1.945423521e-016
		,1.904623625e-016
		,1.877036582e-016
		,1.863113843e-016
		,1.845101596e-016
		,1.837299576e-016
		,1.809949442e-016
		,1.800852866e-016
		,1.802712645e-016
		,1.802390472e-016
		,1.797957411e-016
		,1.791981891e-016
		,1.782997101e-016
		,1.772528257e-016
		,1.763084373e-016
		,1.752469356e-016
		,1.742561979e-016
		,1.735708593e-016
		,1.737991315e-016
		,1.767663550e-016
		,1.883456359e-016
		,2.186233379e-016
		,2.667774696e-016
		,3.149855584e-016
		,3.518091633e-016
		,3.773852294e-016
		,3.951006844e-016
		,4.077570352e-016
		,4.171564923e-016
		,4.243981048e-016
		,4.301610517e-016
		,4.348731977e-016
		,4.388139555e-016
		,4.421715739e-016
		,4.450766731e-016
		,4.476222858e-016
		,4.498762750e-016
		,4.518892961e-016
		,4.537000225e-016
		,2.234183051e-016
		,2.164944948e-016
		,2.124886188e-016
		,2.045216134e-016
		,1.989268576e-016
		,1.965847184e-016
		,1.943084972e-016
		,1.914229560e-016
		,1.900281897e-016
		,1.868756864e-016
		,1.854283190e-016
		,1.849124395e-016
		,1.841824098e-016
		,1.840584407e-016
		,1.833921365e-016
		,1.822963034e-016
		,1.809580516e-016
		,1.796886667e-016
		,1.790172128e-016
		,1.780919861e-016
		,1.781666367e-016
		,1.818971425e-016
		,1.964948434e-016
		,2.309924355e-016
		,2.796310098e-016
		,3.251439232e-016
		,3.591874643e-016
		,3.827440453e-016
		,3.990875140e-016
		,4.108202053e-016
		,4.195884911e-016
		,4.263888529e-016
		,4.318327385e-016
		,4.363066355e-016
		,4.400634960e-016
		,4.432744216e-016
		,4.460587204e-016
		,4.485019535e-016
		,4.506671417e-016
		,4.526018645e-016
		,4.543429014e-016
		,2.396129913e-016
		,2.294175227e-016
		,2.254740094e-016
		,2.217447194e-016
		,2.139724017e-016
		,2.075171530e-016
		,2.060447100e-016
		,2.016604249e-016
		,1.991374614e-016
		,1.961926826e-016
		,1.913237658e-016
		,1.900994925e-016
		,1.892900028e-016
		,1.884995919e-016
		,1.879013733e-016
		,1.875860033e-016
		,1.866050432e-016
		,1.852002032e-016
		,1.836954352e-016
		,1.825368519e-016
		,1.840066159e-016
		,1.899594086e-016
		,2.093136843e-016
		,2.476727300e-016
		,2.949494433e-016
		,3.365594573e-016
		,3.672233538e-016
		,3.885004330e-016
		,4.033841721e-016
		,4.141552714e-016
		,4.222743836e-016
		,4.286068530e-016
		,4.337024085e-016
		,4.379088265e-016
		,4.414537074e-016
		,4.444918286e-016
		,4.471320454e-016
		,4.494530829e-016
		,4.515134390e-016
		,4.533576268e-016
		,4.550201892e-016
		,2.524822907e-016
		,2.388847258e-016
		,2.320064633e-016
		,2.318889050e-016
		,2.295483587e-016
		,2.215952695e-016
		,2.164714166e-016
		,2.138456948e-016
		,2.090157545e-016
		,2.062541427e-016
		,2.025130758e-016
		,1.971372121e-016
		,1.944386917e-016
		,1.937984911e-016
		,1.906098060e-016
		,1.917804194e-016
		,1.910536764e-016
		,1.908631263e-016
		,1.895744490e-016
		,1.882700273e-016
		,1.889761592e-016
		,1.963886739e-016
		,2.227137763e-016
		,2.682499193e-016
		,3.135654673e-016
		,3.501005654e-016
		,3.766677840e-016
		,3.951983712e-016
		,4.083085434e-016
		,4.179205675e-016
		,4.252470039e-016
		,4.310259890e-016
		,4.357157762e-016
		,4.396122423e-016
		,4.429131515e-016
		,4.457548880e-016
		,4.482342712e-016
		,4.504218731e-016
		,4.523704844e-016
		,4.541203048e-016
		,4.557026654e-016
		,2.749061147e-016
		,2.483428651e-016
		,2.442444099e-016
		,2.381318191e-016
		,2.366578195e-016
		,2.325778572e-016
		,2.276950174e-016
		,2.233366125e-016
		,2.206757745e-016
		,2.159413296e-016
		,2.126569854e-016
		,2.087472272e-016
		,2.022987811e-016
		,1.972285888e-016
		,1.971528979e-016
		,1.949058006e-016
		,1.950605363e-016
		,1.952192981e-016
		,1.941565939e-016
		,1.936056077e-016
		,1.932138734e-016
		,1.989772216e-016
		,2.245877446e-016
		,2.775800435e-016
		,3.287372991e-016
		,3.630027626e-016
		,3.856751049e-016
		,4.015718677e-016
		,4.135173750e-016
		,4.224120423e-016
		,4.291636745e-016
		,4.344924735e-016
		,4.388438292e-016
		,4.423645194e-016
		,4.454354112e-016
		,4.480812004e-016
		,4.503867759e-016
		,4.524213658e-016
		,4.542358132e-016
		,4.558669428e-016
		,4.573463891e-016
		,2.845077450e-016
		,2.730507017e-016
		,2.520913726e-016
		,2.486519895e-016
		,2.435751290e-016
		,2.420428333e-016
		,2.379922642e-016
		,2.347691683e-016
		,2.283142122e-016
		,2.241779709e-016
		,2.173577651e-016
		,2.156164077e-016
		,2.140608077e-016
		,2.087812544e-016
		,2.035589488e-016
		,1.996563510e-016
		,1.985345735e-016
		,1.973308956e-016
		,1.989101166e-016
		,1.983226683e-016
		,1.978196211e-016
		,2.006097609e-016
		,2.135501592e-016
		,2.559056706e-016
		,3.181772038e-016
		,3.661924304e-016
		,3.947116027e-016
		,4.113021018e-016
		,4.218951596e-016
		,4.293943949e-016
		,4.350908105e-016
		,4.396224887e-016
		,4.433456925e-016
		,4.464774707e-016
		,4.491593127e-016
		,4.514883657e-016
		,4.535341801e-016
		,4.553483209e-016
		,4.569701894e-016
		,4.584289165e-016
		,4.597524719e-016
		,2.947199406e-016
		,2.878215200e-016
		,2.701415939e-016
		,2.563642413e-016
		,2.520444216e-016
		,2.487220667e-016
		,2.463056795e-016
		,2.368030126e-016
		,2.344850228e-016
		,2.289006254e-016
		,2.268502643e-016
		,2.237817770e-016
		,2.199130550e-016
		,2.189697218e-016
		,2.152692082e-016
		,2.096035206e-016
		,2.034045317e-016
		,2.016076236e-016
		,2.009114836e-016
		,2.006298000e-016
		,2.031374905e-016
		,2.042832247e-016
		,2.110486936e-016
		,2.331149713e-016
		,2.744513292e-016
		,3.314514226e-016
		,3.807275673e-016
		,4.114254915e-016
		,4.277736432e-016
		,4.370953888e-016
		,4.432375113e-016
		,4.472297705e-016
		,4.509069167e-016
		,4.538453612e-016
		,4.562871052e-016
		,4.583669773e-016
		,4.601642998e-016
		,4.617465039e-016
		,4.631411517e-016
		,4.643847045e-016
		,4.655020884e-016
		,3.037832264e-016
		,2.972838620e-016
		,2.901520614e-016
		,2.665313165e-016
		,2.523602695e-016
		,2.420368828e-016
		,2.429200684e-016
		,2.429530702e-016
		,2.407868185e-016
		,2.449601813e-016
		,2.354738877e-016
		,2.330943579e-016
		,2.293266475e-016
		,2.253909122e-016
		,2.236425739e-016
		,2.203448271e-016
		,2.148116841e-016
		,2.094068371e-016
		,2.030467927e-016
		,2.048138538e-016
		,2.048779177e-016
		,2.076773001e-016
		,2.151477029e-016
		,2.255382979e-016
		,2.490336365e-016
		,2.893420097e-016
		,3.366113189e-016
		,3.805889100e-016
		,4.143695075e-016
		,4.357610373e-016
		,4.473232298e-016
		,4.540946539e-016
		,4.583214625e-016
		,4.614849787e-016
		,4.642199504e-016
		,4.651923946e-016
		,4.670293387e-016
		,4.685348123e-016
		,4.697846173e-016
		,4.708531541e-016
		,4.717829384e-016
		,2.933490860e-016
		,2.907381213e-016
		,2.869694511e-016
		,2.825605905e-016
		,2.576506469e-016
		,2.567993802e-016
		,2.536636129e-016
		,2.505698409e-016
		,2.484114499e-016
		,2.483882858e-016
		,2.507775980e-016
		,2.416246090e-016
		,2.385092330e-016
		,2.345075655e-016
		,2.299991526e-016
		,2.280440828e-016
		,2.257149134e-016
		,2.209486744e-016
		,2.142818294e-016
		,2.091915535e-016
		,2.070410191e-016
		,2.103561552e-016
		,2.176477937e-016
		,2.282627555e-016
		,2.448616711e-016
		,2.653974469e-016
		,2.976446873e-016
		,3.370791123e-016
		,3.750727581e-016
		,4.082444792e-016
		,4.336567928e-016
		,4.516277814e-016
		,4.624270002e-016
		,4.675033249e-016
		,4.708916101e-016
		,4.732045185e-016
		,4.750268414e-016
		,4.766947776e-016
		,4.764073398e-016
		,4.774202334e-016
		,4.782356958e-016
		,3.014709810e-016
		,2.970301065e-016
		,2.936057727e-016
		,2.886345522e-016
		,2.640097167e-016
		,2.638736126e-016
		,2.597889462e-016
		,2.554948638e-016
		,2.520324446e-016
		,2.555832818e-016
		,2.553681711e-016
		,2.472352366e-016
		,2.431475546e-016
		,2.393236125e-016
		,2.340444929e-016
		,2.294975989e-016
		,2.304217350e-016
		,2.261531484e-016
		,2.217178309e-016
		,2.177203196e-016
		,2.155727566e-016
		,2.210640346e-016
		,2.301269192e-016
		,2.459227397e-016
		,2.632345019e-016
		,2.817355462e-016
		,3.032871774e-016
		,3.258569417e-016
		,3.439277790e-016
		,3.682259874e-016
		,3.981727275e-016
		,4.243571619e-016
		,4.458769385e-016
		,4.613860700e-016
		,4.716514722e-016
		,4.784225494e-016
		,4.811954575e-016
		,4.830471770e-016
		,4.845025639e-016
		,4.856912822e-016
		,4.854390904e-016
		,3.083691064e-016
		,3.038220790e-016
		,2.998251640e-016
		,2.956871314e-016
		,2.893766763e-016
		,2.700066043e-016
		,2.692262743e-016
		,2.651216305e-016
		,2.596778821e-016
		,2.554862550e-016
		,2.625552189e-016
		,2.597662895e-016
		,2.514678605e-016
		,2.428346371e-016
		,2.413242829e-016
		,2.374383722e-016
		,2.342810104e-016
		,2.350808380e-016
		,2.325168263e-016
		,2.301735620e-016
		,2.284501857e-016
		,2.321004121e-016
		,2.370287735e-016
		,2.508210365e-016
		,2.625891460e-016
		,2.741339731e-016
		,2.989314233e-016
		,3.119971370e-016
		,3.310491079e-016
		,3.519783383e-016
		,3.677127721e-016
		,3.875852800e-016
		,4.103705287e-016
		,4.320230055e-016
		,4.503840135e-016
		,4.654850145e-016
		,4.769824172e-016
		,4.845054071e-016
		,4.902858222e-016
		,4.917725558e-016
		,4.933211282e-016
		,1.780355778e-016
		,1.758118742e-016
		,1.744685698e-016
		,1.735198699e-016
		,1.727825525e-016
		,1.721793110e-016
		,1.716718576e-016
		,1.712371900e-016
		,1.708604752e-016
		,1.705295170e-016
		,1.702361738e-016
		,1.699757464e-016
		,1.697388092e-016
		,1.695287847e-016
		,1.693470844e-016
		,1.691822014e-016
		,1.690491904e-016
		,1.689801380e-016
		,1.689774552e-016
		,1.691050925e-016
		,1.696398779e-016
		,1.712493144e-016
		,1.762431881e-016
		,1.911235628e-016
		,2.248928030e-016
		,2.736654716e-016
		,3.193491929e-016
		,3.530857994e-016
		,3.765484378e-016
		,3.932731179e-016
		,4.056573590e-016
		,4.151149531e-016
		,4.225078696e-016
		,4.284225052e-016
		,4.332656143e-016
		,4.373164481e-016
		,4.407653854e-016
		,4.437453025e-016
		,4.463527114e-016
		,4.486602547e-016
		,4.507233561e-016
		,1.771854111e-016
		,1.752146929e-016
		,1.740074200e-016
		,1.731424034e-016
		,1.724632504e-016
		,1.719039092e-016
		,1.714310251e-016
		,1.710242382e-016
		,1.706691228e-016
		,1.703547901e-016
		,1.700726629e-016
		,1.698162779e-016
		,1.695810777e-016
		,1.693633871e-016
		,1.691610714e-016
		,1.689735394e-016
		,1.688014359e-016
		,1.686477003e-016
		,1.685302149e-016
		,1.685094295e-016
		,1.687930488e-016
		,1.701101536e-016
		,1.750077449e-016
		,1.905785135e-016
		,2.264678250e-016
		,2.768818958e-016
		,3.224529544e-016
		,3.555304937e-016
		,3.785110526e-016
		,3.949067975e-016
		,4.070184275e-016
		,4.162303201e-016
		,4.234247468e-016
		,4.291928612e-016
		,4.339293502e-016
		,4.379012457e-016
		,4.412917879e-016
		,4.442294386e-016
		,4.468067499e-016
		,4.490921770e-016
		,4.511374706e-016
		,1.764509494e-016
		,1.746925646e-016
		,1.735995037e-016
		,1.728062733e-016
		,1.721785490e-016
		,1.716592894e-016
		,1.712189941e-016
		,1.708390152e-016
		,1.705058759e-016
		,1.702092300e-016
		,1.699411209e-016
		,1.696955712e-016
		,1.694682816e-016
		,1.692563024e-016
		,1.690576815e-016
		,1.688712900e-016
		,1.686974981e-016
		,1.685404027e-016
		,1.684167168e-016
		,1.683876443e-016
		,1.686768788e-016
		,1.700933981e-016
		,1.754217159e-016
		,1.922686899e-016
		,2.300115804e-016
		,2.809916446e-016
		,3.258537539e-016
		,3.581092754e-016
		,3.805012549e-016
		,3.964765941e-016
		,4.082654057e-016
		,4.172297242e-016
		,4.242396670e-016
		,4.298720653e-016
		,4.345077953e-016
		,4.384029123e-016
		,4.417333542e-016
		,4.446231373e-016
		,4.471619563e-016
		,4.494162225e-016
		,4.514360966e-016
		,1.758065731e-016
		,1.742272985e-016
		,1.732312770e-016
		,1.725003977e-016
		,1.719183920e-016
		,1.714353279e-016
		,1.710245877e-016
		,1.706688637e-016
		,1.703554602e-016
		,1.700746603e-016
		,1.698191020e-016
		,1.695834003e-016
		,1.693637901e-016
		,1.691577572e-016
		,1.689637046e-016
		,1.687808332e-016
		,1.686096765e-016
		,1.684547191e-016
		,1.683340975e-016
		,1.683147770e-016
		,1.686416399e-016
		,1.702060394e-016
		,1.760686349e-016
		,1.943469025e-016
		,2.338848820e-016
		,2.851692787e-016
		,3.292145272e-016
		,3.606497677e-016
		,3.824643086e-016
		,3.980212951e-016
		,4.094903135e-016
		,4.182130871e-016
		,4.250448056e-016
		,4.305456829e-016
		,4.350829386e-016
		,4.389028510e-016
		,4.421747126e-016
		,4.450180754e-016
		,4.475195608e-016
		,4.497433486e-016
		,4.517378778e-016
		,1.752368424e-016
		,1.738098015e-016
		,1.728972370e-016
		,1.722211168e-016
		,1.716799061e-016
		,1.712292683e-016
		,1.708448670e-016
		,1.705105020e-016
		,1.702142186e-016
		,1.699469626e-016
		,1.697020073e-016
		,1.694745622e-016
		,1.692613853e-016
		,1.690603862e-016
		,1.688702922e-016
		,1.686905546e-016
		,1.685219665e-016
		,1.683695257e-016
		,1.682530246e-016
		,1.682456925e-016
		,1.686168641e-016
		,1.703511451e-016
		,1.768129247e-016
		,1.966146227e-016
		,2.378714104e-016
		,2.892928582e-016
		,3.324819846e-016
		,3.631153815e-016
		,3.843637210e-016
		,3.995071138e-016
		,4.106651096e-016
		,4.191563632e-016
		,4.258199288e-016
		,4.311967978e-016
		,4.356410313e-016
		,4.393896895e-016
		,4.426058983e-016
		,4.454050423e-016
		,4.478708011e-016
		,4.500651661e-016
		,4.520348797e-016
		,1.747339432e-016
		,1.734376485e-016
		,1.725977290e-016
		,1.719700768e-016
		,1.714652215e-016
		,1.710433189e-016
		,1.706819314e-016
		,1.703658995e-016
		,1.700839828e-016
		,1.698277993e-016
		,1.695912973e-016
		,1.693702943e-016
		,1.691620417e-016
		,1.689648379e-016
		,1.687776923e-016
		,1.686002692e-016
		,1.684336010e-016
		,1.682832259e-016
		,1.681707796e-016
		,1.681765378e-016
		,1.685973811e-016
		,1.705224302e-016
		,1.776473076e-016
		,1.990533605e-016
		,2.419343339e-016
		,2.933409370e-016
		,3.356491235e-016
		,3.654994252e-016
		,3.861917922e-016
		,4.009290370e-016
		,4.117863717e-016
		,4.200593355e-016
		,4.265639176e-016
		,4.318240615e-016
		,4.361806279e-016
		,4.398619853e-016
		,4.430254870e-016
		,4.457825699e-016
		,4.482140862e-016
		,4.503799104e-016
		,4.523251621e-016
		,1.742998171e-016
		,1.731149545e-016
		,1.723385735e-016
		,1.717538166e-016
		,1.712810354e-016
		,1.708843807e-016
		,1.705423570e-016
		,1.702423184e-016
		,1.699731531e-016
		,1.697260241e-016
		,1.694955953e-016
		,1.692785776e-016
		,1.690731051e-016
		,1.688778667e-016
		,1.686921455e-016
		,1.685157669e-016
		,1.683499379e-016
		,1.682007571e-016
		,1.680918960e-016
		,1.681115314e-016
		,1.685875728e-016
		,1.707261435e-016
		,1.785817845e-016
		,2.016629237e-016
		,2.460526364e-016
		,2.973029194e-016
		,3.387146226e-016
		,3.677997094e-016
		,3.879464207e-016
		,4.022875269e-016
		,4.128571527e-016
		,4.209230322e-016
		,4.272782851e-016
		,4.324285516e-016
		,4.367024226e-016
		,4.403201221e-016
		,4.434335708e-016
		,4.461504512e-016
		,4.485489030e-016
		,4.506867806e-016
		,4.526076958e-016
		,1.740670904e-016
		,1.729171152e-016
		,1.721902353e-016
		,1.716269766e-016
		,1.711764367e-016
		,1.707974618e-016
		,1.704504002e-016
		,1.701607833e-016
		,1.699233899e-016
		,1.696942738e-016
		,1.694804397e-016
		,1.692630972e-016
		,1.690489542e-016
		,1.688447395e-016
		,1.686507833e-016
		,1.684677101e-016
		,1.682968776e-016
		,1.681443840e-016
		,1.680359190e-016
		,1.680683474e-016
		,1.686044753e-016
		,1.709816096e-016
		,1.796418230e-016
		,2.044617097e-016
		,2.502289646e-016
		,3.011897088e-016
		,3.416915433e-016
		,3.700243466e-016
		,3.896340355e-016
		,4.035883506e-016
		,4.138847889e-016
		,4.217531998e-016
		,4.279672661e-016
		,4.330135626e-016
		,4.372090029e-016
		,4.407661065e-016
		,4.438316381e-016
		,4.465096927e-016
		,4.488758221e-016
		,4.509859875e-016
		,4.528824424e-016
		,1.754391833e-016
		,1.736455053e-016
		,1.728208908e-016
		,1.720713177e-016
		,1.715864495e-016
		,1.711173093e-016
		,1.705927677e-016
		,1.700384683e-016
		,1.698993934e-016
		,1.699925134e-016
		,1.699202842e-016
		,1.699460666e-016
		,1.697502835e-016
		,1.694545730e-016
		,1.691693008e-016
		,1.688922193e-016
		,1.686377841e-016
		,1.684174083e-016
		,1.682574950e-016
		,1.682629934e-016
		,1.688360250e-016
		,1.714647069e-016
		,1.810178359e-016
		,2.076608172e-016
		,2.546596024e-016
		,3.051625660e-016
		,3.446977235e-016
		,3.722563590e-016
		,3.913164210e-016
		,4.048823000e-016
		,4.149047743e-016
		,4.225802438e-016
		,4.286555167e-016
		,4.335994515e-016
		,4.377174303e-016
		,4.412144063e-016
		,4.442320524e-016
		,4.468709110e-016
		,4.492040023e-016
		,4.512854909e-016
		,4.531564012e-016
		,1.818504871e-016
		,1.781869690e-016
		,1.759790806e-016
		,1.746190599e-016
		,1.732321848e-016
		,1.729506057e-016
		,1.718796021e-016
		,1.710655323e-016
		,1.701645950e-016
		,1.707313146e-016
		,1.715704698e-016
		,1.717501277e-016
		,1.721239823e-016
		,1.720201560e-016
		,1.715260734e-016
		,1.710310069e-016
		,1.705336336e-016
		,1.700745848e-016
		,1.697110028e-016
		,1.695719714e-016
		,1.701109152e-016
		,1.730339438e-016
		,1.837705334e-016
		,2.126285708e-016
		,2.607188059e-016
		,3.103017244e-016
		,3.485085776e-016
		,3.750512757e-016
		,3.934019781e-016
		,4.064772414e-016
		,4.161596210e-016
		,4.235975934e-016
		,4.295023476e-016
		,4.343204516e-016
		,4.383429315e-016
		,4.417653638e-016
		,4.447231233e-016
		,4.473124217e-016
		,4.496032828e-016
		,4.516478331e-016
		,4.534857680e-016
		,1.933685485e-016
		,1.904254019e-016
		,1.823715923e-016
		,1.796379613e-016
		,1.779770972e-016
		,1.773453434e-016
		,1.765088111e-016
		,1.752903619e-016
		,1.743897061e-016
		,1.734399694e-016
		,1.738872615e-016
		,1.746332556e-016
		,1.752020420e-016
		,1.753581162e-016
		,1.752315578e-016
		,1.746575259e-016
		,1.739316521e-016
		,1.732289659e-016
		,1.725403158e-016
		,1.720909488e-016
		,1.725234000e-016
		,1.759575093e-016
		,1.886477870e-016
		,2.206576821e-016
		,2.697045235e-016
		,3.176258358e-016
		,3.538751900e-016
		,3.789601714e-016
		,3.963076051e-016
		,4.087013535e-016
		,4.179169181e-016
		,4.250297607e-016
		,4.307005700e-016
		,4.353450350e-016
		,4.392344163e-016
		,4.425515523e-016
		,4.454233758e-016
		,4.479404087e-016
		,4.501688779e-016
		,4.521584665e-016
		,4.539473777e-016
		,2.072745563e-016
		,2.021675165e-016
		,1.966554683e-016
		,1.884952834e-016
		,1.868160338e-016
		,1.852660219e-016
		,1.846869161e-016
		,1.822938124e-016
		,1.818691846e-016
		,1.796878466e-016
		,1.790067469e-016
		,1.787037489e-016
		,1.782798468e-016
		,1.791960672e-016
		,1.793568978e-016
		,1.789279029e-016
		,1.781725211e-016
		,1.772839254e-016
		,1.766386220e-016
		,1.761500617e-016
		,1.765998279e-016
		,1.808590483e-016
		,1.964531268e-016
		,2.321929507e-016
		,2.814060254e-016
		,3.267275508e-016
		,3.604188094e-016
		,3.836805231e-016
		,3.998128186e-016
		,4.113982316e-016
		,4.200640904e-016
		,4.267918537e-016
		,4.321825569e-016
		,4.366159300e-016
		,4.403405225e-016
		,4.435246198e-016
		,4.462857279e-016
		,4.487083655e-016
		,4.508549626e-016
		,4.527728032e-016
		,4.544984800e-016
		,2.230444504e-016
		,2.131131349e-016
		,2.101467254e-016
		,2.063784156e-016
		,1.994242270e-016
		,1.956284262e-016
		,1.933822511e-016
		,1.913084885e-016
		,1.895342612e-016
		,1.886441615e-016
		,1.852581605e-016
		,1.849692449e-016
		,1.841970749e-016
		,1.827338784e-016
		,1.831807359e-016
		,1.833738071e-016
		,1.831032419e-016
		,1.821140329e-016
		,1.811102768e-016
		,1.805445787e-016
		,1.816424941e-016
		,1.884023072e-016
		,2.086657482e-016
		,2.480952472e-016
		,2.957494482e-016
		,3.373049450e-016
		,3.678133721e-016
		,3.889303850e-016
		,4.036948365e-016
		,4.144097208e-016
		,4.224853803e-016
		,4.287980471e-016
		,4.338811625e-016
		,4.380739926e-016
		,4.416047358e-016
		,4.446289694e-016
		,4.472560982e-016
		,4.495651793e-016
		,4.516147730e-016
		,4.534492626e-016
		,4.551031383e-016
		,2.301965604e-016
		,2.247549080e-016
		,2.207930366e-016
		,2.206599027e-016
		,2.171998223e-016
		,2.097959018e-016
		,2.036023699e-016
		,2.018688447e-016
		,1.993569238e-016
		,1.977082952e-016
		,1.958696413e-016
		,1.919103389e-016
		,1.892783442e-016
		,1.891870287e-016
		,1.861260050e-016
		,1.866381771e-016
		,1.878219880e-016
		,1.872322856e-016
		,1.863339443e-016
		,1.855408421e-016
		,1.865833095e-016
		,1.945628593e-016
		,2.206164613e-016
		,2.669665346e-016
		,3.134359101e-016
		,3.501816594e-016
		,3.767455471e-016
		,3.953015832e-016
		,4.084109330e-016
		,4.180124819e-016
		,4.253334375e-016
		,4.311053704e-016
		,4.357884012e-016
		,4.396788396e-016
		,4.429745369e-016
		,4.458118973e-016
		,4.482875617e-016
		,4.504720331e-016
		,4.524179535e-016
		,4.541654988e-016
		,4.557458101e-016
		,2.511127817e-016
		,2.336950778e-016
		,2.303478769e-016
		,2.265105981e-016
		,2.260614116e-016
		,2.222086466e-016
		,2.160145026e-016
		,2.119617794e-016
		,2.096187740e-016
		,2.088543367e-016
		,2.051213412e-016
		,2.024993223e-016
		,1.979613896e-016
		,1.942192976e-016
		,1.925977455e-016
		,1.902162785e-016
		,1.904396494e-016
		,1.914533478e-016
		,1.910229312e-016
		,1.902216072e-016
		,1.905941820e-016
		,1.965144105e-016
		,2.218092846e-016
		,2.755962293e-016
		,3.279031657e-016
		,3.627380611e-016
		,3.855722102e-016
		,4.012234124e-016
		,4.125917938e-016
		,4.214724313e-016
		,4.284901459e-016
		,4.340469484e-016
		,4.385115826e-016
		,4.422205938e-016
		,4.453608647e-016
		,4.479772176e-016
		,4.503233613e-016
		,4.523927949e-016
		,4.542298391e-016
		,4.558764622e-016
		,4.573648303e-016
		,2.690333276e-016
		,2.513870232e-016
		,2.413201136e-016
		,2.365466681e-016
		,2.344681776e-016
		,2.331782509e-016
		,2.290257514e-016
		,2.221414066e-016
		,2.164230221e-016
		,2.163028039e-016
		,2.128907267e-016
		,2.096508100e-016
		,2.073062405e-016
		,2.046248986e-016
		,2.007066015e-016
		,1.960869688e-016
		,1.938253899e-016
		,1.942645508e-016
		,1.944734229e-016
		,1.955486451e-016
		,1.949270232e-016
		,1.974534216e-016
		,2.109724452e-016
		,2.533738508e-016
		,3.164003223e-016
		,3.652852646e-016
		,3.939756360e-016
		,4.108427915e-016
		,4.215738168e-016
		,4.291668841e-016
		,4.349329292e-016
		,4.395169171e-016
		,4.432766054e-016
		,4.464381680e-016
		,4.491448920e-016
		,4.514951779e-016
		,4.535576385e-016
		,4.553867132e-016
		,4.570236881e-016
		,4.584979521e-016
		,4.598344448e-016
		,2.815781365e-016
		,2.753055984e-016
		,2.522277541e-016
		,2.478817283e-016
		,2.424835979e-016
		,2.406455638e-016
		,2.388668500e-016
		,2.345619742e-016
		,2.230479595e-016
		,2.168665885e-016
		,2.204950318e-016
		,2.182202848e-016
		,2.145650870e-016
		,2.109343370e-016
		,2.117020052e-016
		,2.072804536e-016
		,2.016426640e-016
		,1.960583487e-016
		,1.972846961e-016
		,1.985934814e-016
		,1.988258134e-016
		,2.019368948e-016
		,2.085097017e-016
		,2.303238417e-016
		,2.735579840e-016
		,3.308080756e-016
		,3.803779832e-016
		,4.113365913e-016
		,4.276366839e-016
		,4.368392721e-016
		,4.431100679e-016
		,4.470177706e-016
		,4.506431159e-016
		,4.536328890e-016
		,4.561006596e-016
		,4.582007993e-016
		,4.600184928e-016
		,4.616100340e-016
		,4.630170666e-016
		,4.642714056e-016
		,4.653982939e-016
		,2.925325140e-016
		,2.864075944e-016
		,2.782096786e-016
		,2.533791646e-016
		,2.527364263e-016
		,2.424219139e-016
		,2.331162438e-016
		,2.355588478e-016
		,2.344569127e-016
		,2.295202832e-016
		,2.252185426e-016
		,2.273002004e-016
		,2.242152286e-016
		,2.209036296e-016
		,2.164337699e-016
		,2.163953298e-016
		,2.115762840e-016
		,2.074366736e-016
		,2.018739825e-016
		,1.985802217e-016
		,2.021112761e-016
		,2.054878837e-016
		,2.113605310e-016
		,2.235114775e-016
		,2.472021034e-016
		,2.877313185e-016
		,3.374442931e-016
		,3.823367886e-016
		,4.155909635e-016
		,4.370095958e-016
		,4.473899168e-016
		,4.541075516e-016
		,4.582785813e-016
		,4.613582997e-016
		,4.640145619e-016
		,4.653803069e-016
		,4.668636394e-016
		,4.683892232e-016
		,4.696587803e-016
		,4.707369565e-016
		,4.716702121e-016
		,3.019340800e-016
		,2.963487753e-016
		,2.765543558e-016
		,2.602796992e-016
		,2.436222136e-016
		,2.478958985e-016
		,2.443420909e-016
		,2.449283512e-016
		,2.439851140e-016
		,2.410154965e-016
		,2.362079027e-016
		,2.320911851e-016
		,2.334344492e-016
		,2.300641224e-016
		,2.269576877e-016
		,2.218029767e-016
		,2.199635484e-016
		,2.181396548e-016
		,2.124298317e-016
		,2.073824290e-016
		,2.027520426e-016
		,2.070501974e-016
		,2.151768127e-016
		,2.256779965e-016
		,2.418449817e-016
		,2.641654336e-016
		,2.970830031e-016
		,3.373310967e-016
		,3.772889887e-016
		,4.114608854e-016
		,4.365965536e-016
		,4.532961857e-016
		,4.632042006e-016
		,4.690318021e-016
		,4.711427593e-016
		,4.733873841e-016
		,4.751084154e-016
		,4.767061182e-016
		,4.767997074e-016
		,4.774136310e-016
		,4.782309231e-016
		,2.923680059e-016
		,2.883363314e-016
		,2.841317204e-016
		,2.720257043e-016
		,2.563936315e-016
		,2.574990080e-016
		,2.531888414e-016
		,2.513207990e-016
		,2.487098668e-016
		,2.460137957e-016
		,2.402911515e-016
		,2.402241867e-016
		,2.393073521e-016
		,2.355636423e-016
		,2.312762257e-016
		,2.260588558e-016
		,2.225423373e-016
		,2.236728949e-016
		,2.191029394e-016
		,2.162309144e-016
		,2.133848529e-016
		,2.149745441e-016
		,2.288315751e-016
		,2.435674261e-016
		,2.610288088e-016
		,2.797527605e-016
		,3.030401184e-016
		,3.263452583e-016
		,3.452249926e-016
		,3.703030134e-016
		,4.008329003e-016
		,4.295183444e-016
		,4.505300959e-016
		,4.652173225e-016
		,4.743355288e-016
		,4.797047831e-016
		,4.831169889e-016
		,4.836378706e-016
		,4.848913930e-016
		,4.859523689e-016
		,4.859101597e-016
		,3.008840564e-016
		,2.958628280e-016
		,2.920303907e-016
		,2.881184174e-016
		,2.761401873e-016
		,2.650239629e-016
		,2.646475394e-016
		,2.594769969e-016
		,2.558232127e-016
		,2.532546182e-016
		,2.506618943e-016
		,2.448842664e-016
		,2.476134881e-016
		,2.407409312e-016
		,2.376433014e-016
		,2.341603842e-016
		,2.321674984e-016
		,2.271137925e-016
		,2.287859431e-016
		,2.281265542e-016
		,2.265370967e-016
		,2.293548903e-016
		,2.355357156e-016
		,2.454776668e-016
		,2.608809382e-016
		,2.739195781e-016
		,2.970537725e-016
		,3.108223796e-016
		,3.317557376e-016
		,3.541369720e-016
		,3.702498977e-016
		,3.907296560e-016
		,4.141690615e-016
		,4.374487372e-016
		,4.569617664e-016
		,4.710530270e-016
		,4.815332937e-016
		,4.874918616e-016
		,4.923295379e-016
		,4.939473400e-016
		,4.942880851e-016
		,1.770448487e-016
		,1.751843601e-016
		,1.740247456e-016
		,1.731834100e-016
		,1.725183069e-016
		,1.719693448e-016
		,1.715062566e-016
		,1.711104956e-016
		,1.707686469e-016
		,1.704699265e-016
		,1.702105869e-016
		,1.699801785e-016
		,1.697844734e-016
		,1.696353114e-016
		,1.694951393e-016
		,1.694332043e-016
		,1.694633774e-016
		,1.695506748e-016
		,1.698666213e-016
		,1.705347242e-016
		,1.715608734e-016
		,1.740479501e-016
		,1.809731370e-016
		,1.981753497e-016
		,2.333184614e-016
		,2.814782298e-016
		,3.252490671e-016
		,3.573184038e-016
		,3.796800548e-016
		,3.957535122e-016
		,4.076816157e-016
		,4.167472498e-016
		,4.238116594e-016
		,4.294593402e-016
		,4.340831823e-016
		,4.379529673e-016
		,4.412568010e-016
		,4.441282561e-016
		,4.466615951e-016
		,4.489219545e-016
		,4.509551044e-016
		,1.763281939e-016
		,1.746633612e-016
		,1.736098407e-016
		,1.728355253e-016
		,1.722180795e-016
		,1.717050523e-016
		,1.712688730e-016
		,1.708918917e-016
		,1.705612183e-016
		,1.702670917e-016
		,1.700013632e-016
		,1.697593159e-016
		,1.695359493e-016
		,1.693290109e-016
		,1.691397156e-016
		,1.689637320e-016
		,1.688061170e-016
		,1.686803002e-016
		,1.686029003e-016
		,1.686322806e-016
		,1.690397763e-016
		,1.707013968e-016
		,1.765423913e-016
		,1.943184543e-016
		,2.329598391e-016
		,2.839017453e-016
		,3.282602523e-016
		,3.600367156e-016
		,3.820743286e-016
		,3.977630493e-016
		,4.093006077e-016
		,4.180561249e-016
		,4.249062614e-016
		,4.304239280e-016
		,4.349785762e-016
		,4.388148629e-016
		,4.421009599e-016
		,4.449562690e-016
		,4.474678188e-016
		,4.497002398e-016
		,4.517021305e-016
		,1.757044037e-016
		,1.742062698e-016
		,1.732445545e-016
		,1.725302177e-016
		,1.719572261e-016
		,1.714795040e-016
		,1.710720697e-016
		,1.707184211e-016
		,1.704063323e-016
		,1.701263920e-016
		,1.698714671e-016
		,1.696362873e-016
		,1.694172809e-016
		,1.692119581e-016
		,1.690187648e-016
		,1.688372581e-016
		,1.686682372e-016
		,1.685159926e-016
		,1.684006486e-016
		,1.683940881e-016
		,1.687556585e-016
		,1.704303345e-016
		,1.766630214e-016
		,1.958706067e-016
		,2.364825544e-016
		,2.879301880e-016
		,3.315382974e-016
		,3.625278535e-016
		,3.839901694e-016
		,3.992462434e-016
		,4.104622460e-016
		,4.189882137e-016
		,4.256748900e-016
		,4.310708382e-016
		,4.355322027e-016
		,4.392967729e-016
		,4.425278205e-016
		,4.453406959e-016
		,4.478189963e-016
		,4.500246045e-016
		,4.520041568e-016
		,1.751504569e-016
		,1.737951521e-016
		,1.729134312e-016
		,1.722526989e-016
		,1.717202369e-016
		,1.712750079e-016
		,1.708940811e-016
		,1.705619624e-016
		,1.702671142e-016
		,1.700007595e-016
		,1.697563668e-016
		,1.695292823e-016
		,1.693163578e-016
		,1.691155696e-016
		,1.689256803e-016
		,1.687461798e-016
		,1.685779665e-016
		,1.684263449e-016
		,1.683121765e-016
		,1.683130949e-016
		,1.687157938e-016
		,1.705708276e-016
		,1.774529030e-016
		,1.982844315e-016
		,2.406343218e-016
		,2.921456365e-016
		,3.348522266e-016
		,3.650171465e-016
		,3.858885299e-016
		,4.007148027e-016
		,4.116165045e-016
		,4.199157038e-016
		,4.264395074e-016
		,4.317163669e-016
		,4.360884749e-016
		,4.397845382e-016
		,4.429619191e-016
		,4.457319404e-016
		,4.481752826e-016
		,4.503516283e-016
		,4.523059264e-016
		,1.746537007e-016
		,1.734216847e-016
		,1.726102642e-016
		,1.719975725e-016
		,1.715017839e-016
		,1.710859037e-016
		,1.707286947e-016
		,1.704155966e-016
		,1.701357965e-016
		,1.698811930e-016
		,1.696458965e-016
		,1.694258341e-016
		,1.692183457e-016
		,1.690217828e-016
		,1.688351926e-016
		,1.686582792e-016
		,1.684921684e-016
		,1.683427406e-016
		,1.682329670e-016
		,1.682483995e-016
		,1.687067733e-016
		,1.707761711e-016
		,1.783961373e-016
		,2.009506331e-016
		,2.449128364e-016
		,2.963029282e-016
		,3.380732161e-016
		,3.674260185e-016
		,3.877169985e-016
		,4.021255566e-016
		,4.127276973e-016
		,4.208125615e-016
		,4.271830726e-016
		,4.323472059e-016
		,4.366344674e-016
		,4.402651043e-016
		,4.433908428e-016
		,4.461191064e-016
		,4.485277701e-016
		,4.506744579e-016
		,4.526026263e-016
		,1.742084945e-016
		,1.730837311e-016
		,1.723344604e-016
		,1.717647522e-016
		,1.713017808e-016
		,1.709118950e-016
		,1.705753529e-016
		,1.702785179e-016
		,1.700113408e-016
		,1.697664215e-016
		,1.695385112e-016
		,1.693240918e-016
		,1.691209504e-016
		,1.689277759e-016
		,1.687438536e-016
		,1.685690727e-016
		,1.684048039e-016
		,1.682575764e-016
		,1.681526920e-016
		,1.681847389e-016
		,1.687068577e-016
		,1.710198144e-016
		,1.794586592e-016
		,2.038093172e-016
		,2.492466835e-016
		,3.003692732e-016
		,3.411892943e-016
		,3.697462013e-016
		,3.894691912e-016
		,4.034726137e-016
		,4.137918835e-016
		,4.216741024e-016
		,4.278998492e-016
		,4.329576069e-016
		,4.371644999e-016
		,4.407328223e-016
		,4.438089837e-016
		,4.464967156e-016
		,4.488712555e-016
		,4.509883421e-016
		,4.528901291e-016
		,1.738138625e-016
		,1.727831866e-016
		,1.720892370e-016
		,1.715579430e-016
		,1.711240798e-016
		,1.707568470e-016
		,1.704378898e-016
		,1.701545184e-016
		,1.698975124e-016
		,1.696601876e-016
		,1.694378899e-016
		,1.692275964e-016
		,1.690274934e-016
		,1.688365789e-016
		,1.686543561e-016
		,1.684808777e-016
		,1.683177532e-016
		,1.681722264e-016
		,1.680722391e-016
		,1.681226380e-016
		,1.687167487e-016
		,1.713043629e-016
		,1.806458256e-016
		,2.068494242e-016
		,2.536072607e-016
		,3.043325060e-016
		,3.441962152e-016
		,3.719739110e-016
		,3.911437450e-016
		,4.047596882e-016
		,4.148081588e-016
		,4.225006353e-016
		,4.285902280e-016
		,4.335475082e-016
		,4.376781456e-016
		,4.411869452e-016
		,4.442152972e-016
		,4.468634632e-016
		,4.492042519e-016
		,4.512917317e-016
		,4.531669628e-016
		,1.734782542e-016
		,1.725272636e-016
		,1.718820570e-016
		,1.713842304e-016
		,1.709754903e-016
		,1.706275992e-016
		,1.703227571e-016
		,1.700508411e-016
		,1.698007836e-016
		,1.695695552e-016
		,1.693529941e-016
		,1.691458204e-016
		,1.689479340e-016
		,1.687578108e-016
		,1.685757098e-016
		,1.684019906e-016
		,1.682386842e-016
		,1.680938175e-016
		,1.679983079e-016
		,1.680686325e-016
		,1.687437275e-016
		,1.716406319e-016
		,1.819719320e-016
		,2.100661166e-016
		,2.579749982e-016
		,3.081877292e-016
		,3.470938144e-016
		,3.741092512e-016
		,3.927428598e-016
		,4.059886206e-016
		,4.157810387e-016
		,4.232948166e-016
		,4.292559129e-016
		,4.341179800e-016
		,4.381759013e-016
		,4.416274496e-016
		,4.446093157e-016
		,4.472185486e-016
		,4.495257664e-016
		,4.515835919e-016
		,4.534321838e-016
		,1.733746347e-016
		,1.724299061e-016
		,1.718045894e-016
		,1.713186324e-016
		,1.709144620e-016
		,1.705739291e-016
		,1.702723519e-016
		,1.700086191e-016
		,1.697415930e-016
		,1.695035784e-016
		,1.693073213e-016
		,1.691240093e-016
		,1.689385967e-016
		,1.687589927e-016
		,1.685716644e-016
		,1.683877885e-016
		,1.682140194e-016
		,1.680605847e-016
		,1.679626401e-016
		,1.680500756e-016
		,1.688133603e-016
		,1.720573137e-016
		,1.834727441e-016
		,2.134815791e-016
		,2.623601655e-016
		,3.119529341e-016
		,3.498975881e-016
		,3.761642903e-016
		,3.942775135e-016
		,4.071689219e-016
		,4.167181515e-016
		,4.240624394e-016
		,4.299012578e-016
		,4.346722662e-016
		,4.386601432e-016
		,4.420560369e-016
		,4.449922378e-016
		,4.475628428e-016
		,4.498365221e-016
		,4.518646572e-016
		,4.536866502e-016
		,1.751028551e-016
		,1.736957013e-016
		,1.726822280e-016
		,1.720348704e-016
		,1.714315920e-016
		,1.710830439e-016
		,1.706119610e-016
		,1.703481265e-016
		,1.698902798e-016
		,1.693709548e-016
		,1.690482019e-016
		,1.693271135e-016
		,1.691912291e-016
		,1.692965060e-016
		,1.692799901e-016
		,1.690806434e-016
		,1.688359161e-016
		,1.685974614e-016
		,1.684122314e-016
		,1.684427674e-016
		,1.692489511e-016
		,1.728560696e-016
		,1.854703826e-016
		,2.174318546e-016
		,2.670580243e-016
		,3.158509646e-016
		,3.527603109e-016
		,3.782456680e-016
		,3.958257538e-016
		,4.083596525e-016
		,4.176653164e-016
		,4.248398248e-016
		,4.305557423e-016
		,4.352347442e-016
		,4.391513220e-016
		,4.424900844e-016
		,4.453790432e-016
		,4.479094732e-016
		,4.501481964e-016
		,4.521454321e-016
		,4.539398879e-016
		,1.820968754e-016
		,1.802458027e-016
		,1.761533383e-016
		,1.748175324e-016
		,1.738001570e-016
		,1.732608508e-016
		,1.719620240e-016
		,1.720471568e-016
		,1.709241865e-016
		,1.697756177e-016
		,1.690275628e-016
		,1.690400694e-016
		,1.706345303e-016
		,1.707465522e-016
		,1.712486190e-016
		,1.714784337e-016
		,1.712943904e-016
		,1.708990518e-016
		,1.705623407e-016
		,1.704116611e-016
		,1.711691414e-016
		,1.752346998e-016
		,1.895137317e-016
		,2.238168287e-016
		,2.738108850e-016
		,3.211808778e-016
		,3.565936021e-016
		,3.810001601e-016
		,3.978612124e-016
		,4.099189705e-016
		,4.189020338e-016
		,4.258522630e-016
		,4.314055093e-016
		,4.359621936e-016
		,4.397834032e-016
		,4.430452524e-016
		,4.458703335e-016
		,4.483465249e-016
		,4.505385153e-016
		,4.524950840e-016
		,4.542538759e-016
		,1.953260865e-016
		,1.904275820e-016
		,1.844218060e-016
		,1.807458721e-016
		,1.796224196e-016
		,1.772050272e-016
		,1.761860559e-016
		,1.751410081e-016
		,1.752357270e-016
		,1.724556183e-016
		,1.728554621e-016
		,1.710882983e-016
		,1.719990616e-016
		,1.734302015e-016
		,1.744477703e-016
		,1.744567585e-016
		,1.744743717e-016
		,1.743904519e-016
		,1.740465115e-016
		,1.738683014e-016
		,1.747615208e-016
		,1.797454920e-016
		,1.967210634e-016
		,2.340394005e-016
		,2.837863736e-016
		,3.288021461e-016
		,3.620042441e-016
		,3.848710883e-016
		,4.007274706e-016
		,4.121270504e-016
		,4.206647089e-016
		,4.273008708e-016
		,4.326236364e-016
		,4.370045434e-016
		,4.406867899e-016
		,4.438353696e-016
		,4.465658429e-016
		,4.489615636e-016
		,4.510841980e-016
		,4.529806442e-016
		,4.546872611e-016
		,2.088441564e-016
		,2.013474656e-016
		,1.977216255e-016
		,1.910944255e-016
		,1.878605340e-016
		,1.843408617e-016
		,1.823121426e-016
		,1.815222269e-016
		,1.804744778e-016
		,1.806922524e-016
		,1.772334446e-016
		,1.788172360e-016
		,1.759188606e-016
		,1.767079895e-016
		,1.774427212e-016
		,1.781575099e-016
		,1.786787584e-016
		,1.780287014e-016
		,1.778856956e-016
		,1.779648091e-016
		,1.792531659e-016
		,1.864587519e-016
		,2.080178776e-016
		,2.487690240e-016
		,2.968565781e-016
		,3.382911268e-016
		,3.685808729e-016
		,3.895170252e-016
		,4.041392038e-016
		,4.147338893e-016
		,4.227332719e-016
		,4.290024332e-016
		,4.340607486e-016
		,4.382378549e-016
		,4.417585135e-016
		,4.447736140e-016
		,4.473910023e-016
		,4.496902662e-016
		,4.517305125e-016
		,4.535563183e-016
		,4.552023012e-016
		,2.210122610e-016
		,2.132968731e-016
		,2.086415808e-016
		,2.056881534e-016
		,1.992882027e-016
		,1.950069350e-016
		,1.925530115e-016
		,1.908418811e-016
		,1.889332331e-016
		,1.874577695e-016
		,1.863958059e-016
		,1.837259317e-016
		,1.840319407e-016
		,1.821057970e-016
		,1.807881810e-016
		,1.821929146e-016
		,1.823461076e-016
		,1.829326770e-016
		,1.821242677e-016
		,1.821455245e-016
		,1.836699291e-016
		,1.920968660e-016
		,2.188388735e-016
		,2.650674095e-016
		,3.130896660e-016
		,3.503436153e-016
		,3.769224316e-016
		,3.954225469e-016
		,4.085152292e-016
		,4.181193793e-016
		,4.254346625e-016
		,4.311973220e-016
		,4.358752763e-016
		,4.397607078e-016
		,4.430512372e-016
		,4.458835399e-016
		,4.483548717e-016
		,4.505359400e-016
		,4.524790650e-016
		,4.542243526e-016
		,4.558030115e-016
		,2.299530372e-016
		,2.221050352e-016
		,2.145508267e-016
		,2.135054294e-016
		,2.112836329e-016
		,2.090952997e-016
		,2.045637753e-016
		,2.020229960e-016
		,1.997568330e-016
		,1.968976842e-016
		,1.953184471e-016
		,1.935547201e-016
		,1.911150877e-016
		,1.894763265e-016
		,1.874175728e-016
		,1.846354646e-016
		,1.864318371e-016
		,1.864220024e-016
		,1.867931962e-016
		,1.863401231e-016
		,1.872316027e-016
		,1.933634723e-016
		,2.184803925e-016
		,2.729064270e-016
		,3.266884795e-016
		,3.623251291e-016
		,3.854720434e-016
		,4.012329648e-016
		,4.125142313e-016
		,4.209828542e-016
		,4.276614810e-016
		,4.332394083e-016
		,4.378551858e-016
		,4.417650908e-016
		,4.450137263e-016
		,4.477957193e-016
		,4.502199013e-016
		,4.523343079e-016
		,4.541669712e-016
		,4.558542343e-016
		,4.573729045e-016
		,2.535968500e-016
		,2.278157461e-016
		,2.264828362e-016
		,2.209536548e-016
		,2.208736752e-016
		,2.201920243e-016
		,2.167957771e-016
		,2.101331660e-016
		,2.075601934e-016
		,2.059250477e-016
		,2.046493580e-016
		,2.009753506e-016
		,2.001298253e-016
		,1.978877433e-016
		,1.960107144e-016
		,1.927063485e-016
		,1.880032879e-016
		,1.908059714e-016
		,1.907216242e-016
		,1.907793338e-016
		,1.914334686e-016
		,1.936168456e-016
		,2.080215146e-016
		,2.500986877e-016
		,3.141370075e-016
		,3.640229567e-016
		,3.932054766e-016
		,4.102999533e-016
		,4.212193126e-016
		,4.289097092e-016
		,4.347358705e-016
		,4.393644298e-016
		,4.431635863e-016
		,4.463556488e-016
		,4.490855445e-016
		,4.514590708e-016
		,4.535437533e-016
		,4.553924840e-016
		,4.570456082e-016
		,4.585346840e-016
		,4.598849764e-016
		,2.644125753e-016
		,2.525666108e-016
		,2.346116004e-016
		,2.335584604e-016
		,2.300124385e-016
		,2.297916062e-016
		,2.282786367e-016
		,2.252626645e-016
		,2.169542610e-016
		,2.098814086e-016
		,2.081943676e-016
		,2.070480103e-016
		,2.078818589e-016
		,2.057787203e-016
		,2.038679134e-016
		,2.028632719e-016
		,1.985271089e-016
		,1.933727277e-016
		,1.921742333e-016
		,1.956552545e-016
		,1.949537206e-016
		,1.979630827e-016
		,2.055706597e-016
		,2.273121447e-016
		,2.718966053e-016
		,3.296267796e-016
		,3.798682397e-016
		,4.109585609e-016
		,4.273964116e-016
		,4.365738570e-016
		,4.427614698e-016
		,4.470567487e-016
		,4.503819786e-016
		,4.534381340e-016
		,4.559494559e-016
		,4.580751246e-016
		,4.599099653e-016
		,4.615147731e-016
		,4.629325602e-016
		,4.641869382e-016
		,4.653190695e-016
		,2.761158183e-016
		,2.704386037e-016
		,2.550826180e-016
		,2.427246816e-016
		,2.412598220e-016
		,2.375331493e-016
		,2.349653442e-016
		,2.242022792e-016
		,2.247110440e-016
		,2.184723735e-016
		,2.169367873e-016
		,2.156726953e-016
		,2.151284677e-016
		,2.147766286e-016
		,2.110746417e-016
		,2.084690403e-016
		,2.072607027e-016
		,2.045310221e-016
		,1.999181914e-016
		,1.940402400e-016
		,1.987305758e-016
		,2.029275138e-016
		,2.074246913e-016
		,2.204603148e-016
		,2.452050959e-016
		,2.869014218e-016
		,3.374177331e-016
		,3.833060999e-016
		,4.166680520e-016
		,4.370984572e-016
		,4.483666833e-016
		,4.539453143e-016
		,4.581655386e-016
		,4.612226358e-016
		,4.638150250e-016
		,4.655811265e-016
		,4.666953106e-016
		,4.682732066e-016
		,4.695635195e-016
		,4.706511015e-016
		,4.715885262e-016
		,2.875059244e-016
		,2.832055044e-016
		,2.773228421e-016
		,2.562654708e-016
		,2.296303807e-016
		,2.340294072e-016
		,2.341203105e-016
		,2.357623754e-016
		,2.355015640e-016
		,2.331825606e-016
		,2.270892380e-016
		,2.238756391e-016
		,2.208541910e-016
		,2.228512818e-016
		,2.213131182e-016
		,2.173015308e-016
		,2.139003753e-016
		,2.124633051e-016
		,2.095660243e-016
		,2.049838302e-016
		,2.016807782e-016
		,2.015869970e-016
		,2.117941006e-016
		,2.242292658e-016
		,2.375948237e-016
		,2.624718741e-016
		,2.967052848e-016
		,3.393368994e-016
		,3.790105388e-016
		,4.140955411e-016
		,4.387134644e-016
		,4.545065991e-016
		,4.641046625e-016
		,4.697716209e-016
		,4.717912871e-016
		,4.734936550e-016
		,4.751737869e-016
		,4.767117530e-016
		,4.772437081e-016
		,4.774180950e-016
		,4.782578917e-016
		,2.763445703e-016
		,2.740759663e-016
		,2.710915120e-016
		,2.504935549e-016
		,2.470295962e-016
		,2.474048792e-016
		,2.437970882e-016
		,2.434142182e-016
		,2.420678629e-016
		,2.405851539e-016
		,2.344840951e-016
		,2.282777993e-016
		,2.268652556e-016
		,2.300237488e-016
		,2.272743910e-016
		,2.226642643e-016
		,2.178400892e-016
		,2.168727832e-016
		,2.157635768e-016
		,2.134517732e-016
		,2.121601528e-016
		,2.132070950e-016
		,2.229625166e-016
		,2.408745655e-016
		,2.603168116e-016
		,2.764205544e-016
		,3.024648768e-016
		,3.269399034e-016
		,3.470214254e-016
		,3.739763919e-016
		,4.056576286e-016
		,4.327697056e-016
		,4.549702347e-016
		,4.685936506e-016
		,4.767852177e-016
		,4.809504057e-016
		,4.846186522e-016
		,4.843727835e-016
		,4.852515645e-016
		,4.862172659e-016
		,4.864826100e-016
		,2.895945198e-016
		,2.856862670e-016
		,2.822951301e-016
		,2.788020866e-016
		,2.597512758e-016
		,2.564365774e-016
		,2.559830371e-016
		,2.509031084e-016
		,2.497369801e-016
		,2.487875574e-016
		,2.462999266e-016
		,2.398062149e-016
		,2.329219323e-016
		,2.328862991e-016
		,2.327383128e-016
		,2.299821660e-016
		,2.281498614e-016
		,2.241234380e-016
		,2.208055890e-016
		,2.247767327e-016
		,2.244837393e-016
		,2.271024830e-016
		,2.341560167e-016
		,2.415222801e-016
		,2.573217244e-016
		,2.738400586e-016
		,2.961080128e-016
		,3.085176163e-016
		,3.323598295e-016
		,3.564163008e-016
		,3.733745986e-016
		,3.953113817e-016
		,4.207214601e-016
		,4.430838202e-016
		,4.622403049e-016
		,4.771428779e-016
		,4.860140817e-016
		,4.905069878e-016
		,4.942861283e-016
		,4.961754089e-016
		,4.952114655e-016
		,1.762668917e-016
		,1.746810628e-016
		,1.736634241e-016
		,1.729093294e-016
		,1.723065354e-016
		,1.718072933e-016
		,1.713883554e-016
		,1.710404213e-016
		,1.707638100e-016
		,1.705529728e-016
		,1.703701267e-016
		,1.702207113e-016
		,1.701755814e-016
		,1.701369472e-016
		,1.701979412e-016
		,1.704355501e-016
		,1.708148903e-016
		,1.717922702e-016
		,1.727124586e-016
		,1.742220066e-016
		,1.769720364e-016
		,1.808818006e-016
		,1.901608382e-016
		,2.097924308e-016
		,2.436063964e-016
		,2.885165392e-016
		,3.298843084e-016
		,3.602914050e-016
		,3.815903326e-016
		,3.970181953e-016
		,4.085153849e-016
		,4.172773270e-016
		,4.241234476e-016
		,4.296077503e-016
		,4.341068805e-016
		,4.378907471e-016
		,4.411492023e-016
		,4.440048433e-016
		,4.465353592e-016
		,4.487942439e-016
		,4.508220453e-016
		,1.756370723e-016
		,1.742053071e-016
		,1.732719390e-016
		,1.725717285e-016
		,1.720069741e-016
		,1.715347843e-016
		,1.711316360e-016
		,1.707819826e-016
		,1.704746605e-016
		,1.702012172e-016
		,1.699544061e-016
		,1.697311907e-016
		,1.695233690e-016
		,1.693401648e-016
		,1.691712519e-016
		,1.690270468e-016
		,1.689462260e-016
		,1.688792157e-016
		,1.689019362e-016
		,1.691706877e-016
		,1.698879867e-016
		,1.720845623e-016
		,1.793832491e-016
		,1.998904059e-016
		,2.404269669e-016
		,2.908799636e-016
		,3.337787541e-016
		,3.643637203e-016
		,3.855052010e-016
		,4.004501573e-016
		,4.113992038e-016
		,4.197108257e-016
		,4.262416649e-016
		,4.315314877e-016
		,4.359236217e-016
		,4.396415879e-016
		,4.428386063e-016
		,4.456243159e-016
		,4.480792475e-016
		,4.502635202e-016
		,4.522224787e-016
		,1.750924225e-016
		,1.737949371e-016
		,1.729376836e-016
		,1.722888991e-016
		,1.717630532e-016
		,1.713218164e-016
		,1.709434349e-016
		,1.706130276e-016
		,1.703194423e-016
		,1.700541744e-016
		,1.698109393e-016
		,1.695851248e-016
		,1.693740167e-016
		,1.691750588e-016
		,1.689884030e-016
		,1.688133297e-016
		,1.686503996e-016
		,1.685093529e-016
		,1.684119977e-016
		,1.684375006e-016
		,1.689040197e-016
		,1.709414249e-016
		,1.783213272e-016
		,2.001871971e-016
		,2.434710288e-016
		,2.949267814e-016
		,3.371338174e-016
		,3.668349111e-016
		,3.873237935e-016
		,4.018358395e-016
		,4.125030493e-016
		,4.206285907e-016
		,4.270294910e-016
		,4.322175249e-016
		,4.365246087e-016
		,4.401727898e-016
		,4.433145716e-016
		,4.460573385e-016
		,4.484786904e-016
		,4.506360588e-016
		,4.525728558e-016
		,1.746065986e-016
		,1.734262177e-016
		,1.726369840e-016
		,1.720353850e-016
		,1.715458619e-016
		,1.711337760e-016
		,1.707789204e-016
		,1.704672732e-016
		,1.701883509e-016
		,1.699342748e-016
		,1.696993138e-016
		,1.694795045e-016
		,1.692722680e-016
		,1.690760049e-016
		,1.688897820e-016
		,1.687134538e-016
		,1.685481971e-016
		,1.684002451e-016
		,1.682943542e-016
		,1.683220778e-016
		,1.688228063e-016
		,1.710488685e-016
		,1.791906322e-016
		,2.028960405e-016
		,2.478413932e-016
		,2.991403954e-016
		,3.403727596e-016
		,3.692344064e-016
		,3.891283673e-016
		,4.032220980e-016
		,4.135935021e-016
		,4.215103956e-016
		,4.277628228e-016
		,4.328431509e-016
		,4.370699160e-016
		,4.406559044e-016
		,4.437476453e-016
		,4.464488593e-016
		,4.488347605e-016
		,4.509611134e-016
		,4.528701785e-016
		,1.741672532e-016
		,1.730895631e-016
		,1.723612173e-016
		,1.718025279e-016
		,1.713461642e-016
		,1.709605443e-016
		,1.706268389e-016
		,1.703318992e-016
		,1.700659807e-016
		,1.698218969e-016
		,1.695945509e-016
		,1.693805309e-016
		,1.691776950e-016
		,1.689847742e-016
		,1.688010836e-016
		,1.686265519e-016
		,1.684626665e-016
		,1.683164069e-016
		,1.682148380e-016
		,1.682594792e-016
		,1.688306312e-016
		,1.713296624e-016
		,1.803794023e-016
		,2.059944542e-016
		,2.523714146e-016
		,3.032980614e-016
		,3.435282587e-016
		,3.715629474e-016
		,3.908714102e-016
		,4.045601729e-016
		,4.146481042e-016
		,4.223701450e-016
		,4.284826399e-016
		,4.334596075e-016
		,4.376076901e-016
		,4.411319277e-016
		,4.441737022e-016
		,4.468332059e-016
		,4.491832237e-016
		,4.512778992e-016
		,4.531584766e-016
		,1.737689959e-016
		,1.727817678e-016
		,1.721079000e-016
		,1.715878678e-016
		,1.711612349e-016
		,1.707990502e-016
		,1.704837789e-016
		,1.702031676e-016
		,1.699482435e-016
		,1.697125208e-016
		,1.694915215e-016
		,1.692823482e-016
		,1.690832583e-016
		,1.688932694e-016
		,1.687118921e-016
		,1.685392247e-016
		,1.683770086e-016
		,1.682330151e-016
		,1.681373548e-016
		,1.682033955e-016
		,1.688575017e-016
		,1.716704257e-016
		,1.817293846e-016
		,2.093089178e-016
		,2.569334905e-016
		,3.073494323e-016
		,3.465698266e-016
		,3.737951003e-016
		,3.925373749e-016
		,4.058379995e-016
		,4.156629207e-016
		,4.231995585e-016
		,4.291795659e-016
		,4.340582618e-016
		,4.381309487e-016
		,4.415954025e-016
		,4.445881936e-016
		,4.472062880e-016
		,4.495203313e-016
		,4.515831008e-016
		,4.534350158e-016
		,1.734115351e-016
		,1.725043281e-016
		,1.718790889e-016
		,1.713934964e-016
		,1.709930167e-016
		,1.706510555e-016
		,1.703513387e-016
		,1.700825294e-016
		,1.698364421e-016
		,1.696072740e-016
		,1.693911388e-016
		,1.691856086e-016
		,1.689892895e-016
		,1.688014427e-016
		,1.686217365e-016
		,1.684504039e-016
		,1.682894872e-016
		,1.681476454e-016
		,1.680583750e-016
		,1.681486467e-016
		,1.688978915e-016
		,1.720677039e-016
		,1.832375006e-016
		,2.128098157e-016
		,2.614901026e-016
		,3.112818901e-016
		,3.494933082e-016
		,3.759296241e-016
		,3.941274037e-016
		,4.070608228e-016
		,4.166355158e-016
		,4.239983560e-016
		,4.298529996e-016
		,4.346379777e-016
		,4.386380696e-016
		,4.420442964e-016
		,4.449888218e-016
		,4.475657314e-016
		,4.498438283e-016
		,4.518747490e-016
		,4.536982196e-016
		,1.730965982e-016
		,1.722605415e-016
		,1.716787776e-016
		,1.712237402e-016
		,1.708460555e-016
		,1.705213137e-016
		,1.702344466e-016
		,1.699750873e-016
		,1.697358196e-016
		,1.695114523e-016
		,1.692987021e-016
		,1.690955164e-016
		,1.689009331e-016
		,1.687142578e-016
		,1.685353574e-016
		,1.683645196e-016
		,1.682041235e-016
		,1.680638878e-016
		,1.679812293e-016
		,1.680983655e-016
		,1.689553321e-016
		,1.725292036e-016
		,1.849128720e-016
		,2.164815760e-016
		,2.660166076e-016
		,3.150851727e-016
		,3.522934503e-016
		,3.779651983e-016
		,3.956427181e-016
		,4.082288989e-016
		,4.175679301e-016
		,4.247667743e-016
		,4.305023271e-016
		,4.351975591e-016
		,4.391274834e-016
		,4.424768882e-016
		,4.453739302e-016
		,4.479101350e-016
		,4.501527001e-016
		,4.521522671e-016
		,4.539479328e-016
		,1.728356538e-016
		,1.720596837e-016
		,1.715144420e-016
		,1.710854895e-016
		,1.707269977e-016
		,1.704163485e-016
		,1.701398899e-016
		,1.698873190e-016
		,1.696530800e-016
		,1.694318296e-016
		,1.692209901e-016
		,1.690188267e-016
		,1.688262552e-016
		,1.686409158e-016
		,1.684627717e-016
		,1.682920926e-016
		,1.681309421e-016
		,1.679911913e-016
		,1.679146473e-016
		,1.680613214e-016
		,1.690391155e-016
		,1.730668049e-016
		,1.867685667e-016
		,2.203117655e-016
		,2.704998362e-016
		,3.187636722e-016
		,3.549775561e-016
		,3.799069462e-016
		,3.970865680e-016
		,4.093434552e-016
		,4.184594793e-016
		,4.255030582e-016
		,4.311256995e-016
		,4.357352018e-016
		,4.395973259e-016
		,4.428912740e-016
		,4.457417066e-016
		,4.482379373e-016
		,4.504457586e-016
		,4.524148911e-016
		,4.541837861e-016
		,1.728350239e-016
		,1.720673249e-016
		,1.714941656e-016
		,1.710679171e-016
		,1.707103891e-016
		,1.704061071e-016
		,1.701239502e-016
		,1.698655603e-016
		,1.696310388e-016
		,1.694037998e-016
		,1.691766930e-016
		,1.689661528e-016
		,1.687740097e-016
		,1.686185369e-016
		,1.684381666e-016
		,1.682924941e-016
		,1.681399180e-016
		,1.679938373e-016
		,1.679148537e-016
		,1.680855682e-016
		,1.691937225e-016
		,1.737232602e-016
		,1.888437420e-016
		,2.243219157e-016
		,2.749622836e-016
		,3.223438303e-016
		,3.575677304e-016
		,3.817761069e-016
		,3.984784006e-016
		,4.104212893e-016
		,4.193239196e-016
		,4.262173670e-016
		,4.317290365e-016
		,4.362535039e-016
		,4.400481588e-016
		,4.432868572e-016
		,4.460908938e-016
		,4.485474760e-016
		,4.507210599e-016
		,4.526604886e-016
		,4.544035963e-016
		,1.749021667e-016
		,1.738818791e-016
		,1.724880414e-016
		,1.719579733e-016
		,1.714769941e-016
		,1.711083979e-016
		,1.706420436e-016
		,1.703602897e-016
		,1.699490075e-016
		,1.697132599e-016
		,1.693398308e-016
		,1.688675586e-016
		,1.684521672e-016
		,1.686509419e-016
		,1.686118174e-016
		,1.685141292e-016
		,1.687181762e-016
		,1.687332117e-016
		,1.686279241e-016
		,1.687792929e-016
		,1.699756543e-016
		,1.750421743e-016
		,1.916975034e-016
		,2.290372401e-016
		,2.798386757e-016
		,3.261300803e-016
		,3.602692911e-016
		,3.837148698e-016
		,3.999195938e-016
		,4.115367284e-016
		,4.202187658e-016
		,4.269563394e-016
		,4.323530123e-016
		,4.367889877e-016
		,4.405130850e-016
		,4.436939002e-016
		,4.464494483e-016
		,4.488647731e-016
		,4.510028561e-016
		,4.529115336e-016
		,4.546279071e-016
		,1.834085570e-016
		,1.805696763e-016
		,1.769952780e-016
		,1.754256140e-016
		,1.747273102e-016
		,1.734426508e-016
		,1.728847485e-016
		,1.721151324e-016
		,1.714591088e-016
		,1.706461932e-016
		,1.707217322e-016
		,1.685677728e-016
		,1.683306061e-016
		,1.679453562e-016
		,1.695566513e-016
		,1.698980872e-016
		,1.698527776e-016
		,1.706790306e-016
		,1.710826139e-016
		,1.713113905e-016
		,1.726594270e-016
		,1.786514952e-016
		,1.976136278e-016
		,2.370526909e-016
		,2.872194838e-016
		,3.315872062e-016
		,3.640959946e-016
		,3.864429426e-016
		,4.019392144e-016
		,4.130917916e-016
		,4.214583252e-016
		,4.279727262e-016
		,4.332052852e-016
		,4.375164696e-016
		,4.411420611e-016
		,4.442422398e-016
		,4.469304216e-016
		,4.492889829e-016
		,4.513790259e-016
		,4.532468182e-016
		,4.549281422e-016
		,1.971419857e-016
		,1.909663377e-016
		,1.882472709e-016
		,1.818688760e-016
		,1.800977668e-016
		,1.783568323e-016
		,1.771758203e-016
		,1.762913970e-016
		,1.740713323e-016
		,1.737270565e-016
		,1.730090866e-016
		,1.724144151e-016
		,1.696073366e-016
		,1.698026880e-016
		,1.708021076e-016
		,1.722699992e-016
		,1.732986849e-016
		,1.728486263e-016
		,1.737563499e-016
		,1.746199582e-016
		,1.765858915e-016
		,1.841273132e-016
		,2.073975508e-016
		,2.498424875e-016
		,2.984777604e-016
		,3.396731461e-016
		,3.696248999e-016
		,3.903047906e-016
		,4.047516662e-016
		,4.152237381e-016
		,4.231281389e-016
		,4.293141020e-016
		,4.343034733e-016
		,4.384291986e-016
		,4.419118696e-016
		,4.449022920e-016
		,4.475058955e-016
		,4.497978962e-016
		,4.518345597e-016
		,4.536591363e-016
		,4.553050727e-016
		,2.108009010e-016
		,2.014324769e-016
		,1.978335027e-016
		,1.939353675e-016
		,1.876060574e-016
		,1.855844584e-016
		,1.835680666e-016
		,1.816666292e-016
		,1.791507387e-016
		,1.788329647e-016
		,1.778372547e-016
		,1.768618981e-016
		,1.768324579e-016
		,1.748527667e-016
		,1.733006688e-016
		,1.757006777e-016
		,1.766949223e-016
		,1.771440105e-016
		,1.768540550e-016
		,1.777737573e-016
		,1.799476659e-016
		,1.888911363e-016
		,2.166546234e-016
		,2.636095232e-016
		,3.120071869e-016
		,3.503167056e-016
		,3.771857604e-016
		,3.956615294e-016
		,4.086852746e-016
		,4.182391042e-016
		,4.255374022e-016
		,4.313023023e-016
		,4.359804153e-016
		,4.398641304e-016
		,4.431527975e-016
		,4.459826390e-016
		,4.484503482e-016
		,4.506308432e-016
		,4.525732818e-016
		,4.543179527e-016
		,4.558962001e-016
		,2.177302254e-016
		,2.142701155e-016
		,2.067070438e-016
		,2.047391326e-016
		,2.021952321e-016
		,1.952478397e-016
		,1.913256633e-016
		,1.896846467e-016
		,1.880958358e-016
		,1.864618243e-016
		,1.859850822e-016
		,1.840655038e-016
		,1.826705726e-016
		,1.817005477e-016
		,1.795436275e-016
		,1.787130656e-016
		,1.801136775e-016
		,1.816894410e-016
		,1.821262566e-016
		,1.808086583e-016
		,1.829321001e-016
		,1.892352850e-016
		,2.141871328e-016
		,2.693148696e-016
		,3.250871426e-016
		,3.617609041e-016
		,3.852712743e-016
		,4.011986905e-016
		,4.125701853e-016
		,4.210676499e-016
		,4.276387304e-016
		,4.328954971e-016
		,4.372537260e-016
		,4.410134029e-016
		,4.443598315e-016
		,4.472331763e-016
		,4.498034465e-016
		,4.520537046e-016
		,4.540165966e-016
		,4.557476458e-016
		,4.573340306e-016
		,2.301161557e-016
		,2.196840496e-016
		,2.154577750e-016
		,2.106058590e-016
		,2.094691107e-016
		,2.069676422e-016
		,1.999045509e-016
		,1.967802509e-016
		,1.980860526e-016
		,1.972981782e-016
		,1.955853698e-016
		,1.931146336e-016
		,1.894275750e-016
		,1.889121974e-016
		,1.884716138e-016
		,1.867173188e-016
		,1.834088323e-016
		,1.847442303e-016
		,1.863685463e-016
		,1.864941517e-016
		,1.855182615e-016
		,1.897771059e-016
		,2.043293587e-016
		,2.458820657e-016
		,3.109320263e-016
		,3.622839679e-016
		,3.923832349e-016
		,4.096327614e-016
		,4.208235543e-016
		,4.286455435e-016
		,4.345507618e-016
		,4.392277316e-016
		,4.430675953e-016
		,4.462938495e-016
		,4.490539612e-016
		,4.514494808e-016
		,4.535456792e-016
		,4.554066780e-016
		,4.570762304e-016
		,4.585803037e-016
		,4.599444234e-016
		,2.513123578e-016
		,2.290321873e-016
		,2.245207218e-016
		,2.193093468e-016
		,2.172463119e-016
		,2.161763838e-016
		,2.137277753e-016
		,2.090804830e-016
		,2.056899614e-016
		,2.046558694e-016
		,1.990307298e-016
		,1.982738279e-016
		,1.965678718e-016
		,1.971127862e-016
		,1.967792301e-016
		,1.952781935e-016
		,1.932897892e-016
		,1.895134013e-016
		,1.868992684e-016
		,1.917523346e-016
		,1.918475025e-016
		,1.928503313e-016
		,2.011044504e-016
		,2.245745642e-016
		,2.688155198e-016
		,3.277790300e-016
		,3.791014292e-016
		,4.101038429e-016
		,4.269798994e-016
		,4.362693540e-016
		,4.424293777e-016
		,4.471005401e-016
		,4.501239639e-016
		,4.532770578e-016
		,4.558388523e-016
		,4.579933073e-016
		,4.598292625e-016
		,4.614491919e-016
		,4.628800052e-016
		,4.641538863e-016
		,4.652970963e-016
		,2.621163127e-016
		,2.560561802e-016
		,2.306324234e-016
		,2.302602656e-016
		,2.255681735e-016
		,2.243294268e-016
		,2.243540021e-016
		,2.227957854e-016
		,2.097443282e-016
		,2.076700460e-016
		,2.079635222e-016
		,2.072507721e-016
		,2.055224564e-016
		,2.028620710e-016
		,2.030806355e-016
		,2.021566170e-016
		,1.996838201e-016
		,1.999647727e-016
		,1.960379517e-016
		,1.924838135e-016
		,1.927498705e-016
		,2.001759734e-016
		,2.036916251e-016
		,2.162121523e-016
		,2.427864576e-016
		,2.865424276e-016
		,3.365849682e-016
		,3.836356782e-016
		,4.172038669e-016
		,4.372801898e-016
		,4.485531295e-016
		,4.540315514e-016
		,4.579313094e-016
		,4.610480536e-016
		,4.636047308e-016
		,4.658026299e-016
		,4.665532080e-016
		,4.681851592e-016
		,4.695024343e-016
		,4.705966691e-016
		,4.715194073e-016
		,2.735776520e-016
		,2.675090092e-016
		,2.568982770e-016
		,2.364152725e-016
		,2.363460506e-016
		,2.245317333e-016
		,2.191711822e-016
		,2.233434231e-016
		,2.239687848e-016
		,2.226031648e-016
		,2.159825305e-016
		,2.159272597e-016
		,2.141150107e-016
		,2.118225063e-016
		,2.094886761e-016
		,2.109621518e-016
		,2.090158284e-016
		,2.048041184e-016
		,2.039552876e-016
		,2.015060479e-016
		,1.997091358e-016
		,1.985119324e-016
		,2.076742594e-016
		,2.213667063e-016
		,2.344767817e-016
		,2.594950997e-016
		,2.969843058e-016
		,3.416731112e-016
		,3.818227990e-016
		,4.152277593e-016
		,4.402688547e-016
		,4.560121603e-016
		,4.641911437e-016
		,4.695308823e-016
		,4.729588727e-016
		,4.734504489e-016
		,4.751796832e-016
		,4.766805781e-016
		,4.777263548e-016
		,4.774366363e-016
		,4.783065147e-016
		,2.768032125e-016
		,2.611279413e-016
		,2.380928421e-016
		,2.270385306e-016
		,2.332647758e-016
		,2.327876515e-016
		,2.330917263e-016
		,2.337134471e-016
		,2.332521026e-016
		,2.306947731e-016
		,2.241667375e-016
		,2.224966633e-016
		,2.206454884e-016
		,2.177423621e-016
		,2.173024293e-016
		,2.175417758e-016
		,2.131314307e-016
		,2.108843324e-016
		,2.094572053e-016
		,2.096790904e-016
		,2.094794974e-016
		,2.121496923e-016
		,2.182580254e-016
		,2.374592232e-016
		,2.590600298e-016
		,2.742728573e-016
		,3.010561045e-016
		,3.283595960e-016
		,3.498890323e-016
		,3.786053957e-016
		,4.110631024e-016
		,4.376293346e-016
		,4.571637312e-016
		,4.711008078e-016
		,4.796504770e-016
		,4.819530514e-016
		,4.847104717e-016
		,4.859506497e-016
		,4.854916670e-016
		,4.864205778e-016
		,4.871229364e-016
		,2.714820161e-016
		,2.701655507e-016
		,2.677903864e-016
		,2.590288892e-016
		,2.434581826e-016
		,2.457055764e-016
		,2.438819024e-016
		,2.420886380e-016
		,2.410205918e-016
		,2.406506124e-016
		,2.374112264e-016
		,2.316819510e-016
		,2.286005535e-016
		,2.268719579e-016
		,2.206983213e-016
		,2.222285807e-016
		,2.226610285e-016
		,2.197769287e-016
		,2.177044296e-016
		,2.159413330e-016
		,2.212781455e-016
		,2.244963334e-016
		,2.322063284e-016
		,2.416019833e-016
		,2.511785640e-016
		,2.727020875e-016
		,2.956034453e-016
		,3.067123005e-016
		,3.326556776e-016
		,3.596757341e-016
		,3.782613049e-016
		,4.017619282e-016
		,4.283127139e-016
		,4.503573327e-016
		,4.675564807e-016
		,4.806940793e-016
		,4.908825365e-016
		,4.939169199e-016
		,4.958588613e-016
		,4.979907931e-016
		,4.961632834e-016
		,1.756564690e-016
		,1.742875912e-016
		,1.733880262e-016
		,1.727127176e-016
		,1.721719631e-016
		,1.717278978e-016
		,1.713638660e-016
		,1.710800905e-016
		,1.709055504e-016
		,1.709276217e-016
		,1.712669489e-016
		,1.719143184e-016
		,1.722285456e-016
		,1.722918216e-016
		,1.729463043e-016
		,1.737042857e-016
		,1.762906248e-016
		,1.769790966e-016
		,1.800422546e-016
		,1.827936917e-016
		,1.862776597e-016
		,1.938159513e-016
		,2.035858812e-016
		,2.220542420e-016
		,2.549583086e-016
		,2.947508832e-016
		,3.315421667e-016
		,3.600596113e-016
		,3.807649437e-016
		,3.959424800e-016
		,4.073302548e-016
		,4.161015527e-016
		,4.230124288e-016
		,4.285836191e-016
		,4.331807928e-016
		,4.370534473e-016
		,4.403689410e-016
		,4.432447490e-016
		,4.457686763e-016
		,4.480076167e-016
		,4.500122491e-016
		,1.750686072e-016
		,1.738204010e-016
		,1.729852120e-016
		,1.723485717e-016
		,1.718309598e-016
		,1.713964293e-016
		,1.710244731e-016
		,1.707013054e-016
		,1.704175229e-016
		,1.701688693e-016
		,1.699577965e-016
		,1.697953945e-016
		,1.696542882e-016
		,1.695455864e-016
		,1.694332800e-016
		,1.694947212e-016
		,1.696042533e-016
		,1.697407273e-016
		,1.703436364e-016
		,1.708951268e-016
		,1.725752965e-016
		,1.765004289e-016
		,1.853007877e-016
		,2.079082891e-016
		,2.492005725e-016
		,2.976863541e-016
		,3.384444210e-016
		,3.677837505e-016
		,3.881265550e-016
		,4.024663842e-016
		,4.129582481e-016
		,4.209414650e-016
		,4.272249603e-016
		,4.323206479e-016
		,4.365658552e-016
		,4.401796325e-016
		,4.433034387e-016
		,4.460344762e-016
		,4.484443556e-016
		,4.505877455e-016
		,4.525071890e-016
		,1.745794813e-016
		,1.734415233e-016
		,1.726704597e-016
		,1.720779962e-016
		,1.715937728e-016
		,1.711851303e-016
		,1.708327537e-016
		,1.705231133e-016
		,1.702460664e-016
		,1.699940640e-016
		,1.697618781e-016
		,1.695463188e-016
		,1.693455212e-016
		,1.691565242e-016
		,1.689834778e-016
		,1.688199002e-016
		,1.686819412e-016
		,1.685701719e-016
		,1.685085327e-016
		,1.686466568e-016
		,1.693224127e-016
		,1.718481318e-016
		,1.807341458e-016
		,2.056248591e-016
		,2.509892939e-016
		,3.018443043e-016
		,3.424921765e-016
		,3.708968965e-016
		,3.904391454e-016
		,4.042632852e-016
		,4.144335142e-016
		,4.221994364e-016
		,4.283373864e-016
		,4.333326412e-016
		,4.374963960e-016
		,4.410338279e-016
		,4.440860331e-016
		,4.467538886e-016
		,4.491111890e-016
		,4.512125012e-016
		,4.530989672e-016
		,1.741462897e-016
		,1.731065319e-016
		,1.723944854e-016
		,1.718439511e-016
		,1.713921718e-016
		,1.710093030e-016
		,1.706772966e-016
		,1.703834251e-016
		,1.701182082e-016
		,1.698746411e-016
		,1.696477640e-016
		,1.694342766e-016
		,1.692321451e-016
		,1.690401483e-016
		,1.688577331e-016
		,1.686851052e-016
		,1.685233793e-016
		,1.683817987e-016
		,1.682886518e-016
		,1.683519338e-016
		,1.689867329e-016
		,1.717028806e-016
		,1.814023175e-016
		,2.082597055e-016
		,2.554399430e-016
		,3.060944406e-016
		,3.457335321e-016
		,3.732530966e-016
		,3.921625797e-016
		,4.055578145e-016
		,4.154429133e-016
		,4.230221402e-016
		,4.290352012e-016
		,4.339408398e-016
		,4.380358695e-016
		,4.415188303e-016
		,4.445267996e-016
		,4.471571541e-016
		,4.494808933e-016
		,4.515511523e-016
		,4.534087318e-016
		,1.737539046e-016
		,1.728015730e-016
		,1.721431722e-016
		,1.716312057e-016
		,1.712092941e-016
		,1.708500339e-016
		,1.705365954e-016
		,1.702571141e-016
		,1.700028658e-016
		,1.697675364e-016
		,1.695467695e-016
		,1.693377521e-016
		,1.691387962e-016
		,1.689489538e-016
		,1.687677649e-016
		,1.685953694e-016
		,1.684336825e-016
		,1.682911120e-016
		,1.682001359e-016
		,1.682833857e-016
		,1.690032937e-016
		,1.720599018e-016
		,1.828722772e-016
		,2.118056017e-016
		,2.601701415e-016
		,3.102154614e-016
		,3.487932814e-016
		,3.754784165e-016
		,3.938162375e-016
		,4.068305474e-016
		,4.164551132e-016
		,4.238554800e-016
		,4.297389551e-016
		,4.345474404e-016
		,4.385669090e-016
		,4.419889526e-016
		,4.449461160e-016
		,4.475328531e-016
		,4.498183771e-016
		,4.518547656e-016
		,4.536821789e-016
		,1.733958473e-016
		,1.725213940e-016
		,1.719114072e-016
		,1.714343232e-016
		,1.710392189e-016
		,1.707008841e-016
		,1.704036850e-016
		,1.701366481e-016
		,1.698918221e-016
		,1.696635774e-016
		,1.694481408e-016
		,1.692431671e-016
		,1.690473157e-016
		,1.688598714e-016
		,1.686805317e-016
		,1.685095719e-016
		,1.683491408e-016
		,1.682088554e-016
		,1.681250166e-016
		,1.682357007e-016
		,1.690645454e-016
		,1.725297208e-016
		,1.845792436e-016
		,2.155944587e-016
		,2.649031038e-016
		,3.142124482e-016
		,3.517319498e-016
		,3.776072887e-016
		,3.953979682e-016
		,4.080493663e-016
		,4.174311946e-016
		,4.246608402e-016
		,4.304206693e-016
		,4.351354944e-016
		,4.390811771e-016
		,4.424429920e-016
		,4.453495092e-016
		,4.478926949e-016
		,4.501402166e-016
		,4.521431791e-016
		,4.539410986e-016
		,1.730709469e-016
		,1.722657597e-016
		,1.716990482e-016
		,1.712529573e-016
		,1.708813348e-016
		,1.705609998e-016
		,1.702775013e-016
		,1.700207646e-016
		,1.697836020e-016
		,1.695610373e-016
		,1.693498365e-016
		,1.691480729e-016
		,1.689547054e-016
		,1.687692166e-016
		,1.685914072e-016
		,1.684217059e-016
		,1.682625305e-016
		,1.681244611e-016
		,1.680490818e-016
		,1.681921289e-016
		,1.691464030e-016
		,1.730761718e-016
		,1.864826463e-016
		,2.195666069e-016
		,2.695992023e-016
		,3.180749567e-016
		,3.545421366e-016
		,3.796346579e-016
		,3.969052296e-016
		,4.092154287e-016
		,4.183669311e-016
		,4.254358862e-016
		,4.310778863e-016
		,4.357024398e-016
		,4.395762192e-016
		,4.428788750e-016
		,4.457354786e-016
		,4.482358064e-016
		,4.504461335e-016
		,4.524166390e-016
		,4.541861730e-016
		,1.727815367e-016
		,1.720379699e-016
		,1.715096724e-016
		,1.710907306e-016
		,1.707392566e-016
		,1.704339807e-016
		,1.701616187e-016
		,1.699129865e-016
		,1.696816352e-016
		,1.694632036e-016
		,1.692549482e-016
		,1.690553160e-016
		,1.688635198e-016
		,1.686792036e-016
		,1.685022446e-016
		,1.683331363e-016
		,1.681746745e-016
		,1.680383493e-016
		,1.679711690e-016
		,1.681510833e-016
		,1.692502326e-016
		,1.737037414e-016
		,1.885730829e-016
		,2.236871232e-016
		,2.742288606e-016
		,3.217949985e-016
		,3.572279740e-016
		,3.815695874e-016
		,3.983460043e-016
		,4.103323411e-016
		,4.192636274e-016
		,4.261777550e-016
		,4.317050671e-016
		,4.362414834e-016
		,4.400450641e-016
		,4.432901267e-016
		,4.460983636e-016
		,4.485573962e-016
		,4.507321292e-016
		,4.526718201e-016
		,4.544146345e-016
		,1.725295655e-016
		,1.718410206e-016
		,1.713467201e-016
		,1.709515647e-016
		,1.706173590e-016
		,1.703246408e-016
		,1.700612539e-016
		,1.698188729e-016
		,1.695917497e-016
		,1.693761145e-016
		,1.691696558e-016
		,1.689711293e-016
		,1.687800097e-016
		,1.685959859e-016
		,1.684191674e-016
		,1.682498528e-016
		,1.680912020e-016
		,1.679559182e-016
		,1.678949114e-016
		,1.681139981e-016
		,1.693776112e-016
		,1.744253441e-016
		,1.908568901e-016
		,2.279032176e-016
		,2.787646048e-016
		,3.253697133e-016
		,3.597917581e-016
		,3.834127812e-016
		,3.997201273e-016
		,4.114002370e-016
		,4.201239214e-016
		,4.268905657e-016
		,4.323082134e-016
		,4.367594590e-016
		,4.404943731e-016
		,4.436825127e-016
		,4.464427827e-016
		,4.488610203e-016
		,4.510008427e-016
		,4.529105167e-016
		,4.546274236e-016
		,1.723289553e-016
		,1.716869160e-016
		,1.712170222e-016
		,1.708421073e-016
		,1.705217313e-016
		,1.702391517e-016
		,1.699824244e-016
		,1.697444220e-016
		,1.695203063e-016
		,1.693056874e-016
		,1.691002832e-016
		,1.689020082e-016
		,1.687102950e-016
		,1.685255009e-016
		,1.683488681e-016
		,1.681805685e-016
		,1.680212026e-016
		,1.678872454e-016
		,1.678322505e-016
		,1.680829424e-016
		,1.695260721e-016
		,1.752377441e-016
		,1.933477734e-016
		,2.322222435e-016
		,2.831576406e-016
		,3.287819054e-016
		,3.622310962e-016
		,3.851673392e-016
		,4.010327848e-016
		,4.124244386e-016
		,4.209498963e-016
		,4.275739372e-016
		,4.328845155e-016
		,4.372522799e-016
		,4.409202315e-016
		,4.440534948e-016
		,4.467680657e-016
		,4.491478151e-016
		,4.512549647e-016
		,4.531367468e-016
		,4.548297491e-016
		,1.724585282e-016
		,1.717909913e-016
		,1.712473719e-016
		,1.708719153e-016
		,1.705473176e-016
		,1.702606091e-016
		,1.699981600e-016
		,1.697557968e-016
		,1.695200770e-016
		,1.692999067e-016
		,1.690832902e-016
		,1.688792584e-016
		,1.686796824e-016
		,1.684882931e-016
		,1.682787925e-016
		,1.681446598e-016
		,1.679949538e-016
		,1.678736578e-016
		,1.678484784e-016
		,1.681341028e-016
		,1.697435104e-016
		,1.761692803e-016
		,1.960611178e-016
		,2.366940639e-016
		,2.875414236e-016
		,3.320611682e-016
		,3.645206126e-016
		,3.868103763e-016
		,4.022721776e-016
		,4.133927563e-016
		,4.217299829e-016
		,4.282189635e-016
		,4.334284692e-016
		,4.377182929e-016
		,4.413247356e-016
		,4.444078493e-016
		,4.470801694e-016
		,4.494238285e-016
		,4.515000951e-016
		,4.533554432e-016
		,4.550257800e-016
		,1.753140792e-016
		,1.737981970e-016
		,1.726350312e-016
		,1.719192401e-016
		,1.714973324e-016
		,1.710697270e-016
		,1.707488253e-016
		,1.703873404e-016
		,1.700913636e-016
		,1.696734591e-016
		,1.694839411e-016
		,1.690743711e-016
		,1.688396365e-016
		,1.685965339e-016
		,1.679754035e-016
		,1.678925840e-016
		,1.681294314e-016
		,1.678646786e-016
		,1.681944533e-016
		,1.688392024e-016
		,1.707057945e-016
		,1.779381231e-016
		,1.998560658e-016
		,2.421730094e-016
		,2.925611216e-016
		,3.357418273e-016
		,3.670673336e-016
		,3.885858865e-016
		,4.035461312e-016
		,4.143470011e-016
		,4.224744225e-016
		,4.288230467e-016
		,4.339377629e-016
		,4.381606037e-016
		,4.417145400e-016
		,4.447524516e-016
		,4.473854233e-016
		,4.496952133e-016
		,4.517424978e-016
		,4.535731445e-016
		,4.552224733e-016
		,1.848395654e-016
		,1.804156074e-016
		,1.785581498e-016
		,1.756247829e-016
		,1.749606920e-016
		,1.741222210e-016
		,1.734689278e-016
		,1.728866349e-016
		,1.717841715e-016
		,1.712337960e-016
		,1.708999140e-016
		,1.698778287e-016
		,1.698431743e-016
		,1.682986803e-016
		,1.681684715e-016
		,1.669911641e-016
		,1.677931968e-016
		,1.691104448e-016
		,1.688576170e-016
		,1.702668522e-016
		,1.731205802e-016
		,1.816527627e-016
		,2.064070547e-016
		,2.516844261e-016
		,3.009544373e-016
		,3.417412376e-016
		,3.711688110e-016
		,3.914493196e-016
		,4.056303945e-016
		,4.159261608e-016
		,4.237103212e-016
		,4.298109800e-016
		,4.347360519e-016
		,4.388102335e-016
		,4.422484926e-016
		,4.451986695e-016
		,4.477651108e-016
		,4.500239927e-016
		,4.520319019e-016
		,4.538316439e-016
		,4.554562908e-016
		,1.984480905e-016
		,1.903565749e-016
		,1.888374056e-016
		,1.842521582e-016
		,1.814784569e-016
		,1.799943547e-016
		,1.779837446e-016
		,1.767353769e-016
		,1.754153757e-016
		,1.748721458e-016
		,1.731919585e-016
		,1.719142659e-016
		,1.723426654e-016
		,1.705987718e-016
		,1.682463672e-016
		,1.694241163e-016
		,1.694451378e-016
		,1.698570860e-016
		,1.717773176e-016
		,1.726323446e-016
		,1.749827118e-016
		,1.844498716e-016
		,2.134355809e-016
		,2.627480285e-016
		,3.114484173e-016
		,3.494296386e-016
		,3.768793405e-016
		,3.957731703e-016
		,4.089419249e-016
		,4.184922588e-016
		,4.257524606e-016
		,4.314819450e-016
		,4.361398019e-016
		,4.400166875e-016
		,4.433079552e-016
		,4.461441757e-016
		,4.486231848e-016
		,4.508120349e-016
		,4.527605288e-016
		,4.545098312e-016
		,4.560911812e-016
		,2.088370944e-016
		,2.033773331e-016
		,1.984213488e-016
		,1.956358844e-016
		,1.900723493e-016
		,1.862922482e-016
		,1.837786064e-016
		,1.822524902e-016
		,1.811253147e-016
		,1.796980437e-016
		,1.774616512e-016
		,1.757185351e-016
		,1.756730426e-016
		,1.761370138e-016
		,1.716646357e-016
		,1.723715532e-016
		,1.730762238e-016
		,1.747590872e-016
		,1.744753878e-016
		,1.754908848e-016
		,1.776643809e-016
		,1.839078830e-016
		,2.083998681e-016
		,2.641735546e-016
		,3.228014887e-016
		,3.610510365e-016
		,3.850583384e-016
		,4.011616742e-016
		,4.126336123e-016
		,4.212024194e-016
		,4.278212663e-016
		,4.331010601e-016
		,4.374326657e-016
		,4.410682077e-016
		,4.441741521e-016
		,4.468967379e-016
		,4.493246754e-016
		,4.515283302e-016
		,4.535553931e-016
		,4.553880601e-016
		,4.570370293e-016
		,2.154613957e-016
		,2.128969535e-016
		,2.068533709e-016
		,2.045146635e-016
		,2.016994142e-016
		,1.965662110e-016
		,1.923595483e-016
		,1.899465320e-016
		,1.890435052e-016
		,1.858568215e-016
		,1.844482351e-016
		,1.838330850e-016
		,1.813614594e-016
		,1.805657412e-016
		,1.810982882e-016
		,1.766206724e-016
		,1.769271917e-016
		,1.779562900e-016
		,1.796671051e-016
		,1.800354727e-016
		,1.807044230e-016
		,1.848416709e-016
		,1.990482938e-016
		,2.402445987e-016
		,3.061585096e-016
		,3.598827217e-016
		,3.911559610e-016
		,4.089716878e-016
		,4.203801550e-016
		,4.283859890e-016
		,4.343926768e-016
		,4.391421141e-016
		,4.430238535e-016
		,4.462756320e-016
		,4.490689157e-016
		,4.514925706e-016
		,4.536203420e-016
		,4.554806857e-016
		,4.571707076e-016
		,4.586949341e-016
		,4.600770354e-016
		,2.340032749e-016
		,2.165626063e-016
		,2.155446044e-016
		,2.089041870e-016
		,2.077894889e-016
		,2.066890468e-016
		,2.022401593e-016
		,1.965692552e-016
		,1.941470417e-016
		,1.926477569e-016
		,1.908979264e-016
		,1.895881935e-016
		,1.901026536e-016
		,1.884876774e-016
		,1.874343348e-016
		,1.863987122e-016
		,1.842226320e-016
		,1.827616798e-016
		,1.831631556e-016
		,1.848655304e-016
		,1.866702566e-016
		,1.876722837e-016
		,1.965799622e-016
		,2.203323392e-016
		,2.651583022e-016
		,3.246459353e-016
		,3.768900186e-016
		,4.095810521e-016
		,4.262040691e-016
		,4.358584128e-016
		,4.421173235e-016
		,4.469261186e-016
		,4.501661226e-016
		,4.531439561e-016
		,4.557775916e-016
		,4.579707103e-016
		,4.598478809e-016
		,4.614689439e-016
		,4.628842519e-016
		,4.641713938e-016
		,4.653249510e-016
		,2.497993746e-016
		,2.323122042e-016
		,2.221751744e-016
		,2.197177902e-016
		,2.152838867e-016
		,2.143839205e-016
		,2.130113772e-016
		,2.097767996e-016
		,2.019420790e-016
		,1.956319026e-016
		,1.962731207e-016
		,1.968328015e-016
		,1.957660592e-016
		,1.946540381e-016
		,1.939801588e-016
		,1.916083711e-016
		,1.926203009e-016
		,1.914937178e-016
		,1.904504899e-016
		,1.887899144e-016
		,1.879496531e-016
		,1.951713808e-016
		,1.999751625e-016
		,2.125252791e-016
		,2.395975143e-016
		,2.850829607e-016
		,3.369103989e-016
		,3.829836309e-016
		,4.174480967e-016
		,4.368049136e-016
		,4.475835775e-016
		,4.544903588e-016
		,4.574074177e-016
		,4.607801860e-016
		,4.634122868e-016
		,4.657426347e-016
		,4.667082634e-016
		,4.680968085e-016
		,4.694573882e-016
		,4.705766061e-016
		,4.715268386e-016
		,2.608405113e-016
		,2.548768470e-016
		,2.337314754e-016
		,2.275045140e-016
		,2.249939298e-016
		,2.218194514e-016
		,2.210132361e-016
		,2.064847312e-016
		,2.080395624e-016
		,2.050223760e-016
		,2.055896465e-016
		,2.051383143e-016
		,2.047010176e-016
		,2.036910283e-016
		,2.019153694e-016
		,1.995901728e-016
		,1.981237854e-016
		,1.989495491e-016
		,1.959742925e-016
		,1.955868194e-016
		,1.962793166e-016
		,1.967314273e-016
		,2.015861640e-016
		,2.182855413e-016
		,2.322162144e-016
		,2.574832998e-016
		,2.965636067e-016
		,3.431050620e-016
		,3.849955534e-016
		,4.188022739e-016
		,4.417193637e-016
		,4.552592724e-016
		,4.640551977e-016
		,4.688681290e-016
		,4.725225256e-016
		,4.739674242e-016
		,4.750261377e-016
		,4.766048723e-016
		,4.780340781e-016
		,4.776162939e-016
		,4.783585098e-016
		,2.657402438e-016
		,2.594771475e-016
		,2.350646042e-016
		,2.205800995e-016
		,2.127249025e-016
		,2.151747931e-016
		,2.179884958e-016
		,2.204543888e-016
		,2.203089769e-016
		,2.168117906e-016
		,2.136232239e-016
		,2.136483110e-016
		,2.123579701e-016
		,2.106265744e-016
		,2.083421780e-016
		,2.059348106e-016
		,2.055185433e-016
		,2.046373643e-016
		,2.030395535e-016
		,2.030114314e-016
		,2.052113579e-016
		,2.094573404e-016
		,2.166378224e-016
		,2.320408062e-016
		,2.579962138e-016
		,2.726579101e-016
		,3.014406296e-016
		,3.305582720e-016
		,3.526089565e-016
		,3.822584531e-016
		,4.164978633e-016
		,4.437000237e-016
		,4.626040178e-016
		,4.735555003e-016
		,4.789048137e-016
		,4.828322361e-016
		,4.845846932e-016
		,4.867855117e-016
		,4.855596984e-016
		,4.864406772e-016
		,4.873257751e-016
		,2.489747800e-016
		,2.470108363e-016
		,2.244670226e-016
		,2.273405828e-016
		,2.297633214e-016
		,2.284510838e-016
		,2.296456048e-016
		,2.300552503e-016
		,2.298519044e-016
		,2.265024236e-016
		,2.213184688e-016
		,2.212844642e-016
		,2.190629438e-016
		,2.162263233e-016
		,2.134402168e-016
		,2.104444027e-016
		,2.127629818e-016
		,2.130402873e-016
		,2.105844862e-016
		,2.132485673e-016
		,2.210708907e-016
		,2.293076165e-016
		,2.403237111e-016
		,2.469523228e-016
		,2.652017147e-016
		,2.791899148e-016
		,2.943797103e-016
		,3.059478388e-016
		,3.350760982e-016
		,3.640658082e-016
		,3.839779672e-016
		,4.084548715e-016
		,4.359631656e-016
		,4.586942676e-016
		,4.756082032e-016
		,4.866603015e-016
		,4.926963830e-016
		,4.950732866e-016
		,4.981021316e-016
		,4.981554208e-016
		,4.975424818e-016
		,1.752457975e-016
		,1.740663391e-016
		,1.732850346e-016
		,1.727036885e-016
		,1.722514023e-016
		,1.719007931e-016
		,1.716453865e-016
		,1.715014312e-016
		,1.715367421e-016
		,1.719364692e-016
		,1.731314473e-016
		,1.755505540e-016
		,1.790375865e-016
		,1.820203744e-016
		,1.835200322e-016
		,1.843129377e-016
		,1.865939558e-016
		,1.875648569e-016
		,1.904278355e-016
		,1.953806396e-016
		,1.987259275e-016
		,2.041596985e-016
		,2.166675470e-016
		,2.352284591e-016
		,2.647770902e-016
		,2.997808594e-016
		,3.311693004e-016
		,3.568073545e-016
		,3.768674563e-016
		,3.923650205e-016
		,4.042074082e-016
		,4.133108605e-016
		,4.204491600e-016
		,4.261860687e-016
		,4.309073171e-016
		,4.348736989e-016
		,4.382676769e-016
		,4.412217573e-016
		,4.438317721e-016
		,4.461646081e-016
		,4.482658672e-016
		,1.746025821e-016
		,1.735043229e-016
		,1.727536420e-016
		,1.721751005e-016
		,1.717029413e-016
		,1.713066006e-016
		,1.709682525e-016
		,1.706761849e-016
		,1.704237142e-016
		,1.702116683e-016
		,1.700576690e-016
		,1.700191539e-016
		,1.702008741e-016
		,1.707576424e-016
		,1.714643263e-016
		,1.720828798e-016
		,1.722500187e-016
		,1.736731694e-016
		,1.743450544e-016
		,1.777658516e-016
		,1.801843958e-016
		,1.849333843e-016
		,1.974609503e-016
		,2.192461722e-016
		,2.570607879e-016
		,3.031045567e-016
		,3.417633164e-016
		,3.691499660e-016
		,3.883464368e-016
		,4.021560621e-016
		,4.125357088e-016
		,4.206045744e-016
		,4.270186773e-016
		,4.322165545e-016
		,4.365066280e-016
		,4.401131946e-016
		,4.432004664e-016
		,4.458851748e-016
		,4.482483199e-016
		,4.503474740e-016
		,4.522260249e-016
		,1.741446230e-016
		,1.731370663e-016
		,1.724393579e-016
		,1.718966105e-016
		,1.714499291e-016
		,1.710709781e-016
		,1.707424314e-016
		,1.704520047e-016
		,1.701905856e-016
		,1.699516344e-016
		,1.697310801e-016
		,1.695279622e-016
		,1.693458904e-016
		,1.691959945e-016
		,1.690944699e-016
		,1.690026674e-016
		,1.689721398e-016
		,1.689335283e-016
		,1.691281360e-016
		,1.696007570e-016
		,1.706091900e-016
		,1.744012839e-016
		,1.851026598e-016
		,2.122875765e-016
		,2.588308126e-016
		,3.085856640e-016
		,3.474470578e-016
		,3.744241467e-016
		,3.930359251e-016
		,4.062601636e-016
		,4.160298092e-016
		,4.235225932e-016
		,4.294691709e-016
		,4.343257657e-016
		,4.383824528e-016
		,4.418304654e-016
		,4.448027176e-016
		,4.473956733e-016
		,4.496814410e-016
		,4.517149885e-016
		,4.535388923e-016
		,1.737515427e-016
		,1.728276103e-016
		,1.721814809e-016
		,1.716757333e-016
		,1.712573988e-016
		,1.709003882e-016
		,1.705884783e-016
		,1.703101420e-016
		,1.700568717e-016
		,1.698225096e-016
		,1.696028281e-016
		,1.693951586e-016
		,1.691980727e-016
		,1.690111578e-016
		,1.688351151e-016
		,1.686700189e-016
		,1.685185477e-016
		,1.683928846e-016
		,1.683214363e-016
		,1.684572223e-016
		,1.692946313e-016
		,1.726533765e-016
		,1.843073693e-016
		,2.145268200e-016
		,2.633292949e-016
		,3.128880765e-016
		,3.508306319e-016
		,3.770077887e-016
		,3.949828816e-016
		,4.077473981e-016
		,4.172036200e-016
		,4.244839016e-016
		,4.302793362e-016
		,4.350199302e-016
		,4.389853678e-016
		,4.423630641e-016
		,4.452823527e-016
		,4.478355112e-016
		,4.500905666e-016
		,4.520990884e-016
		,4.539011078e-016
		,1.733982213e-016
		,1.725498755e-016
		,1.719513727e-016
		,1.714801870e-016
		,1.710884453e-016
		,1.707521176e-016
		,1.704561209e-016
		,1.701897917e-016
		,1.699453786e-016
		,1.697173901e-016
		,1.695021506e-016
		,1.692973822e-016
		,1.691017900e-016
		,1.689146965e-016
		,1.687358352e-016
		,1.685655676e-016
		,1.684063601e-016
		,1.682685600e-016
		,1.681920097e-016
		,1.683278724e-016
		,1.692481220e-016
		,1.730367430e-016
		,1.860091039e-016
		,2.184161661e-016
		,2.682074836e-016
		,3.169775878e-016
		,3.538096314e-016
		,3.791497671e-016
		,3.965668397e-016
		,4.089665548e-016
		,4.181762133e-016
		,4.252874883e-016
		,4.309609821e-016
		,4.356098743e-016
		,4.395024895e-016
		,4.428195805e-016
		,4.456871208e-016
		,4.481956708e-016
		,4.504121752e-016
		,4.523873596e-016
		,4.541604990e-016
		,1.730755234e-016
		,1.722951128e-016
		,1.717398407e-016
		,1.712999992e-016
		,1.709321823e-016
		,1.706142811e-016
		,1.703323552e-016
		,1.700766251e-016
		,1.698400983e-016
		,1.696179362e-016
		,1.694070016e-016
		,1.692054322e-016
		,1.690122250e-016
		,1.688268748e-016
		,1.686491862e-016
		,1.684794969e-016
		,1.683205194e-016
		,1.681839640e-016
		,1.681138049e-016
		,1.682848166e-016
		,1.693489534e-016
		,1.736646479e-016
		,1.881310876e-016
		,2.226729319e-016
		,2.730520113e-016
		,3.208843564e-016
		,3.566239141e-016
		,3.811715097e-016
		,3.980710044e-016
		,4.101336268e-016
		,4.191173480e-016
		,4.260684756e-016
		,4.316234959e-016
		,4.361803051e-016
		,4.399986319e-016
		,4.432541966e-016
		,4.460698874e-016
		,4.485342670e-016
		,4.507128866e-016
		,4.526554203e-016
		,4.544003160e-016
		,1.727803741e-016
		,1.720606435e-016
		,1.715440466e-016
		,1.711320195e-016
		,1.707851435e-016
		,1.704831235e-016
		,1.702131467e-016
		,1.699663065e-016
		,1.697363413e-016
		,1.695190227e-016
		,1.693117024e-016
		,1.691128856e-016
		,1.689218218e-016
		,1.687381592e-016
		,1.685617768e-016
		,1.683930746e-016
		,1.682345807e-016
		,1.680999431e-016
		,1.680385114e-016
		,1.682456898e-016
		,1.694799008e-016
		,1.744062431e-016
		,1.904904208e-016
		,2.270618917e-016
		,2.778092197e-016
		,3.246437519e-016
		,3.593132791e-016
		,3.831037076e-016
		,3.995138622e-016
		,4.112571132e-016
		,4.200222291e-016
		,4.268175838e-016
		,4.322554779e-016
		,4.367210713e-016
		,4.404661234e-016
		,4.436613922e-016
		,4.464266407e-016
		,4.488483889e-016
		,4.509907824e-016
		,4.529024623e-016
		,4.546210434e-016
		,1.725141746e-016
		,1.718482684e-016
		,1.713657543e-016
		,1.709778687e-016
		,1.706488035e-016
		,1.703599845e-016
		,1.700996966e-016
		,1.698598760e-016
		,1.696349508e-016
		,1.694212534e-016
		,1.692165728e-016
		,1.690197325e-016
		,1.688301924e-016
		,1.686477231e-016
		,1.684722478e-016
		,1.683042054e-016
		,1.681460229e-016
		,1.680117309e-016
		,1.679588972e-016
		,1.682024245e-016
		,1.696108761e-016
		,1.752323126e-016
		,1.930639499e-016
		,2.315776573e-016
		,2.824276852e-016
		,3.282176446e-016
		,3.618619115e-016
		,3.849409425e-016
		,4.008907927e-016
		,4.123308967e-016
		,4.208885031e-016
		,4.275347474e-016
		,4.328606968e-016
		,4.372391101e-016
		,4.409143534e-016
		,4.440523196e-016
		,4.467695907e-016
		,4.491506912e-016
		,4.512584085e-016
		,4.531403495e-016
		,4.548333140e-016
		,1.722800837e-016
		,1.716618966e-016
		,1.712092376e-016
		,1.708420911e-016
		,1.705279298e-016
		,1.702498173e-016
		,1.699970857e-016
		,1.697624765e-016
		,1.695410615e-016
		,1.693296883e-016
		,1.691265330e-016
		,1.689306986e-016
		,1.687418185e-016
		,1.685597581e-016
		,1.683844735e-016
		,1.682163875e-016
		,1.680580288e-016
		,1.679219522e-016
		,1.678737336e-016
		,1.681584423e-016
		,1.697223526e-016
		,1.760892000e-016
		,1.958053758e-016
		,2.361762216e-016
		,2.869641237e-016
		,3.316213546e-016
		,3.642350912e-016
		,3.866341343e-016
		,4.021693918e-016
		,4.133331255e-016
		,4.216967335e-016
		,4.282043992e-016
		,4.334277852e-016
		,4.377253811e-016
		,4.413340971e-016
		,4.444168337e-016
		,4.470882871e-016
		,4.494312391e-016
		,4.515069563e-016
		,4.533618391e-016
		,4.550317705e-016
		,1.720791330e-016
		,1.715032589e-016
		,1.710766635e-016
		,1.707274775e-016
		,1.704259216e-016
		,1.701566051e-016
		,1.699098426e-016
		,1.696791123e-016
		,1.694601059e-016
		,1.692500958e-016
		,1.690476725e-016
		,1.688520870e-016
		,1.686631715e-016
		,1.684808365e-016
		,1.683051125e-016
		,1.681363192e-016
		,1.679770427e-016
		,1.678383033e-016
		,1.677860376e-016
		,1.680991715e-016
		,1.698441622e-016
		,1.768474873e-016
		,1.985903886e-016
		,2.408214891e-016
		,2.914226382e-016
		,3.349426141e-016
		,3.665609520e-016
		,3.882730435e-016
		,4.033480742e-016
		,4.142156511e-016
		,4.223835149e-016
		,4.287579818e-016
		,4.338923341e-016
		,4.381295821e-016
		,4.416906927e-016
		,4.447316124e-016
		,4.473663180e-016
		,4.496776666e-016
		,4.517266439e-016
		,4.535591662e-016
		,4.552105569e-016
		,1.719314405e-016
		,1.713854588e-016
		,1.709767634e-016
		,1.706407922e-016
		,1.703490035e-016
		,1.700861150e-016
		,1.698434817e-016
		,1.696151924e-016
		,1.693970957e-016
		,1.691876513e-016
		,1.689848953e-016
		,1.687895322e-016
		,1.685997298e-016
		,1.684163011e-016
		,1.682392414e-016
		,1.680697890e-016
		,1.679084358e-016
		,1.677699101e-016
		,1.677061822e-016
		,1.680195230e-016
		,1.699053324e-016
		,1.775533683e-016
		,2.010531270e-016
		,2.453691752e-016
		,2.958086753e-016
		,3.382191627e-016
		,3.688420603e-016
		,3.898910993e-016
		,4.045457890e-016
		,4.151399361e-016
		,4.231187708e-016
		,4.293511034e-016
		,4.343682324e-016
		,4.385070717e-016
		,4.419913586e-016
		,4.449750177e-016
		,4.475666958e-016
		,4.498450712e-016
		,4.518685757e-016
		,4.536815977e-016
		,4.553185044e-016
		,1.722106367e-016
		,1.715497373e-016
		,1.710936459e-016
		,1.707151128e-016
		,1.704152327e-016
		,1.701385420e-016
		,1.698902836e-016
		,1.696474615e-016
		,1.694210499e-016
		,1.692004652e-016
		,1.689910278e-016
		,1.687876271e-016
		,1.685911556e-016
		,1.684028231e-016
		,1.682024768e-016
		,1.680453595e-016
		,1.678357139e-016
		,1.677227455e-016
		,1.676753130e-016
		,1.679580982e-016
		,1.699247820e-016
		,1.781722515e-016
		,2.030841506e-016
		,2.494226017e-016
		,3.001507819e-016
		,3.414237612e-016
		,3.711098389e-016
		,3.915179701e-016
		,4.057517750e-016
		,4.160687234e-016
		,4.238584097e-016
		,4.299556982e-016
		,4.348726051e-016
		,4.389361119e-016
		,4.423628816e-016
		,4.453014332e-016
		,4.478567004e-016
		,4.501048789e-016
		,4.521026247e-016
		,4.538929635e-016
		,4.555091823e-016
		,1.757371339e-016
		,1.737492644e-016
		,1.729542926e-016
		,1.719226874e-016
		,1.715241179e-016
		,1.711262852e-016
		,1.707458036e-016
		,1.704131551e-016
		,1.701015476e-016
		,1.697636647e-016
		,1.695220708e-016
		,1.691817034e-016
		,1.688907610e-016
		,1.687176623e-016
		,1.683907726e-016
		,1.681448656e-016
		,1.675665516e-016
		,1.673564589e-016
		,1.676523280e-016
		,1.679497360e-016
		,1.699058893e-016
		,1.789697445e-016
		,2.060698938e-016
		,2.534865183e-016
		,3.042351897e-016
		,3.451273153e-016
		,3.737671727e-016
		,3.933523267e-016
		,4.070776525e-016
		,4.170928450e-016
		,4.247036065e-016
		,4.306755957e-016
		,4.354950868e-016
		,4.394831639e-016
		,4.428517311e-016
		,4.457442068e-016
		,4.482615597e-016
		,4.504774554e-016
		,4.524471822e-016
		,4.542128826e-016
		,4.558072466e-016
		,1.860159825e-016
		,1.808962005e-016
		,1.792141297e-016
		,1.765144618e-016
		,1.752670096e-016
		,1.744940947e-016
		,1.735562753e-016
		,1.731669335e-016
		,1.724313982e-016
		,1.720216030e-016
		,1.711242720e-016
		,1.705892186e-016
		,1.699496545e-016
		,1.693386583e-016
		,1.692764475e-016
		,1.684272112e-016
		,1.678602301e-016
		,1.656651949e-016
		,1.667616752e-016
		,1.685160123e-016
		,1.702890807e-016
		,1.784563695e-016
		,2.080070178e-016
		,2.610480673e-016
		,3.124840400e-016
		,3.503865617e-016
		,3.767466291e-016
		,3.950127497e-016
		,4.081663744e-016
		,4.180684313e-016
		,4.256866633e-016
		,4.316735493e-016
		,4.364784568e-016
		,4.404308405e-016
		,4.437434424e-016
		,4.465794479e-016
		,4.490489402e-016
		,4.512196980e-016
		,4.531597295e-016
		,4.549015956e-016
		,4.564758704e-016
		,1.975986502e-016
		,1.922668575e-016
		,1.880341529e-016
		,1.861005885e-016
		,1.810624006e-016
		,1.803778112e-016
		,1.792745531e-016
		,1.777906837e-016
		,1.771417555e-016
		,1.753518708e-016
		,1.743158760e-016
		,1.729364927e-016
		,1.729998816e-016
		,1.706742221e-016
		,1.699172546e-016
		,1.707738389e-016
		,1.682428553e-016
		,1.687002150e-016
		,1.664780693e-016
		,1.684666192e-016
		,1.720687967e-016
		,1.783048590e-016
		,2.000484456e-016
		,2.562363685e-016
		,3.191378677e-016
		,3.601384749e-016
		,3.849302743e-016
		,4.012429755e-016
		,4.128316730e-016
		,4.214765453e-016
		,4.281638589e-016
		,4.335132626e-016
		,4.378971583e-016
		,4.415608541e-016
		,4.447151925e-016
		,4.474511097e-016
		,4.498529500e-016
		,4.519693244e-016
		,4.538773052e-016
		,4.556012887e-016
		,4.571650744e-016
		,2.068330173e-016
		,2.049883023e-016
		,1.965035175e-016
		,1.958812750e-016
		,1.932430338e-016
		,1.868339183e-016
		,1.858755474e-016
		,1.835910126e-016
		,1.812993498e-016
		,1.800072092e-016
		,1.789847149e-016
		,1.779614099e-016
		,1.757411562e-016
		,1.736904844e-016
		,1.735415016e-016
		,1.718023259e-016
		,1.720713598e-016
		,1.706362995e-016
		,1.730624033e-016
		,1.709385384e-016
		,1.736439579e-016
		,1.791913033e-016
		,1.935532934e-016
		,2.319213431e-016
		,2.987910353e-016
		,3.560236828e-016
		,3.893237239e-016
		,4.083561851e-016
		,4.199087642e-016
		,4.282274051e-016
		,4.343797372e-016
		,4.392161688e-016
		,4.431289081e-016
		,4.464331555e-016
		,4.492684791e-016
		,4.517264992e-016
		,4.538361628e-016
		,4.557451184e-016
		,4.574641133e-016
		,4.590101339e-016
		,4.604098320e-016
		,2.160592459e-016
		,2.107666130e-016
		,2.082520450e-016
		,2.028587016e-016
		,2.012803061e-016
		,1.989039717e-016
		,1.921701526e-016
		,1.905833115e-016
		,1.890403719e-016
		,1.873374848e-016
		,1.858204646e-016
		,1.841576927e-016
		,1.796821458e-016
		,1.794181445e-016
		,1.790959932e-016
		,1.785963475e-016
		,1.760546330e-016
		,1.753278305e-016
		,1.763084299e-016
		,1.774507421e-016
		,1.780108257e-016
		,1.809142938e-016
		,1.912014937e-016
		,2.168863204e-016
		,2.621279382e-016
		,3.195719181e-016
		,3.730456104e-016
		,4.072625276e-016
		,4.251936344e-016
		,4.350596076e-016
		,4.416637676e-016
		,4.465818158e-016
		,4.503447755e-016
		,4.530773780e-016
		,4.557971418e-016
		,4.580522532e-016
		,4.599637192e-016
		,4.616036567e-016
		,4.629921579e-016
		,4.642966391e-016
		,4.654616572e-016
		,2.388717706e-016
		,2.156339937e-016
		,2.151148030e-016
		,2.094742554e-016
		,2.069051611e-016
		,2.056342281e-016
		,2.035944059e-016
		,1.967075968e-016
		,1.949909793e-016
		,1.933812215e-016
		,1.884947167e-016
		,1.854032335e-016
		,1.852659811e-016
		,1.849510865e-016
		,1.852987647e-016
		,1.863365840e-016
		,1.845954600e-016
		,1.819970460e-016
		,1.813230599e-016
		,1.822184786e-016
		,1.835670579e-016
		,1.874029289e-016
		,1.938503889e-016
		,2.082908851e-016
		,2.376113322e-016
		,2.849966296e-016
		,3.381509806e-016
		,3.846162991e-016
		,4.166101787e-016
		,4.344157427e-016
		,4.457485037e-016
		,4.523552858e-016
		,4.572716363e-016
		,4.601558442e-016
		,4.630228618e-016
		,4.653994278e-016
		,4.668972330e-016
		,4.680117816e-016
		,4.693582996e-016
		,4.705048782e-016
		,4.714762956e-016
		,2.489209957e-016
		,2.362796587e-016
		,2.200226575e-016
		,2.198875045e-016
		,2.143880123e-016
		,2.130184907e-016
		,2.121574751e-016
		,2.099072041e-016
		,1.980807914e-016
		,1.939672319e-016
		,1.933104949e-016
		,1.931413953e-016
		,1.931377713e-016
		,1.925280343e-016
		,1.918084006e-016
		,1.919047209e-016
		,1.901107558e-016
		,1.888388735e-016
		,1.871612731e-016
		,1.872162588e-016
		,1.901818185e-016
		,1.928792527e-016
		,1.971884068e-016
		,2.120620009e-016
		,2.295463612e-016
		,2.563186675e-016
		,2.985710963e-016
		,3.467852789e-016
		,3.898366003e-016
		,4.238078071e-016
		,4.453330603e-016
		,4.561747200e-016
		,4.606098057e-016
		,4.637466391e-016
		,4.706389427e-016
		,4.738936698e-016
		,4.743476197e-016
		,4.762629211e-016
		,4.777669088e-016
		,4.779687565e-016
		,4.782931051e-016
		,2.540809062e-016
		,2.375719964e-016
		,2.256065235e-016
		,2.249173086e-016
		,2.203145639e-016
		,2.046995850e-016
		,2.062102915e-016
		,2.075539607e-016
		,2.049591838e-016
		,2.000189551e-016
		,2.014774440e-016
		,2.016704013e-016
		,2.011860290e-016
		,2.008428179e-016
		,1.998563039e-016
		,1.982323817e-016
		,1.972368866e-016
		,1.937031693e-016
		,1.944218145e-016
		,1.957021476e-016
		,1.988016171e-016
		,2.049423349e-016
		,2.142906492e-016
		,2.272865945e-016
		,2.549015147e-016
		,2.733996442e-016
		,3.035692720e-016
		,3.354329773e-016
		,3.581531151e-016
		,3.879674670e-016
		,4.238318490e-016
		,4.512342095e-016
		,4.688728644e-016
		,4.776331754e-016
		,4.802074003e-016
		,4.799437038e-016
		,4.795786427e-016
		,4.855925563e-016
		,4.860848452e-016
		,4.858770675e-016
		,4.869919888e-016
		,2.648200648e-016
		,2.588193328e-016
		,2.284935201e-016
		,2.062438363e-016
		,2.143516923e-016
		,2.140407035e-016
		,2.148613536e-016
		,2.152642152e-016
		,2.157384909e-016
		,2.143824892e-016
		,2.107043746e-016
		,2.104042180e-016
		,2.104596592e-016
		,2.096254057e-016
		,2.089041530e-016
		,2.060825132e-016
		,2.037421101e-016
		,2.021666622e-016
		,2.014280263e-016
		,2.052035781e-016
		,2.064700382e-016
		,2.137648633e-016
		,2.253762426e-016
		,2.376739511e-016
		,2.460493685e-016
		,2.682311138e-016
		,2.940194419e-016
		,3.083972806e-016
		,3.406055756e-016
		,3.721397335e-016
		,3.919049027e-016
		,4.163155138e-016
		,4.449335135e-016
		,4.680827597e-016
		,4.844167656e-016
		,4.940162710e-016
		,4.976011443e-016
		,4.962647771e-016
		,4.935379864e-016
		,4.959975503e-016
		,4.992134818e-016
		,1.753561207e-016
		,1.743840101e-016
		,1.737648456e-016
		,1.733365736e-016
		,1.730437138e-016
		,1.728688971e-016
		,1.728165913e-016
		,1.729203177e-016
		,1.732809861e-016
		,1.741846414e-016
		,1.762944417e-016
		,1.807706717e-016
		,1.876116830e-016
		,1.944602399e-016
		,1.995595268e-016
		,2.037317269e-016
		,2.058038569e-016
		,2.020398569e-016
		,2.021584657e-016
		,2.055391262e-016
		,2.100531624e-016
		,2.146520695e-016
		,2.278478397e-016
		,2.484060113e-016
		,2.731777697e-016
		,3.011637651e-016
		,3.287483887e-016
		,3.530499609e-016
		,3.724453231e-016
		,3.871437527e-016
		,3.988108544e-016
		,4.081673198e-016
		,4.157259086e-016
		,4.219094709e-016
		,4.270387173e-016
		,4.313522110e-016
		,4.350336159e-016
		,4.382272814e-016
		,4.410439976e-016
		,4.435626563e-016
		,4.458348547e-016
		,1.742608109e-016
		,1.732948844e-016
		,1.726271005e-016
		,1.721126641e-016
		,1.716969620e-016
		,1.713545175e-016
		,1.710710801e-016
		,1.708388770e-016
		,1.706569479e-016
		,1.705365248e-016
		,1.705187140e-016
		,1.707244396e-016
		,1.714663569e-016
		,1.733349180e-016
		,1.768314878e-016
		,1.812251795e-016
		,1.844176261e-016
		,1.863816599e-016
		,1.865284499e-016
		,1.899760086e-016
		,1.926154079e-016
		,1.981103418e-016
		,2.108193236e-016
		,2.344345200e-016
		,2.656906021e-016
		,3.031296256e-016
		,3.384541105e-016
		,3.658489281e-016
		,3.854969836e-016
		,3.995758381e-016
		,4.101540449e-016
		,4.184371879e-016
		,4.250718065e-016
		,4.304755949e-016
		,4.349419940e-016
		,4.386877479e-016
		,4.418755667e-016
		,4.446260791e-016
		,4.470289611e-016
		,4.491521699e-016
		,4.510480011e-016
		,1.737781166e-016
		,1.728802841e-016
		,1.722471698e-016
		,1.717499102e-016
		,1.713385134e-016
		,1.709881403e-016
		,1.706832689e-016
		,1.704129269e-016
		,1.701692223e-016
		,1.699469343e-016
		,1.697437585e-016
		,1.695617302e-016
		,1.694129483e-016
		,1.693365164e-016
		,1.694272424e-016
		,1.698823872e-016
		,1.708417516e-016
		,1.718483633e-016
		,1.726997845e-016
		,1.730226921e-016
		,1.760580940e-016
		,1.799152365e-016
		,1.937313941e-016
		,2.226730621e-016
		,2.650024308e-016
		,3.123983683e-016
		,3.503334817e-016
		,3.768092757e-016
		,3.948612706e-016
		,4.075533897e-016
		,4.169475721e-016
		,4.241859024e-016
		,4.299645342e-016
		,4.347177642e-016
		,4.387092497e-016
		,4.421119605e-016
		,4.450498116e-016
		,4.476147486e-016
		,4.498759857e-016
		,4.518863217e-016
		,4.536866436e-016
		,1.734111858e-016
		,1.725846436e-016
		,1.719958210e-016
		,1.715298267e-016
		,1.711413790e-016
		,1.708074659e-016
		,1.705134904e-016
		,1.702490724e-016
		,1.700066564e-016
		,1.697809101e-016
		,1.695683188e-016
		,1.693668357e-016
		,1.691756573e-016
		,1.689954663e-016
		,1.688298984e-016
		,1.686891530e-016
		,1.685989918e-016
		,1.685717101e-016
		,1.686151181e-016
		,1.689345873e-016
		,1.700780929e-016
		,1.745167806e-016
		,1.886023690e-016
		,2.216215666e-016
		,2.711838439e-016
		,3.193520897e-016
		,3.555744458e-016
		,3.804317988e-016
		,3.975256406e-016
		,4.097179688e-016
		,4.187997932e-016
		,4.258215243e-016
		,4.314255565e-016
		,4.360166278e-016
		,4.398604625e-016
		,4.431361289e-016
		,4.459678751e-016
		,4.484449552e-016
		,4.506334869e-016
		,4.525836459e-016
		,4.543342876e-016
		,1.730898583e-016
		,1.723291886e-016
		,1.717825538e-016
		,1.713471226e-016
		,1.709818144e-016
		,1.706654315e-016
		,1.703844663e-016
		,1.701293870e-016
		,1.698933624e-016
		,1.696716669e-016
		,1.694612443e-016
		,1.692602914e-016
		,1.690678538e-016
		,1.688834868e-016
		,1.687071079e-016
		,1.685393512e-016
		,1.683834621e-016
		,1.682525508e-016
		,1.681968117e-016
		,1.684069191e-016
		,1.696032987e-016
		,1.743628436e-016
		,1.899481610e-016
		,2.258145713e-016
		,2.763548382e-016
		,3.234975717e-016
		,3.585371103e-016
		,3.825834500e-016
		,3.991509562e-016
		,4.109937590e-016
		,4.198253328e-016
		,4.266669831e-016
		,4.321380731e-016
		,4.366278495e-016
		,4.403907014e-016
		,4.435991888e-016
		,4.463743510e-016
		,4.488036209e-016
		,4.509517931e-016
		,4.528679720e-016
		,4.545901131e-016
		,1.727983093e-016
		,1.720972956e-016
		,1.715891852e-016
		,1.711816516e-016
		,1.708373879e-016
		,1.705369349e-016
		,1.702678857e-016
		,1.700215715e-016
		,1.697918885e-016
		,1.695747191e-016
		,1.693674919e-016
		,1.691687622e-016
		,1.689778087e-016
		,1.687942943e-016
		,1.686180810e-016
		,1.684494469e-016
		,1.682906728e-016
		,1.681533664e-016
		,1.680928113e-016
		,1.683305303e-016
		,1.696792240e-016
		,1.751160947e-016
		,1.925108255e-016
		,2.304710891e-016
		,2.812199422e-016
		,3.272858941e-016
		,3.612374708e-016
		,3.845220107e-016
		,4.006039065e-016
		,4.121292684e-016
		,4.207414825e-016
		,4.274243145e-016
		,4.327755452e-016
		,4.371716737e-016
		,4.408594775e-016
		,4.440066227e-016
		,4.467308430e-016
		,4.491173074e-016
		,4.512292458e-016
		,4.531146084e-016
		,4.548104422e-016
		,1.725307812e-016
		,1.718832041e-016
		,1.714095741e-016
		,1.710268006e-016
		,1.707010008e-016
		,1.704143716e-016
		,1.701555808e-016
		,1.699167951e-016
		,1.696925987e-016
		,1.694794347e-016
		,1.692751691e-016
		,1.690786745e-016
		,1.688894372e-016
		,1.687072381e-016
		,1.685319912e-016
		,1.683639362e-016
		,1.682052956e-016
		,1.680675706e-016
		,1.680041666e-016
		,1.682700680e-016
		,1.698095709e-016
		,1.759253369e-016
		,1.952767030e-016
		,2.352946973e-016
		,2.860298166e-016
		,3.308999398e-016
		,3.637537979e-016
		,3.863174392e-016
		,4.019519731e-016
		,4.131909412e-016
		,4.216071806e-016
		,4.281428788e-016
		,4.333801184e-016
		,4.376864709e-016
		,4.413025048e-016
		,4.443916937e-016
		,4.470686233e-016
		,4.494158336e-016
		,4.514946144e-016
		,4.533516804e-016
		,4.550232428e-016
		,1.722865168e-016
		,1.716862521e-016
		,1.712428975e-016
		,1.708815485e-016
		,1.705714481e-016
		,1.702963590e-016
		,1.700459765e-016
		,1.698132559e-016
		,1.695934171e-016
		,1.693834098e-016
		,1.691814845e-016
		,1.689867845e-016
		,1.687989655e-016
		,1.686178969e-016
		,1.684435292e-016
		,1.682760868e-016
		,1.681176407e-016
		,1.679794023e-016
		,1.679117830e-016
		,1.681803528e-016
		,1.699002314e-016
		,1.767499684e-016
		,1.979702098e-016
		,2.400768935e-016
		,2.907645280e-016
		,3.344391873e-016
		,3.662420047e-016
		,3.880869728e-016
		,4.032398883e-016
		,4.141550694e-016
		,4.223506184e-016
		,4.287381482e-016
		,4.338749795e-016
		,4.381098174e-016
		,4.416702894e-016
		,4.447147197e-016
		,4.473563304e-016
		,4.496762223e-016
		,4.517330351e-016
		,4.535708875e-016
		,4.552247514e-016
		,1.720685459e-016
		,1.715098028e-016
		,1.710926079e-016
		,1.707493690e-016
		,1.704521941e-016
		,1.701863166e-016
		,1.699424023e-016
		,1.697141422e-016
		,1.694973387e-016
		,1.692893965e-016
		,1.690889037e-016
		,1.688952332e-016
		,1.687081770e-016
		,1.685276690e-016
		,1.683536805e-016
		,1.681864504e-016
		,1.680278733e-016
		,1.678884150e-016
		,1.678191521e-016
		,1.680515481e-016
		,1.698672913e-016
		,1.774887931e-016
		,2.004187803e-016
		,2.445492247e-016
		,2.953597618e-016
		,3.379151574e-016
		,3.686737363e-016
		,3.898070350e-016
		,4.045157501e-016
		,4.151437991e-016
		,4.231448874e-016
		,4.293905465e-016
		,4.344124279e-016
		,4.385516482e-016
		,4.420349269e-016
		,4.450169251e-016
		,4.476064486e-016
		,4.498822241e-016
		,4.519026600e-016
		,4.537120734e-016
		,4.553447635e-016
		,1.718796233e-016
		,1.713574157e-016
		,1.709628546e-016
		,1.706349179e-016
		,1.703483378e-016
		,1.700897147e-016
		,1.698506209e-016
		,1.696254260e-016
		,1.694104662e-016
		,1.692035548e-016
		,1.690035701e-016
		,1.688100868e-016
		,1.686230057e-016
		,1.684423075e-016
		,1.682679740e-016
		,1.681002605e-016
		,1.679409195e-016
		,1.677995374e-016
		,1.677267656e-016
		,1.679301540e-016
		,1.696766231e-016
		,1.778923012e-016
		,2.029367456e-016
		,2.482802825e-016
		,2.992133978e-016
		,3.412755945e-016
		,3.710219663e-016
		,3.915022095e-016
		,4.057951540e-016
		,4.161275213e-016
		,4.239198045e-016
		,4.300163849e-016
		,4.349312190e-016
		,4.389920739e-016
		,4.424161756e-016
		,4.453523364e-016
		,4.479055710e-016
		,4.501521155e-016
		,4.521486270e-016
		,4.539379510e-016
		,4.555530199e-016
		,1.717195667e-016
		,1.712292236e-016
		,1.708542982e-016
		,1.705393765e-016
		,1.702617165e-016
		,1.700090129e-016
		,1.697736880e-016
		,1.695507062e-016
		,1.693369016e-016
		,1.691304289e-016
		,1.689304616e-016
		,1.687367041e-016
		,1.685491475e-016
		,1.683678222e-016
		,1.681926878e-016
		,1.680239800e-016
		,1.678634861e-016
		,1.677194062e-016
		,1.676402667e-016
		,1.678298075e-016
		,1.693508125e-016
		,1.777181793e-016
		,2.048126008e-016
		,2.526251700e-016
		,3.027417387e-016
		,3.433320113e-016
		,3.728300718e-016
		,3.930734362e-016
		,4.069737272e-016
		,4.170231549e-016
		,4.246408054e-016
		,4.306356932e-016
		,4.354790833e-016
		,4.394756781e-016
		,4.428424735e-016
		,4.457300680e-016
		,4.482429600e-016
		,4.504559325e-016
		,4.524241622e-016
		,4.541894211e-016
		,4.557840508e-016
		,1.716155238e-016
		,1.711407384e-016
		,1.707793234e-016
		,1.704704083e-016
		,1.701994130e-016
		,1.699503200e-016
		,1.697171527e-016
		,1.694949722e-016
		,1.692811697e-016
		,1.690743640e-016
		,1.688733338e-016
		,1.686789982e-016
		,1.684907963e-016
		,1.683082168e-016
		,1.681323931e-016
		,1.679619638e-016
		,1.677997429e-016
		,1.676539543e-016
		,1.675658174e-016
		,1.677325322e-016
		,1.690188032e-016
		,1.767925227e-016
		,2.051341670e-016
		,2.562410566e-016
		,3.072144254e-016
		,3.464327806e-016
		,3.741768475e-016
		,3.934878614e-016
		,4.072973382e-016
		,4.175148671e-016
		,4.252689085e-016
		,4.312429855e-016
		,4.360088296e-016
		,4.399369218e-016
		,4.432528484e-016
		,4.461037696e-016
		,4.485913542e-016
		,4.507883405e-016
		,4.527474007e-016
		,4.545067361e-016
		,4.560952101e-016
		,1.720370446e-016
		,1.713831581e-016
		,1.709791824e-016
		,1.705883934e-016
		,1.703054604e-016
		,1.700397492e-016
		,1.697904932e-016
		,1.695558654e-016
		,1.693290453e-016
		,1.691068839e-016
		,1.688997641e-016
		,1.686867833e-016
		,1.684970227e-016
		,1.683155570e-016
		,1.681250058e-016
		,1.679456625e-016
		,1.677675300e-016
		,1.676278265e-016
		,1.675100671e-016
		,1.676560643e-016
		,1.688437716e-016
		,1.752928924e-016
		,2.031621747e-016
		,2.579154724e-016
		,3.113508962e-016
		,3.501016082e-016
		,3.768474682e-016
		,3.952447734e-016
		,4.082001255e-016
		,4.177226969e-016
		,4.250688976e-016
		,4.309829880e-016
		,4.358648356e-016
		,4.399527651e-016
		,4.434375457e-016
		,4.464281271e-016
		,4.489959810e-016
		,4.512200926e-016
		,4.531741463e-016
		,4.549138563e-016
		,4.564791673e-016
		,1.760403441e-016
		,1.740887870e-016
		,1.730878700e-016
		,1.721500372e-016
		,1.715870933e-016
		,1.711648486e-016
		,1.707630220e-016
		,1.704708431e-016
		,1.701152610e-016
		,1.698239577e-016
		,1.694709784e-016
		,1.692572199e-016
		,1.688905331e-016
		,1.687427286e-016
		,1.685135715e-016
		,1.682408086e-016
		,1.678520329e-016
		,1.676634233e-016
		,1.675468415e-016
		,1.672347075e-016
		,1.686413587e-016
		,1.740923359e-016
		,1.984989267e-016
		,2.558071221e-016
		,3.146023555e-016
		,3.541840808e-016
		,3.801009412e-016
		,3.977206868e-016
		,4.101640201e-016
		,4.193659622e-016
		,4.264501379e-016
		,4.320678607e-016
		,4.366424871e-016
		,4.404552312e-016
		,4.436924450e-016
		,4.464871230e-016
		,4.489381594e-016
		,4.511199472e-016
		,4.530883513e-016
		,4.548804631e-016
		,4.565120106e-016
		,1.860862051e-016
		,1.823649667e-016
		,1.791900883e-016
		,1.776984268e-016
		,1.754096940e-016
		,1.747502424e-016
		,1.740359749e-016
		,1.733258162e-016
		,1.728141392e-016
		,1.721190264e-016
		,1.716264692e-016
		,1.709627379e-016
		,1.708285425e-016
		,1.696272991e-016
		,1.693005961e-016
		,1.695057825e-016
		,1.684230301e-016
		,1.673833821e-016
		,1.678634081e-016
		,1.659217980e-016
		,1.672686624e-016
		,1.732144701e-016
		,1.913936271e-016
		,2.425410197e-016
		,3.118551044e-016
		,3.587537086e-016
		,3.854161589e-016
		,4.021403941e-016
		,4.138681036e-016
		,4.225905081e-016
		,4.292608840e-016
		,4.346267643e-016
		,4.390316708e-016
		,4.427082899e-016
		,4.457917515e-016
		,4.485216578e-016
		,4.508998524e-016
		,4.529769562e-016
		,4.548392198e-016
		,4.565017173e-016
		,4.579972293e-016
		,1.970823145e-016
		,1.940977368e-016
		,1.872783762e-016
		,1.861940702e-016
		,1.830232529e-016
		,1.800601345e-016
		,1.792219200e-016
		,1.781844004e-016
		,1.772855736e-016
		,1.764879894e-016
		,1.756515795e-016
		,1.747260689e-016
		,1.727986733e-016
		,1.725018509e-016
		,1.704619514e-016
		,1.702162803e-016
		,1.697060443e-016
		,1.707110883e-016
		,1.669538411e-016
		,1.672156980e-016
		,1.670207503e-016
		,1.715538936e-016
		,1.871817438e-016
		,2.255990578e-016
		,2.869545216e-016
		,3.479748294e-016
		,3.860957458e-016
		,4.070389169e-016
		,4.196993696e-016
		,4.282296635e-016
		,4.346601784e-016
		,4.396529434e-016
		,4.437323644e-016
		,4.470250278e-016
		,4.498058918e-016
		,4.523326581e-016
		,4.545324358e-016
		,4.563999280e-016
		,4.580011329e-016
		,4.595706581e-016
		,4.609396672e-016
		,2.053477446e-016
		,2.023187119e-016
		,1.987754187e-016
		,1.957221235e-016
		,1.930513161e-016
		,1.887717835e-016
		,1.860619160e-016
		,1.845905703e-016
		,1.837504930e-016
		,1.821970815e-016
		,1.795422665e-016
		,1.785129766e-016
		,1.763000672e-016
		,1.751396011e-016
		,1.752608489e-016
		,1.713894420e-016
		,1.703891250e-016
		,1.720381444e-016
		,1.723755221e-016
		,1.695268851e-016
		,1.690814194e-016
		,1.737692799e-016
		,1.837233481e-016
		,2.114143372e-016
		,2.612865354e-016
		,3.212537036e-016
		,3.714556726e-016
		,4.004336677e-016
		,4.195193571e-016
		,4.321216839e-016
		,4.399129068e-016
		,4.456565869e-016
		,4.499707529e-016
		,4.529324357e-016
		,4.558717272e-016
		,4.582157701e-016
		,4.600207775e-016
		,4.616905691e-016
		,4.631716215e-016
		,4.644744251e-016
		,4.654802689e-016
		,2.223334491e-016
		,2.087097468e-016
		,2.080497491e-016
		,2.021413616e-016
		,2.008861525e-016
		,1.994142410e-016
		,1.948876054e-016
		,1.906332806e-016
		,1.885129359e-016
		,1.882296779e-016
		,1.862242438e-016
		,1.827766605e-016
		,1.819237634e-016
		,1.806138801e-016
		,1.788271030e-016
		,1.771950951e-016
		,1.760555307e-016
		,1.745268305e-016
		,1.751252505e-016
		,1.758744112e-016
		,1.765417730e-016
		,1.768372646e-016
		,1.857565852e-016
		,2.022940494e-016
		,2.335380428e-016
		,2.850815849e-016
		,3.429803185e-016
		,3.923475457e-016
		,4.236164686e-016
		,4.384935535e-016
		,4.438506114e-016
		,4.444765997e-016
		,4.483089642e-016
		,4.576068966e-016
		,4.613951466e-016
		,4.644962513e-016
		,4.664741315e-016
		,4.674767270e-016
		,4.689028014e-016
		,4.701525647e-016
		,4.711667882e-016
		,2.418281003e-016
		,2.175911639e-016
		,2.144903961e-016
		,2.131575222e-016
		,2.083127139e-016
		,2.054351545e-016
		,2.039011846e-016
		,1.990110385e-016
		,1.942499375e-016
		,1.906166180e-016
		,1.873287564e-016
		,1.872180554e-016
		,1.858298790e-016
		,1.842549888e-016
		,1.821884826e-016
		,1.815240705e-016
		,1.815334191e-016
		,1.807363265e-016
		,1.812444568e-016
		,1.805202522e-016
		,1.814434264e-016
		,1.856708979e-016
		,1.908620795e-016
		,2.042409003e-016
		,2.249796107e-016
		,2.538746816e-016
		,3.000584063e-016
		,3.522620507e-016
		,3.985118239e-016
		,4.333420352e-016
		,4.536623084e-016
		,4.629143266e-016
		,4.657413120e-016
		,4.665550247e-016
		,4.657421337e-016
		,4.625410114e-016
		,4.648566452e-016
		,4.735565161e-016
		,4.758153918e-016
		,4.772601018e-016
		,4.774174439e-016
		,2.528846380e-016
		,2.430445660e-016
		,2.189660321e-016
		,2.185337567e-016
		,2.154188263e-016
		,2.123201215e-016
		,2.112460155e-016
		,2.057965570e-016
		,1.967006408e-016
		,1.923369568e-016
		,1.939645175e-016
		,1.928454322e-016
		,1.918990804e-016
		,1.897375459e-016
		,1.892677424e-016
		,1.884168264e-016
		,1.890465453e-016
		,1.876442902e-016
		,1.870796182e-016
		,1.856412096e-016
		,1.860055711e-016
		,1.901986429e-016
		,1.979037755e-016
		,2.100997863e-016
		,2.233578495e-016
		,2.500188781e-016
		,2.734449899e-016
		,3.052708592e-016
		,3.529869546e-016
		,3.966377679e-016
		,4.361619488e-016
		,4.636034691e-016
		,4.791235374e-016
		,4.854785101e-016
		,4.859620911e-016
		,4.849765501e-016
		,4.833895436e-016
		,4.810670260e-016
		,4.764611374e-016
		,4.750996591e-016
		,4.823739448e-016
		,2.626490937e-016
		,2.537217209e-016
		,2.419366388e-016
		,2.239193209e-016
		,2.235199577e-016
		,2.073618152e-016
		,2.028383922e-016
		,2.056719650e-016
		,2.066908645e-016
		,2.057239470e-016
		,2.001347888e-016
		,1.993183874e-016
		,1.978921919e-016
		,1.975204598e-016
		,1.973462169e-016
		,1.973206957e-016
		,1.971293348e-016
		,1.948612178e-016
		,1.950513604e-016
		,1.938117489e-016
		,1.946496414e-016
		,1.970831979e-016
		,2.056286331e-016
		,2.187406279e-016
		,2.334949064e-016
		,2.434402553e-016
		,2.656361147e-016
		,2.930866173e-016
		,3.116709405e-016
		,3.476824582e-016
		,3.936400477e-016
		,4.306874223e-016
		,4.617720663e-016
		,4.847295699e-016
		,4.980424328e-016
		,5.033400856e-016
		,5.020515673e-016
		,4.997136687e-016
		,4.968917464e-016
		,4.936823930e-016
		,4.893935521e-016
		,1.761373430e-016
		,1.753313829e-016
		,1.748447411e-016
		,1.745379889e-016
		,1.743647330e-016
		,1.743133071e-016
		,1.743946161e-016
		,1.746527962e-016
		,1.752092779e-016
		,1.763986986e-016
		,1.790462386e-016
		,1.847699445e-016
		,1.938680048e-016
		,2.031002714e-016
		,2.111031161e-016
		,2.167037469e-016
		,2.178145717e-016
		,2.179987662e-016
		,2.211899069e-016
		,2.222023839e-016
		,2.271494586e-016
		,2.313470927e-016
		,2.416854636e-016
		,2.595633261e-016
		,2.820265267e-016
		,3.053374856e-016
		,3.264967890e-016
		,3.463645055e-016
		,3.658432195e-016
		,3.814925201e-016
		,3.935509656e-016
		,4.032379188e-016
		,4.111450179e-016
		,4.176905726e-016
		,4.231939619e-016
		,4.278883484e-016
		,4.319326835e-016
		,4.354401035e-016
		,4.384998649e-016
		,4.411878412e-016
		,4.435687108e-016
		,1.742745745e-016
		,1.734559975e-016
		,1.729022783e-016
		,1.724928149e-016
		,1.721824661e-016
		,1.719509827e-016
		,1.717886289e-016
		,1.716929973e-016
		,1.716707765e-016
		,1.717457977e-016
		,1.719847997e-016
		,1.725735411e-016
		,1.740055814e-016
		,1.774780230e-016
		,1.844090324e-016
		,1.933782428e-016
		,2.014650893e-016
		,2.058297523e-016
		,2.092447393e-016
		,2.112064942e-016
		,2.087075314e-016
		,2.114120555e-016
		,2.237060573e-016
		,2.444658587e-016
		,2.729084891e-016
		,3.036415384e-016
		,3.341800235e-016
		,3.603028774e-016
		,3.800962825e-016
		,3.949453203e-016
		,4.061171715e-016
		,4.146868849e-016
		,4.214868053e-016
		,4.270467927e-016
		,4.316825263e-016
		,4.356058144e-016
		,4.389728717e-016
		,4.419018052e-016
		,4.444815407e-016
		,4.467780996e-016
		,4.488399778e-016
		,1.734943996e-016
		,1.726943580e-016
		,1.721234204e-016
		,1.716734084e-016
		,1.713016328e-016
		,1.709864946e-016
		,1.707145614e-016
		,1.704767567e-016
		,1.702672837e-016
		,1.700835468e-016
		,1.699269923e-016
		,1.698062950e-016
		,1.697478490e-016
		,1.698308966e-016
		,1.702849202e-016
		,1.717004862e-016
		,1.749506414e-016
		,1.802437858e-016
		,1.852176405e-016
		,1.876664210e-016
		,1.904212602e-016
		,1.939529315e-016
		,2.079840640e-016
		,2.326116344e-016
		,2.705265703e-016
		,3.126683310e-016
		,3.484542650e-016
		,3.747524087e-016
		,3.932979551e-016
		,4.065346245e-016
		,4.162452150e-016
		,4.235920486e-016
		,4.293407659e-016
		,4.340052107e-016
		,4.379131503e-016
		,4.412584752e-016
		,4.441606726e-016
		,4.467048752e-016
		,4.489569925e-016
		,4.509684539e-016
		,4.527793545e-016
		,1.731199022e-016
		,1.723769053e-016
		,1.718388835e-016
		,1.714088692e-016
		,1.710477976e-016
		,1.707352965e-016
		,1.704582887e-016
		,1.702075325e-016
		,1.699764435e-016
		,1.697605539e-016
		,1.695571374e-016
		,1.693649228e-016
		,1.691840630e-016
		,1.690168850e-016
		,1.688716101e-016
		,1.687743057e-016
		,1.688005712e-016
		,1.691349153e-016
		,1.701429940e-016
		,1.718967929e-016
		,1.745130993e-016
		,1.803582694e-016
		,1.949715472e-016
		,2.294715564e-016
		,2.776745553e-016
		,3.235071484e-016
		,3.587326798e-016
		,3.829460635e-016
		,3.995930001e-016
		,4.114609765e-016
		,4.202690348e-016
		,4.270348340e-016
		,4.324032773e-016
		,4.367978147e-016
		,4.404869505e-016
		,4.436437383e-016
		,4.463847832e-016
		,4.487915908e-016
		,4.509242122e-016
		,4.528288450e-016
		,4.545418758e-016
		,1.728219526e-016
		,1.721361444e-016
		,1.716347763e-016
		,1.712308104e-016
		,1.708887327e-016
		,1.705897954e-016
		,1.703219364e-016
		,1.700766892e-016
		,1.698480872e-016
		,1.696321140e-016
		,1.694262778e-016
		,1.692292030e-016
		,1.690402422e-016
		,1.688591766e-016
		,1.686861467e-016
		,1.685222067e-016
		,1.683718296e-016
		,1.682523139e-016
		,1.682290184e-016
		,1.685489015e-016
		,1.701365901e-016
		,1.761941020e-016
		,1.948659950e-016
		,2.339279349e-016
		,2.844588503e-016
		,3.296969194e-016
		,3.629619870e-016
		,3.857970488e-016
		,4.015854005e-016
		,4.129147613e-016
		,4.213900711e-016
		,4.279707126e-016
		,4.332415506e-016
		,4.375723001e-016
		,4.412058480e-016
		,4.443075718e-016
		,4.469936973e-016
		,4.493482004e-016
		,4.514332521e-016
		,4.532958918e-016
		,4.549724154e-016
		,1.725571589e-016
		,1.719237607e-016
		,1.714564379e-016
		,1.710769163e-016
		,1.707529476e-016
		,1.704673820e-016
		,1.702092084e-016
		,1.699707832e-016
		,1.697468176e-016
		,1.695338440e-016
		,1.693297900e-016
		,1.691335685e-016
		,1.689446901e-016
		,1.687629482e-016
		,1.685882711e-016
		,1.684209248e-016
		,1.682627302e-016
		,1.681232519e-016
		,1.680468556e-016
		,1.682422365e-016
		,1.697605517e-016
		,1.764446592e-016
		,1.972136151e-016
		,2.388464433e-016
		,2.896089919e-016
		,3.335940054e-016
		,3.656899263e-016
		,3.877238479e-016
		,4.030098814e-016
		,4.140100276e-016
		,4.222595388e-016
		,4.286838604e-016
		,4.338441757e-016
		,4.380919185e-016
		,4.416585878e-016
		,4.447048241e-016
		,4.473451468e-016
		,4.496619429e-016
		,4.517154768e-016
		,4.535510937e-016
		,4.552040280e-016
		,1.723149326e-016
		,1.717285856e-016
		,1.712917902e-016
		,1.709340547e-016
		,1.706261269e-016
		,1.703523802e-016
		,1.701028184e-016
		,1.698705844e-016
		,1.696510262e-016
		,1.694411835e-016
		,1.692393683e-016
		,1.690447618e-016
		,1.688570388e-016
		,1.686760749e-016
		,1.685018217e-016
		,1.683345213e-016
		,1.681758795e-016
		,1.680342733e-016
		,1.679498031e-016
		,1.681274339e-016
		,1.696012536e-016
		,1.767514607e-016
		,1.998024036e-016
		,2.434164388e-016
		,2.942505419e-016
		,3.372150568e-016
		,3.683046450e-016
		,3.895881261e-016
		,4.043930570e-016
		,4.150997592e-016
		,4.231395691e-016
		,4.293952239e-016
		,4.344196326e-016
		,4.385602861e-016
		,4.420447628e-016
		,4.450280668e-016
		,4.476192792e-016
		,4.498971883e-016
		,4.519199754e-016
		,4.537315709e-016
		,4.553659575e-016
		,1.720918196e-016
		,1.715471016e-016
		,1.711370901e-016
		,1.707982332e-016
		,1.705040218e-016
		,1.702402577e-016
		,1.699978988e-016
		,1.697708178e-016
		,1.695549429e-016
		,1.693477672e-016
		,1.691479384e-016
		,1.689548639e-016
		,1.687683518e-016
		,1.685883393e-016
		,1.684147932e-016
		,1.682479614e-016
		,1.680895545e-016
		,1.679469125e-016
		,1.678564720e-016
		,1.680151947e-016
		,1.693775966e-016
		,1.765639769e-016
		,2.016009359e-016
		,2.482123793e-016
		,2.985749327e-016
		,3.402752676e-016
		,3.705352352e-016
		,3.912393119e-016
		,4.056812042e-016
		,4.161694235e-016
		,4.240201310e-016
		,4.301243618e-016
		,4.350333048e-016
		,4.390861786e-016
		,4.425039909e-016
		,4.454368079e-016
		,4.479892434e-016
		,4.502355082e-016
		,4.522301178e-016
		,4.540153656e-016
		,4.556250137e-016
		,1.718890409e-016
		,1.713806197e-016
		,1.709935885e-016
		,1.706706059e-016
		,1.703876684e-016
		,1.701319027e-016
		,1.698951512e-016
		,1.696719551e-016
		,1.694587655e-016
		,1.692534769e-016
		,1.690550261e-016
		,1.688630085e-016
		,1.686773342e-016
		,1.684979811e-016
		,1.683249204e-016
		,1.681584064e-016
		,1.680001343e-016
		,1.678570985e-016
		,1.677625341e-016
		,1.678937270e-016
		,1.691850446e-016
		,1.758403051e-016
		,2.020475522e-016
		,2.521722194e-016
		,3.034985633e-016
		,3.436646880e-016
		,3.723909713e-016
		,3.923572627e-016
		,4.064984324e-016
		,4.168377495e-016
		,4.245800488e-016
		,4.305910685e-016
		,4.354448649e-016
		,4.394846885e-016
		,4.429139916e-016
		,4.458522634e-016
		,4.483907440e-016
		,4.506107653e-016
		,4.525766996e-016
		,4.543359021e-016
		,4.559233990e-016
		,1.717105136e-016
		,1.712335425e-016
		,1.708659863e-016
		,1.705560800e-016
		,1.702821066e-016
		,1.700324147e-016
		,1.697996613e-016
		,1.695789983e-016
		,1.693673489e-016
		,1.691629637e-016
		,1.689650307e-016
		,1.687733016e-016
		,1.685877656e-016
		,1.684084250e-016
		,1.682352526e-016
		,1.680684902e-016
		,1.679098385e-016
		,1.677664988e-016
		,1.676679636e-016
		,1.677713561e-016
		,1.689478323e-016
		,1.749121994e-016
		,2.002107951e-016
		,2.545051676e-016
		,3.081752559e-016
		,3.476759628e-016
		,3.751745806e-016
		,3.941303167e-016
		,4.074559731e-016
		,4.172158820e-016
		,4.247049766e-016
		,4.306872128e-016
		,4.355955224e-016
		,4.397001078e-016
		,4.431748828e-016
		,4.461259735e-016
		,4.486566935e-016
		,4.508625733e-016
		,4.528145052e-016
		,4.545622977e-016
		,4.561420332e-016
		,1.715577708e-016
		,1.711082908e-016
		,1.707574618e-016
		,1.704584954e-016
		,1.701917807e-016
		,1.699467629e-016
		,1.697168465e-016
		,1.694977365e-016
		,1.692867796e-016
		,1.690825419e-016
		,1.688844277e-016
		,1.686923196e-016
		,1.685062700e-016
		,1.683262835e-016
		,1.681523365e-016
		,1.679846626e-016
		,1.678250299e-016
		,1.676807937e-016
		,1.675797112e-016
		,1.676582693e-016
		,1.687026895e-016
		,1.743214825e-016
		,1.966391644e-016
		,2.534874432e-016
		,3.115611296e-016
		,3.515283977e-016
		,3.781990510e-016
		,3.963491958e-016
		,4.091234534e-016
		,4.184984146e-016
		,4.256717993e-016
		,4.313487939e-016
		,4.359689800e-016
		,4.398219236e-016
		,4.431061395e-016
		,4.459620771e-016
		,4.484889531e-016
		,4.507512458e-016
		,4.527862875e-016
		,4.546214723e-016
		,4.562844576e-016
		,1.714296893e-016
		,1.710036902e-016
		,1.706672578e-016
		,1.703774060e-016
		,1.701168021e-016
		,1.698755880e-016
		,1.696478749e-016
		,1.694298645e-016
		,1.692192520e-016
		,1.690148968e-016
		,1.688163731e-016
		,1.686236833e-016
		,1.684368927e-016
		,1.682560530e-016
		,1.680810924e-016
		,1.679122458e-016
		,1.677513008e-016
		,1.676057050e-016
		,1.675038108e-016
		,1.675611445e-016
		,1.684706032e-016
		,1.736942622e-016
		,1.938616480e-016
		,2.481218843e-016
		,3.131893604e-016
		,3.547435928e-016
		,3.810110924e-016
		,3.987108812e-016
		,4.110202022e-016
		,4.200539428e-016
		,4.269947528e-016
		,4.325043405e-016
		,4.369970550e-016
		,4.407444525e-016
		,4.439296060e-016
		,4.466794299e-016
		,4.490844871e-016
		,4.512112053e-016
		,4.531096005e-016
		,4.548182960e-016
		,4.563678792e-016
		,1.713607184e-016
		,1.709415552e-016
		,1.706111937e-016
		,1.703237724e-016
		,1.700658945e-016
		,1.698261598e-016
		,1.695989722e-016
		,1.693809546e-016
		,1.691696477e-016
		,1.689640869e-016
		,1.687643862e-016
		,1.685702741e-016
		,1.683827044e-016
		,1.682002275e-016
		,1.680242593e-016
		,1.678543120e-016
		,1.676922121e-016
		,1.675451187e-016
		,1.674415128e-016
		,1.674830675e-016
		,1.682517527e-016
		,1.729046431e-016
		,1.918998672e-016
		,2.408675625e-016
		,3.101874071e-016
		,3.573612833e-016
		,3.839070378e-016
		,4.008917189e-016
		,4.128342875e-016
		,4.217513864e-016
		,4.285735982e-016
		,4.339381425e-016
		,4.382966503e-016
		,4.419314796e-016
		,4.450241351e-016
		,4.476974965e-016
		,4.500383065e-016
		,4.521098698e-016
		,4.539596975e-016
		,4.556243269e-016
		,4.571324625e-016
		,1.719081321e-016
		,1.713054388e-016
		,1.708641083e-016
		,1.705141417e-016
		,1.702099714e-016
		,1.699494370e-016
		,1.697035615e-016
		,1.694715037e-016
		,1.692435538e-016
		,1.690237849e-016
		,1.688086224e-016
		,1.686020420e-016
		,1.683995083e-016
		,1.682170162e-016
		,1.680267834e-016
		,1.678517998e-016
		,1.676903110e-016
		,1.675349237e-016
		,1.674220366e-016
		,1.674578208e-016
		,1.680827843e-016
		,1.720767692e-016
		,1.891837140e-016
		,2.344123167e-016
		,3.027533810e-016
		,3.564881653e-016
		,3.862641618e-016
		,4.035519407e-016
		,4.151231131e-016
		,4.236136556e-016
		,4.301480761e-016
		,4.353733817e-016
		,4.396761807e-016
		,4.432761782e-016
		,4.463225789e-016
		,4.489355714e-016
		,4.512113509e-016
		,4.532194740e-016
		,4.550100398e-016
		,4.566202984e-016
		,4.580788992e-016
		,1.764395583e-016
		,1.746128879e-016
		,1.731160057e-016
		,1.724465207e-016
		,1.716041104e-016
		,1.712330966e-016
		,1.708616704e-016
		,1.704899154e-016
		,1.701894802e-016
		,1.698601035e-016
		,1.695281026e-016
		,1.692340624e-016
		,1.689361862e-016
		,1.686420129e-016
		,1.684771378e-016
		,1.682602373e-016
		,1.680284319e-016
		,1.677693750e-016
		,1.675997066e-016
		,1.675213125e-016
		,1.682295528e-016
		,1.711464094e-016
		,1.859695108e-016
		,2.280642300e-016
		,2.917829947e-016
		,3.498047396e-016
		,3.854960509e-016
		,4.049667253e-016
		,4.176377723e-016
		,4.263203036e-016
		,4.326976651e-016
		,4.376698350e-016
		,4.417080468e-016
		,4.450792895e-016
		,4.479537150e-016
		,4.504452554e-016
		,4.526338394e-016
		,4.545775103e-016
		,4.563192016e-016
		,4.578907549e-016
		,4.593159328e-016
		,1.869743819e-016
		,1.836097903e-016
		,1.792804130e-016
		,1.781599533e-016
		,1.760398967e-016
		,1.749222543e-016
		,1.742700079e-016
		,1.736215284e-016
		,1.730990232e-016
		,1.724930519e-016
		,1.719218174e-016
		,1.712541547e-016
		,1.708003150e-016
		,1.702121823e-016
		,1.695341527e-016
		,1.695860863e-016
		,1.691907853e-016
		,1.683843692e-016
		,1.678950553e-016
		,1.673398508e-016
		,1.685670813e-016
		,1.699034410e-016
		,1.809568432e-016
		,2.176655839e-016
		,2.814733519e-016
		,3.405466889e-016
		,3.761910875e-016
		,3.997608376e-016
		,4.177763631e-016
		,4.285635484e-016
		,4.356484457e-016
		,4.409970331e-016
		,4.449541610e-016
		,4.483015547e-016
		,4.511302043e-016
		,4.535243277e-016
		,4.555815915e-016
		,4.573789346e-016
		,4.589695879e-016
		,4.603918809e-016
		,4.616746366e-016
		,1.976804574e-016
		,1.929871755e-016
		,1.885671455e-016
		,1.860461170e-016
		,1.847015356e-016
		,1.798761427e-016
		,1.797601471e-016
		,1.784619763e-016
		,1.775785738e-016
		,1.769152945e-016
		,1.759062711e-016
		,1.750259686e-016
		,1.739596496e-016
		,1.732296431e-016
		,1.724480202e-016
		,1.700305110e-016
		,1.702613281e-016
		,1.708497427e-016
		,1.691108699e-016
		,1.681684702e-016
		,1.676113861e-016
		,1.709326903e-016
		,1.771728925e-016
		,2.028759099e-016
		,2.559367052e-016
		,3.199686519e-016
		,3.745240473e-016
		,4.059027662e-016
		,4.203942007e-016
		,4.275267869e-016
		,4.326563915e-016
		,4.403948881e-016
		,4.476664511e-016
		,4.521270865e-016
		,4.552053912e-016
		,4.575520534e-016
		,4.595862933e-016
		,4.612926233e-016
		,4.627816100e-016
		,4.640926606e-016
		,4.652660814e-016
		,2.083545620e-016
		,2.019183762e-016
		,2.008336782e-016
		,1.938359789e-016
		,1.934327927e-016
		,1.911938265e-016
		,1.855057749e-016
		,1.857385789e-016
		,1.837391543e-016
		,1.829636435e-016
		,1.817154647e-016
		,1.802000159e-016
		,1.782775790e-016
		,1.754185667e-016
		,1.748104535e-016
		,1.740130285e-016
		,1.720175327e-016
		,1.713378373e-016
		,1.703639783e-016
		,1.721360158e-016
		,1.713835050e-016
		,1.698080165e-016
		,1.787052590e-016
		,1.955430765e-016
		,2.263911989e-016
		,2.821879268e-016
		,3.446135829e-016
		,3.965965033e-016
		,4.278177193e-016
		,4.421119262e-016
		,4.480694511e-016
		,4.511491648e-016
		,4.531039041e-016
		,4.541770187e-016
		,4.556140093e-016
		,4.590355646e-016
		,4.626388093e-016
		,4.657270189e-016
		,4.673704763e-016
		,4.685994625e-016
		,4.696771116e-016
		,2.284148403e-016
		,2.062762921e-016
		,2.066095487e-016
		,2.036086710e-016
		,2.002785575e-016
		,1.991081269e-016
		,1.977467434e-016
		,1.902516802e-016
		,1.907347968e-016
		,1.887013433e-016
		,1.853915837e-016
		,1.814127257e-016
		,1.822465167e-016
		,1.811151950e-016
		,1.796977324e-016
		,1.789498063e-016
		,1.778157711e-016
		,1.740236093e-016
		,1.731225056e-016
		,1.743466470e-016
		,1.762921277e-016
		,1.793098037e-016
		,1.808639072e-016
		,1.957723593e-016
		,2.190703816e-016
		,2.490933612e-016
		,2.997133516e-016
		,3.563549205e-016
		,4.055241758e-016
		,4.402244593e-016
		,4.583577029e-016
		,4.657676893e-016
		,4.678701599e-016
		,4.689705217e-016
		,4.696017148e-016
		,4.699275694e-016
		,4.699751193e-016
		,4.699420140e-016
		,4.707737544e-016
		,4.728089538e-016
		,4.737359008e-016
		,2.437964102e-016
		,2.219466935e-016
		,2.127515596e-016
		,2.130687446e-016
		,2.084067643e-016
		,2.068679945e-016
		,2.057307508e-016
		,2.043923000e-016
		,1.933577461e-016
		,1.874094005e-016
		,1.870482334e-016
		,1.867103449e-016
		,1.859202022e-016
		,1.848191526e-016
		,1.834124946e-016
		,1.831177707e-016
		,1.797302285e-016
		,1.788220842e-016
		,1.777996007e-016
		,1.774127657e-016
		,1.789970182e-016
		,1.849355681e-016
		,1.919872810e-016
		,2.010530567e-016
		,2.165682834e-016
		,2.451828965e-016
		,2.713674157e-016
		,3.060413775e-016
		,3.586360512e-016
		,4.051271471e-016
		,4.449462170e-016
		,4.730724635e-016
		,4.851753583e-016
		,4.884479580e-016
		,4.872218662e-016
		,4.860900680e-016
		,4.849501809e-016
		,4.839696300e-016
		,4.830002380e-016
		,4.822090150e-016
		,4.815157920e-016
		,2.449541373e-016
		,2.226169810e-016
		,2.193469108e-016
		,2.192181990e-016
		,2.122269128e-016
		,2.098085613e-016
		,1.964891183e-016
		,1.984413884e-016
		,1.937005918e-016
		,1.926600878e-016
		,1.926267264e-016
		,1.914307391e-016
		,1.907998719e-016
		,1.894820702e-016
		,1.874719341e-016
		,1.855533746e-016
		,1.861215600e-016
		,1.840090778e-016
		,1.850892400e-016
		,1.861200813e-016
		,1.899840214e-016
		,1.976446788e-016
		,2.106002439e-016
		,2.258739436e-016
		,2.370079286e-016
		,2.640084368e-016
		,2.924642710e-016
		,3.138909003e-016
		,3.413810851e-016
		,3.689643620e-016
		,4.050523602e-016
		,4.451452994e-016
		,4.771102804e-016
		,4.974146202e-016
		,5.057128901e-016
		,5.063803421e-016
		,5.025415955e-016
		,4.997003185e-016
		,4.970387067e-016
		,4.948171177e-016
		,4.929504980e-016
		,1.769520622e-016
		,1.762359153e-016
		,1.758162057e-016
		,1.755679594e-016
		,1.754513377e-016
		,1.754592729e-016
		,1.756076285e-016
		,1.759478264e-016
		,1.766148641e-016
		,1.779715017e-016
		,1.809645421e-016
		,1.872984067e-016
		,1.979492355e-016
		,2.091315046e-016
		,2.165346078e-016
		,2.248354651e-016
		,2.288797822e-016
		,2.279735475e-016
		,2.306217785e-016
		,2.363661357e-016
		,2.415020546e-016
		,2.490338111e-016
		,2.588341034e-016
		,2.712133999e-016
		,2.889937163e-016
		,3.082423306e-016
		,3.276685956e-016
		,3.459778045e-016
		,3.636618418e-016
		,3.793476460e-016
		,3.914938832e-016
		,4.011481395e-016
		,4.090527949e-016
		,4.155825587e-016
		,4.210366714e-016
		,4.256747577e-016
		,4.296905608e-016
		,4.332098807e-016
		,4.363131974e-016
		,4.390535828e-016
		,4.414523807e-016
		,1.749148682e-016
		,1.742319859e-016
		,1.737889627e-016
		,1.734812177e-016
		,1.732695322e-016
		,1.731366693e-016
		,1.730753650e-016
		,1.730862087e-016
		,1.731804328e-016
		,1.733898942e-016
		,1.737972674e-016
		,1.746274388e-016
		,1.764799729e-016
		,1.808763117e-016
		,1.896632133e-016
		,2.018184576e-016
		,2.118440551e-016
		,2.197603828e-016
		,2.223829917e-016
		,2.247754100e-016
		,2.255816760e-016
		,2.321605756e-016
		,2.423359372e-016
		,2.605530441e-016
		,2.855291293e-016
		,3.098792459e-016
		,3.354033808e-016
		,3.586313996e-016
		,3.767116512e-016
		,3.907904143e-016
		,4.019367955e-016
		,4.107505169e-016
		,4.176774939e-016
		,4.231784232e-016
		,4.279743254e-016
		,4.320696851e-016
		,4.355698370e-016
		,4.386049011e-016
		,4.412829710e-016
		,4.436842980e-016
		,4.458624000e-016
		,1.734554945e-016
		,1.727636395e-016
		,1.722754473e-016
		,1.718995124e-016
		,1.715996077e-016
		,1.713576111e-016
		,1.711628440e-016
		,1.710090245e-016
		,1.708935686e-016
		,1.708179281e-016
		,1.707892016e-016
		,1.708251598e-016
		,1.709705145e-016
		,1.713471051e-016
		,1.723092492e-016
		,1.748478901e-016
		,1.809490247e-016
		,1.913434746e-016
		,2.023921432e-016
		,2.090208306e-016
		,2.135534849e-016
		,2.201780748e-016
		,2.316926606e-016
		,2.493128303e-016
		,2.756499495e-016
		,3.116033994e-016
		,3.436738189e-016
		,3.682102107e-016
		,3.869330787e-016
		,4.009769206e-016
		,4.115114433e-016
		,4.196239109e-016
		,4.260182501e-016
		,4.311648891e-016
		,4.353883262e-016
		,4.389249981e-016
		,4.419541039e-016
		,4.446025793e-016
		,4.469545146e-016
		,4.490660695e-016
		,4.509760416e-016
		,1.728868302e-016
		,1.722184703e-016
		,1.717283012e-016
		,1.713339032e-016
		,1.710014602e-016
		,1.707130536e-016
		,1.704572026e-016
		,1.702259914e-016
		,1.700140809e-016
		,1.698182565e-016
		,1.696371482e-016
		,1.694711199e-016
		,1.693226204e-016
		,1.691980203e-016
		,1.691140082e-016
		,1.691205905e-016
		,1.693724511e-016
		,1.703376467e-016
		,1.730623662e-016
		,1.788418329e-016
		,1.871409107e-016
		,1.962337501e-016
		,2.101736165e-016
		,2.388488994e-016
		,2.812070614e-016
		,3.247826779e-016
		,3.594321413e-016
		,3.834138159e-016
		,3.998162974e-016
		,4.114721792e-016
		,4.201958488e-016
		,4.269771441e-016
		,4.323849222e-016
		,4.367988844e-016
		,4.404777969e-016
		,4.436015121e-016
		,4.462974200e-016
		,4.486571006e-016
		,4.507471360e-016
		,4.526166268e-016
		,4.543025613e-016
		,1.725908912e-016
		,1.719697581e-016
		,1.715082952e-016
		,1.711323347e-016
		,1.708110306e-016
		,1.705278039e-016
		,1.702719349e-016
		,1.700359673e-016
		,1.698147563e-016
		,1.696049609e-016
		,1.694046343e-016
		,1.692128310e-016
		,1.690292509e-016
		,1.688540010e-016
		,1.686876562e-016
		,1.685321386e-016
		,1.683941980e-016
		,1.682981212e-016
		,1.683328033e-016
		,1.688280244e-016
		,1.709914787e-016
		,1.787871102e-016
		,2.009448408e-016
		,2.425980343e-016
		,2.923390241e-016
		,3.354997334e-016
		,3.670630397e-016
		,3.887764793e-016
		,4.038438528e-016
		,4.146909856e-016
		,4.228261329e-016
		,4.291553388e-016
		,4.342336136e-016
		,4.384130868e-016
		,4.419256017e-016
		,4.449291529e-016
		,4.475347686e-016
		,4.498226235e-016
		,4.518520348e-016
		,4.536678610e-016
		,4.553047099e-016
		,1.723470281e-016
		,1.717715644e-016
		,1.713395970e-016
		,1.709843783e-016
		,1.706779280e-016
		,1.704051315e-016
		,1.701562472e-016
		,1.699245716e-016
		,1.697055576e-016
		,1.694963205e-016
		,1.692952273e-016
		,1.691014978e-016
		,1.689148356e-016
		,1.687351422e-016
		,1.685623979e-016
		,1.683969171e-016
		,1.682404789e-016
		,1.681012173e-016
		,1.680130355e-016
		,1.681470892e-016
		,1.693318539e-016
		,1.752712060e-016
		,1.981146853e-016
		,2.459519257e-016
		,2.984204875e-016
		,3.403383379e-016
		,3.704284370e-016
		,3.912145633e-016
		,4.056839465e-016
		,4.161116446e-016
		,4.239681741e-016
		,4.301003443e-016
		,4.350372029e-016
		,4.391167882e-016
		,4.425543845e-016
		,4.454978832e-016
		,4.480546601e-016
		,4.503023747e-016
		,4.522975513e-016
		,4.540827773e-016
		,4.556914593e-016
		,1.721271611e-016
		,1.715929443e-016
		,1.711877146e-016
		,1.708513667e-016
		,1.705585689e-016
		,1.702956047e-016
		,1.700536776e-016
		,1.698268113e-016
		,1.696110373e-016
		,1.694039212e-016
		,1.692041592e-016
		,1.690111878e-016
		,1.688248290e-016
		,1.686450253e-016
		,1.684717457e-016
		,1.683052324e-016
		,1.681471565e-016
		,1.680048836e-016
		,1.679081082e-016
		,1.680018071e-016
		,1.690007117e-016
		,1.743166855e-016
		,1.963447342e-016
		,2.473645489e-016
		,3.027940553e-016
		,3.444267113e-016
		,3.734264403e-016
		,3.931257075e-016
		,4.069321498e-016
		,4.170209938e-016
		,4.246740773e-016
		,4.307090647e-016
		,4.356060050e-016
		,4.396518065e-016
		,4.430538984e-016
		,4.459671253e-016
		,4.484996448e-016
		,4.507256653e-016
		,4.526979824e-016
		,4.544587033e-016
		,4.560431461e-016
		,1.719240708e-016
		,1.714263606e-016
		,1.710446361e-016
		,1.707247387e-016
		,1.704437594e-016
		,1.701892809e-016
		,1.699533845e-016
		,1.697307621e-016
		,1.695179695e-016
		,1.693129745e-016
		,1.691147621e-016
		,1.689229547e-016
		,1.687374734e-016
		,1.685582974e-016
		,1.683854010e-016
		,1.682190152e-016
		,1.680608729e-016
		,1.679180976e-016
		,1.678193672e-016
		,1.678871417e-016
		,1.687422583e-016
		,1.735512164e-016
		,1.942260159e-016
		,2.467071350e-016
		,3.054927968e-016
		,3.477939129e-016
		,3.759716841e-016
		,3.952841061e-016
		,4.087313850e-016
		,4.183226042e-016
		,4.255816429e-016
		,4.313210553e-016
		,4.360079296e-016
		,4.399375248e-016
		,4.432927848e-016
		,4.461906444e-016
		,4.487193712e-016
		,4.509482285e-016
		,4.529316076e-016
		,4.547100928e-016
		,4.563127364e-016
		,1.717363819e-016
		,1.712704331e-016
		,1.709088724e-016
		,1.706028615e-016
		,1.703316920e-016
		,1.700841365e-016
		,1.698530775e-016
		,1.696338108e-016
		,1.694233601e-016
		,1.692200450e-016
		,1.690230968e-016
		,1.688322889e-016
		,1.686476157e-016
		,1.684690762e-016
		,1.682966414e-016
		,1.681305531e-016
		,1.679725297e-016
		,1.678297235e-016
		,1.677306175e-016
		,1.677791397e-016
		,1.685215274e-016
		,1.726956862e-016
		,1.921322720e-016
		,2.429095615e-016
		,3.067950917e-016
		,3.501143232e-016
		,3.785312292e-016
		,3.971311672e-016
		,4.099434338e-016
		,4.194737158e-016
		,4.269213753e-016
		,4.327030287e-016
		,4.372713311e-016
		,4.410198048e-016
		,4.441836767e-016
		,4.469072823e-016
		,4.492871454e-016
		,4.513918513e-016
		,4.532722417e-016
		,4.549673027e-016
		,4.565078162e-016
		,1.715671280e-016
		,1.711283922e-016
		,1.707837072e-016
		,1.704889986e-016
		,1.702255496e-016
		,1.699832163e-016
		,1.697556092e-016
		,1.695385685e-016
		,1.693295347e-016
		,1.691271357e-016
		,1.689308120e-016
		,1.687404583e-016
		,1.685561202e-016
		,1.683778028e-016
		,1.682054667e-016
		,1.680393651e-016
		,1.678812068e-016
		,1.677384562e-016
		,1.676385609e-016
		,1.676796290e-016
		,1.683187494e-016
		,1.719900501e-016
		,1.895670872e-016
		,2.388589295e-016
		,3.040839748e-016
		,3.519158012e-016
		,3.800642777e-016
		,3.986933784e-016
		,4.117830255e-016
		,4.209797174e-016
		,4.278941446e-016
		,4.333592734e-016
		,4.378634544e-016
		,4.417030750e-016
		,4.450138991e-016
		,4.478439325e-016
		,4.502621210e-016
		,4.523585761e-016
		,4.542069489e-016
		,4.558585919e-016
		,4.573494078e-016
		,1.714202952e-016
		,1.710049001e-016
		,1.706743018e-016
		,1.703886968e-016
		,1.701311690e-016
		,1.698925568e-016
		,1.696671320e-016
		,1.694512255e-016
		,1.692426514e-016
		,1.690403097e-016
		,1.688438205e-016
		,1.686531769e-016
		,1.684684604e-016
		,1.682896738e-016
		,1.681167650e-016
		,1.679500012e-016
		,1.677911638e-016
		,1.676477827e-016
		,1.675466777e-016
		,1.675881084e-016
		,1.681378568e-016
		,1.713204269e-016
		,1.866018080e-016
		,2.347715380e-016
		,3.010129243e-016
		,3.504743354e-016
		,3.814064181e-016
		,4.001493552e-016
		,4.125180328e-016
		,4.220062536e-016
		,4.294333696e-016
		,4.350140921e-016
		,4.393733667e-016
		,4.429508986e-016
		,4.459745976e-016
		,4.485827389e-016
		,4.508714243e-016
		,4.529103108e-016
		,4.547501857e-016
		,4.564261631e-016
		,4.579588682e-016
		,1.712957630e-016
		,1.709007232e-016
		,1.705822061e-016
		,1.703042225e-016
		,1.700514806e-016
		,1.698156982e-016
		,1.695917398e-016
		,1.693763769e-016
		,1.691677533e-016
		,1.689650057e-016
		,1.687679051e-016
		,1.685765220e-016
		,1.683909588e-016
		,1.682112073e-016
		,1.680372022e-016
		,1.678692294e-016
		,1.677091832e-016
		,1.675645455e-016
		,1.674626418e-016
		,1.675036752e-016
		,1.680140067e-016
		,1.708140346e-016
		,1.837462911e-016
		,2.285575187e-016
		,2.977271174e-016
		,3.493235233e-016
		,3.799456476e-016
		,3.998829919e-016
		,4.138982333e-016
		,4.231759091e-016
		,4.300240466e-016
		,4.356342810e-016
		,4.404277042e-016
		,4.443693406e-016
		,4.475248058e-016
		,4.501224093e-016
		,4.523389386e-016
		,4.542775009e-016
		,4.559998260e-016
		,4.575463724e-016
		,4.589461987e-016
		,1.711920316e-016
		,1.708140689e-016
		,1.705055821e-016
		,1.702339356e-016
		,1.699850957e-016
		,1.697516354e-016
		,1.695288159e-016
		,1.693138110e-016
		,1.691050450e-016
		,1.689018478e-016
		,1.687041175e-016
		,1.685119915e-016
		,1.683255558e-016
		,1.681448298e-016
		,1.679696874e-016
		,1.678004046e-016
		,1.676390474e-016
		,1.674931747e-016
		,1.673910845e-016
		,1.674299461e-016
		,1.679434935e-016
		,1.704345852e-016
		,1.814752089e-016
		,2.219735227e-016
		,2.925135027e-016
		,3.495974803e-016
		,3.805166341e-016
		,3.988506937e-016
		,4.125910793e-016
		,4.233851882e-016
		,4.312825373e-016
		,4.367695780e-016
		,4.410159001e-016
		,4.445801949e-016
		,4.477349861e-016
		,4.505956577e-016
		,4.531344896e-016
		,4.553032879e-016
		,4.571393701e-016
		,4.587209640e-016
		,4.601136471e-016
		,1.711538582e-016
		,1.707752914e-016
		,1.704638955e-016
		,1.701934858e-016
		,1.699428672e-016
		,1.697100185e-016
		,1.694865117e-016
		,1.692704484e-016
		,1.690605220e-016
		,1.688557944e-016
		,1.686566015e-016
		,1.684626529e-016
		,1.682749653e-016
		,1.680923926e-016
		,1.679158822e-016
		,1.677454120e-016
		,1.675828651e-016
		,1.674360289e-016
		,1.673329213e-016
		,1.673693903e-016
		,1.678908935e-016
		,1.701601132e-016
		,1.794804481e-016
		,2.154735867e-016
		,2.852715432e-016
		,3.480157005e-016
		,3.828340187e-016
		,4.012468627e-016
		,4.130445076e-016
		,4.227238717e-016
		,4.305708666e-016
		,4.371265022e-016
		,4.422299625e-016
		,4.459804552e-016
		,4.489191402e-016
		,4.513802056e-016
		,4.535259345e-016
		,4.554506182e-016
		,4.572188204e-016
		,4.588710551e-016
		,4.604161937e-016
		,1.718539710e-016
		,1.712682377e-016
		,1.707691125e-016
		,1.704556391e-016
		,1.701212171e-016
		,1.698726964e-016
		,1.696247083e-016
		,1.693875881e-016
		,1.691650224e-016
		,1.689444036e-016
		,1.687260651e-016
		,1.685191745e-016
		,1.683113889e-016
		,1.681211028e-016
		,1.679317152e-016
		,1.677509215e-016
		,1.675860960e-016
		,1.674384769e-016
		,1.673358540e-016
		,1.673731346e-016
		,1.678822779e-016
		,1.700790065e-016
		,1.777413419e-016
		,2.086800595e-016
		,2.757226029e-016
		,3.427664654e-016
		,3.836202075e-016
		,4.049134962e-016
		,4.167054934e-016
		,4.244359014e-016
		,4.309843459e-016
		,4.371444838e-016
		,4.422067076e-016
		,4.464499587e-016
		,4.500237412e-016
		,4.528740659e-016
		,4.551272318e-016
		,4.569901854e-016
		,4.585957762e-016
		,4.600162853e-016
		,4.612948664e-016
		,1.768842422e-016
		,1.749800991e-016
		,1.733257685e-016
		,1.725675709e-016
		,1.717587399e-016
		,1.712833916e-016
		,1.709138543e-016
		,1.705646324e-016
		,1.702482016e-016
		,1.699210354e-016
		,1.695949236e-016
		,1.692675392e-016
		,1.689966432e-016
		,1.686250346e-016
		,1.683986097e-016
		,1.682156876e-016
		,1.679107785e-016
		,1.677734505e-016
		,1.676957963e-016
		,1.677137594e-016
		,1.681623937e-016
		,1.702079537e-016
		,1.767280088e-016
		,2.011900402e-016
		,2.622170419e-016
		,3.311917373e-016
		,3.810391164e-016
		,4.079434725e-016
		,4.212053071e-016
		,4.289306272e-016
		,4.342431534e-016
		,4.384687004e-016
		,4.427616790e-016
		,4.470842433e-016
		,4.506445678e-016
		,4.535134912e-016
		,4.559864710e-016
		,4.582048459e-016
		,4.600783727e-016
		,4.616608243e-016
		,4.629949107e-016
		,1.876537925e-016
		,1.836087842e-016
		,1.801523051e-016
		,1.781722513e-016
		,1.770686617e-016
		,1.748338162e-016
		,1.746007322e-016
		,1.739481401e-016
		,1.732292832e-016
		,1.728530240e-016
		,1.722506933e-016
		,1.716637475e-016
		,1.710547885e-016
		,1.705084929e-016
		,1.696527764e-016
		,1.693628419e-016
		,1.693647700e-016
		,1.687871079e-016
		,1.685473645e-016
		,1.682324301e-016
		,1.688504342e-016
		,1.701549715e-016
		,1.772246733e-016
		,1.935753077e-016
		,2.414970602e-016
		,3.076998573e-016
		,3.690963501e-016
		,4.075488719e-016
		,4.264889493e-016
		,4.354032730e-016
		,4.407803289e-016
		,4.445647595e-016
		,4.474837835e-016
		,4.498971544e-016
		,4.522395030e-016
		,4.550691383e-016
		,4.577620612e-016
		,4.599394564e-016
		,4.617444124e-016
		,4.632290122e-016
		,4.645497221e-016
		,1.963840527e-016
		,1.920666262e-016
		,1.906612465e-016
		,1.855105977e-016
		,1.844246624e-016
		,1.815304269e-016
		,1.794007293e-016
		,1.792022532e-016
		,1.782433720e-016
		,1.770600181e-016
		,1.764432781e-016
		,1.757400824e-016
		,1.742710898e-016
		,1.732839326e-016
		,1.727327270e-016
		,1.713344512e-016
		,1.708860202e-016
		,1.707278508e-016
		,1.703759589e-016
		,1.688374272e-016
		,1.694745298e-016
		,1.707019552e-016
		,1.769684961e-016
		,1.933110976e-016
		,2.166372029e-016
		,2.740406156e-016
		,3.393998798e-016
		,3.940191329e-016
		,4.273140850e-016
		,4.430723583e-016
		,4.501459717e-016
		,4.540947335e-016
		,4.563411125e-016
		,4.581725575e-016
		,4.597719545e-016
		,4.610933409e-016
		,4.622250105e-016
		,4.633599744e-016
		,4.649343404e-016
		,4.667248578e-016
		,4.676767676e-016
		,2.144772664e-016
		,2.013639882e-016
		,1.994692437e-016
		,1.955328162e-016
		,1.930769413e-016
		,1.919081402e-016
		,1.876487990e-016
		,1.853335569e-016
		,1.848305097e-016
		,1.834768140e-016
		,1.822330781e-016
		,1.800790981e-016
		,1.788701863e-016
		,1.777897617e-016
		,1.766408493e-016
		,1.755849588e-016
		,1.728063441e-016
		,1.714675038e-016
		,1.714384177e-016
		,1.724657878e-016
		,1.714922512e-016
		,1.717464959e-016
		,1.794415602e-016
		,1.906047508e-016
		,2.143051475e-016
		,2.414640120e-016
		,2.956036324e-016
		,3.573139545e-016
		,4.088012210e-016
		,4.430531391e-016
		,4.598801268e-016
		,4.661116266e-016
		,4.685487711e-016
		,4.696422924e-016
		,4.703398017e-016
		,4.702365209e-016
		,4.707605369e-016
		,4.712875837e-016
		,4.717320005e-016
		,4.721036598e-016
		,4.725405438e-016
		,2.335369959e-016
		,2.064876839e-016
		,2.053059759e-016
		,2.051412467e-016
		,1.994030317e-016
		,1.989909292e-016
		,1.975160344e-016
		,1.928565669e-016
		,1.901622088e-016
		,1.891720702e-016
		,1.841483258e-016
		,1.842569892e-016
		,1.831649687e-016
		,1.804764321e-016
		,1.790088859e-016
		,1.789765121e-016
		,1.780994411e-016
		,1.764873087e-016
		,1.753498851e-016
		,1.741761197e-016
		,1.738683337e-016
		,1.786417746e-016
		,1.853766207e-016
		,1.942064677e-016
		,2.099459456e-016
		,2.404256990e-016
		,2.678103132e-016
		,3.037519323e-016
		,3.634397800e-016
		,4.129941111e-016
		,4.504640526e-016
		,4.727790967e-016
		,4.858377548e-016
		,4.873788495e-016
		,4.860876018e-016
		,4.851136352e-016
		,4.838379698e-016
		,4.830660414e-016
		,4.815403738e-016
		,4.812798640e-016
		,4.809605607e-016
		,2.289377288e-016
		,2.113349921e-016
		,2.116942237e-016
		,2.099939299e-016
		,2.062061699e-016
		,2.055203962e-016
		,2.045146963e-016
		,1.925711364e-016
		,1.891828881e-016
		,1.901385505e-016
		,1.864110582e-016
		,1.861401681e-016
		,1.845769056e-016
		,1.837882506e-016
		,1.822298617e-016
		,1.819750888e-016
		,1.803869380e-016
		,1.795596711e-016
		,1.753588583e-016
		,1.776435471e-016
		,1.823154535e-016
		,1.904903655e-016
		,2.042073886e-016
		,2.197696083e-016
		,2.286601740e-016
		,2.623471321e-016
		,2.926148317e-016
		,3.128302693e-016
		,3.470866341e-016
		,3.773041280e-016
		,4.162998859e-016
		,4.580766912e-016
		,4.875911056e-016
		,5.021123518e-016
		,5.053015081e-016
		,5.031712189e-016
		,4.993751161e-016
		,4.967784860e-016
		,4.943914235e-016
		,4.925220110e-016
		,4.904303567e-016
		,1.775981394e-016
		,1.769338958e-016
		,1.765541537e-016
		,1.763436969e-016
		,1.762667448e-016
		,1.763184995e-016
		,1.765170590e-016
		,1.769178096e-016
		,1.776648520e-016
		,1.791421070e-016
		,1.823830818e-016
		,1.891627100e-016
		,2.010625148e-016
		,2.132794992e-016
		,2.217731764e-016
		,2.297317626e-016
		,2.365780389e-016
		,2.392613382e-016
		,2.388754388e-016
		,2.437101420e-016
		,2.504232140e-016
		,2.591162515e-016
		,2.710199951e-016
		,2.850123098e-016
		,2.974527317e-016
		,3.141029793e-016
		,3.326265671e-016
		,3.507021200e-016
		,3.662382073e-016
		,3.791384738e-016
		,3.907435755e-016
		,4.000008006e-016
		,4.076376293e-016
		,4.139952948e-016
		,4.191984250e-016
		,4.236615553e-016
		,4.277296153e-016
		,4.313497771e-016
		,4.345275580e-016
		,4.373194277e-016
		,4.397875356e-016
		,1.756796069e-016
		,1.750767250e-016
		,1.746948505e-016
		,1.744393300e-016
		,1.742749369e-016
		,1.741869789e-016
		,1.741707111e-016
		,1.742297634e-016
		,1.743794054e-016
		,1.746576432e-016
		,1.751581709e-016
		,1.761291957e-016
		,1.782563177e-016
		,1.831553877e-016
		,1.932629301e-016
		,2.072074426e-016
		,2.186041467e-016
		,2.266696379e-016
		,2.327851021e-016
		,2.353798924e-016
		,2.378534698e-016
		,2.433889709e-016
		,2.578735297e-016
		,2.755774694e-016
		,2.965416560e-016
		,3.199613082e-016
		,3.426714367e-016
		,3.615279893e-016
		,3.762446710e-016
		,3.886778215e-016
		,3.991628821e-016
		,4.076187081e-016
		,4.144275078e-016
		,4.200307636e-016
		,4.249533661e-016
		,4.293105254e-016
		,4.331073444e-016
		,4.364073677e-016
		,4.392925369e-016
		,4.418430481e-016
		,4.441226945e-016
		,1.739736694e-016
		,1.733930728e-016
		,1.729969794e-016
		,1.727058316e-016
		,1.724878719e-016
		,1.723272519e-016
		,1.722149208e-016
		,1.721460929e-016
		,1.721198243e-016
		,1.721396861e-016
		,1.722160223e-016
		,1.723724516e-016
		,1.726655231e-016
		,1.732470220e-016
		,1.745423438e-016
		,1.777615154e-016
		,1.853166917e-016
		,1.987077250e-016
		,2.122858167e-016
		,2.223647816e-016
		,2.286108073e-016
		,2.348316061e-016
		,2.471597240e-016
		,2.650917975e-016
		,2.894462942e-016
		,3.184425679e-016
		,3.464663084e-016
		,3.680063016e-016
		,3.851823542e-016
		,3.987784367e-016
		,4.091981339e-016
		,4.171604824e-016
		,4.234831609e-016
		,4.286801290e-016
		,4.330499886e-016
		,4.367871716e-016
		,4.400103079e-016
		,4.428142129e-016
		,4.452800038e-016
		,4.474723473e-016
		,4.494406548e-016
		,1.728238028e-016
		,1.722362650e-016
		,1.718068138e-016
		,1.714651400e-016
		,1.711822005e-016
		,1.709426954e-016
		,1.707371426e-016
		,1.705594829e-016
		,1.704062698e-016
		,1.702763346e-016
		,1.701706571e-016
		,1.700925259e-016
		,1.700484413e-016
		,1.700512228e-016
		,1.701301374e-016
		,1.703632423e-016
		,1.709862589e-016
		,1.727188939e-016
		,1.774347976e-016
		,1.878412551e-016
		,2.028934636e-016
		,2.175535495e-016
		,2.323052991e-016
		,2.564974052e-016
		,2.916080058e-016
		,3.289381894e-016
		,3.595509450e-016
		,3.821929132e-016
		,3.980297772e-016
		,4.095013213e-016
		,4.181312822e-016
		,4.249387496e-016
		,4.304624749e-016
		,4.350220939e-016
		,4.388409169e-016
		,4.420913418e-016
		,4.448996843e-016
		,4.473565710e-016
		,4.495279239e-016
		,4.514628644e-016
		,4.531984665e-016
		,1.724020253e-016
		,1.718383591e-016
		,1.714136407e-016
		,1.710643682e-016
		,1.707637200e-016
		,1.704971135e-016
		,1.702551465e-016
		,1.700314033e-016
		,1.698216310e-016
		,1.696232793e-016
		,1.694351240e-016
		,1.692569178e-016
		,1.690891088e-016
		,1.689327355e-016
		,1.687897551e-016
		,1.686645396e-016
		,1.685690463e-016
		,1.685407736e-016
		,1.687073015e-016
		,1.695210019e-016
		,1.725643721e-016
		,1.826041051e-016
		,2.082658803e-016
		,2.514171647e-016
		,2.996359981e-016
		,3.406801403e-016
		,3.706744276e-016
		,3.913774598e-016
		,4.057957196e-016
		,4.162077158e-016
		,4.240369374e-016
		,4.301422931e-016
		,4.350516199e-016
		,4.391004937e-016
		,4.425101138e-016
		,4.454313123e-016
		,4.479701223e-016
		,4.502031375e-016
		,4.521870530e-016
		,4.539647734e-016
		,4.555694293e-016
		,1.721648844e-016
		,1.716393667e-016
		,1.712382143e-016
		,1.709042515e-016
		,1.706131444e-016
		,1.703515844e-016
		,1.701109851e-016
		,1.698855049e-016
		,1.696712748e-016
		,1.694659409e-016
		,1.692682683e-016
		,1.690777566e-016
		,1.688942932e-016
		,1.687179008e-016
		,1.685486676e-016
		,1.683870312e-016
		,1.682350409e-016
		,1.681007721e-016
		,1.680149985e-016
		,1.681061095e-016
		,1.689630542e-016
		,1.736077884e-016
		,1.935463316e-016
		,2.429716261e-016
		,3.018734223e-016
		,3.463405847e-016
		,3.752271228e-016
		,3.946312636e-016
		,4.083253050e-016
		,4.183189407e-016
		,4.258894603e-016
		,4.317968067e-016
		,4.365407940e-016
		,4.404739461e-016
		,4.438054054e-016
		,4.466643275e-016
		,4.491360339e-016
		,4.513037456e-016
		,4.532326639e-016
		,4.549652878e-016
		,4.565307177e-016
		,1.719631897e-016
		,1.714734619e-016
		,1.710952911e-016
		,1.707772194e-016
		,1.704972601e-016
		,1.702433747e-016
		,1.700078395e-016
		,1.697854682e-016
		,1.695729011e-016
		,1.693681658e-016
		,1.691702879e-016
		,1.689789149e-016
		,1.687939817e-016
		,1.686154762e-016
		,1.684433837e-016
		,1.682779663e-016
		,1.681208525e-016
		,1.679792884e-016
		,1.678791675e-016
		,1.679304419e-016
		,1.685889057e-016
		,1.722811773e-016
		,1.887764401e-016
		,2.359169936e-016
		,2.982346070e-016
		,3.464554681e-016
		,3.768249065e-016
		,3.961106549e-016
		,4.092017453e-016
		,4.188322185e-016
		,4.264295648e-016
		,4.325956446e-016
		,4.375133362e-016
		,4.415228857e-016
		,4.448441212e-016
		,4.476498930e-016
		,4.500803105e-016
		,4.522196606e-016
		,4.541224951e-016
		,4.558267489e-016
		,4.573603783e-016
		,1.717782465e-016
		,1.713203286e-016
		,1.709625584e-016
		,1.706586071e-016
		,1.703886308e-016
		,1.701417654e-016
		,1.699110861e-016
		,1.696920117e-016
		,1.694816516e-016
		,1.692783848e-016
		,1.690814805e-016
		,1.688907322e-016
		,1.687061413e-016
		,1.685277066e-016
		,1.683553996e-016
		,1.681894799e-016
		,1.680316237e-016
		,1.678889959e-016
		,1.677877590e-016
		,1.678308421e-016
		,1.684264236e-016
		,1.715291256e-016
		,1.855976633e-016
		,2.296511057e-016
		,2.945193735e-016
		,3.449439620e-016
		,3.770269901e-016
		,3.966535059e-016
		,4.100141686e-016
		,4.195697604e-016
		,4.268538573e-016
		,4.328645051e-016
		,4.378741013e-016
		,4.420159427e-016
		,4.454669044e-016
		,4.483547332e-016
		,4.508058160e-016
		,4.529292776e-016
		,4.547992818e-016
		,4.564661386e-016
		,4.579674492e-016
		,1.716054705e-016
		,1.711752584e-016
		,1.708350710e-016
		,1.705431627e-016
		,1.702816237e-016
		,1.700406550e-016
		,1.698140543e-016
		,1.695977837e-016
		,1.693893688e-016
		,1.691874961e-016
		,1.689916419e-016
		,1.688017179e-016
		,1.686177733e-016
		,1.684398098e-016
		,1.682677857e-016
		,1.681019700e-016
		,1.679441412e-016
		,1.678013917e-016
		,1.677009398e-016
		,1.677392358e-016
		,1.683021601e-016
		,1.709407263e-016
		,1.832094463e-016
		,2.223137615e-016
		,2.904863987e-016
		,3.447709436e-016
		,3.767833655e-016
		,3.977126569e-016
		,4.111228691e-016
		,4.209457156e-016
		,4.288469452e-016
		,4.346875533e-016
		,4.391512164e-016
		,4.428879629e-016
		,4.461699682e-016
		,4.490399172e-016
		,4.515103458e-016
		,4.536655558e-016
		,4.555830540e-016
		,4.572976377e-016
		,4.588263250e-016
		,1.714456363e-016
		,1.710390765e-016
		,1.707135935e-016
		,1.704315282e-016
		,1.701767067e-016
		,1.699402880e-016
		,1.697167184e-016
		,1.695024444e-016
		,1.692953588e-016
		,1.690944139e-016
		,1.688992582e-016
		,1.687098948e-016
		,1.685264013e-016
		,1.683487705e-016
		,1.681769433e-016
		,1.680111987e-016
		,1.678534203e-016
		,1.677108723e-016
		,1.676110380e-016
		,1.676470400e-016
		,1.681955697e-016
		,1.705491056e-016
		,1.809000349e-016
		,2.142578233e-016
		,2.826578331e-016
		,3.429374710e-016
		,3.770330798e-016
		,3.979375123e-016
		,4.128662853e-016
		,4.231868835e-016
		,4.302246611e-016
		,4.355901742e-016
		,4.401296434e-016
		,4.439335235e-016
		,4.470802817e-016
		,4.498104734e-016
		,4.522683396e-016
		,4.544685373e-016
		,4.563893593e-016
		,4.580578270e-016
		,4.595305079e-016
		,1.713031923e-016
		,1.709165650e-016
		,1.706030801e-016
		,1.703287258e-016
		,1.700788845e-016
		,1.698455776e-016
		,1.696238349e-016
		,1.694105378e-016
		,1.692039053e-016
		,1.690031213e-016
		,1.688079790e-016
		,1.686185514e-016
		,1.684349307e-016
		,1.682570937e-016
		,1.680849620e-016
		,1.679188273e-016
		,1.677606826e-016
		,1.676182147e-016
		,1.675183831e-016
		,1.675577672e-016
		,1.680865084e-016
		,1.702933628e-016
		,1.788660070e-016
		,2.074139948e-016
		,2.720982904e-016
		,3.386573566e-016
		,3.785544142e-016
		,4.004413529e-016
		,4.148083008e-016
		,4.243255068e-016
		,4.316022274e-016
		,4.372704596e-016
		,4.415559589e-016
		,4.450617852e-016
		,4.481688860e-016
		,4.509717187e-016
		,4.534001365e-016
		,4.554884009e-016
		,4.573385535e-016
		,4.590117596e-016
		,4.605224845e-016
		,1.711813145e-016
		,1.708117083e-016
		,1.705081630e-016
		,1.702399262e-016
		,1.699937736e-016
		,1.697625013e-016
		,1.695416641e-016
		,1.693285333e-016
		,1.691216190e-016
		,1.689203070e-016
		,1.687245120e-016
		,1.685343600e-016
		,1.683499486e-016
		,1.681712351e-016
		,1.679981240e-016
		,1.678309251e-016
		,1.676717470e-016
		,1.675287030e-016
		,1.674286254e-016
		,1.674711305e-016
		,1.679809815e-016
		,1.701548129e-016
		,1.774015101e-016
		,2.023202147e-016
		,2.623243105e-016
		,3.337801150e-016
		,3.779917813e-016
		,4.016850557e-016
		,4.159028889e-016
		,4.259126936e-016
		,4.326797435e-016
		,4.379306571e-016
		,4.426528217e-016
		,4.464464743e-016
		,4.493898938e-016
		,4.518502476e-016
		,4.540441498e-016
		,4.560869522e-016
		,4.579916176e-016
		,4.596989280e-016
		,4.611968653e-016
		,1.710782264e-016
		,1.707234876e-016
		,1.704285008e-016
		,1.701654472e-016
		,1.699223105e-016
		,1.696926008e-016
		,1.694723240e-016
		,1.692591005e-016
		,1.690516975e-016
		,1.688496697e-016
		,1.686530293e-016
		,1.684619386e-016
		,1.682764877e-016
		,1.680966097e-016
		,1.679221904e-016
		,1.677535607e-016
		,1.675929477e-016
		,1.674488898e-016
		,1.673496245e-016
		,1.673922143e-016
		,1.678974256e-016
		,1.700290627e-016
		,1.765455597e-016
		,1.978890950e-016
		,2.524554078e-016
		,3.240139541e-016
		,3.753438682e-016
		,4.037978525e-016
		,4.184748199e-016
		,4.280817033e-016
		,4.352361810e-016
		,4.402360156e-016
		,4.440458384e-016
		,4.475710867e-016
		,4.509061223e-016
		,4.535663580e-016
		,4.556644371e-016
		,4.574355902e-016
		,4.590024118e-016
		,4.604358320e-016
		,4.617851242e-016
		,1.709927614e-016
		,1.706501274e-016
		,1.703617728e-016
		,1.701030333e-016
		,1.698621486e-016
		,1.696337476e-016
		,1.694138606e-016
		,1.692005296e-016
		,1.689927030e-016
		,1.687900599e-016
		,1.685926826e-016
		,1.684007756e-016
		,1.682143912e-016
		,1.680334709e-016
		,1.678578368e-016
		,1.676878665e-016
		,1.675259002e-016
		,1.673808947e-016
		,1.672826317e-016
		,1.673258128e-016
		,1.678463853e-016
		,1.699078071e-016
		,1.762194053e-016
		,1.945548816e-016
		,2.437190248e-016
		,3.105840524e-016
		,3.699940875e-016
		,4.038962870e-016
		,4.206301480e-016
		,4.300063965e-016
		,4.370736152e-016
		,4.426094080e-016
		,4.466007426e-016
		,4.496330000e-016
		,4.522794109e-016
		,4.549505809e-016
		,4.574068970e-016
		,4.593308821e-016
		,4.608715288e-016
		,4.621851932e-016
		,4.633492102e-016
		,1.709813878e-016
		,1.706303410e-016
		,1.703336268e-016
		,1.700727289e-016
		,1.698280875e-016
		,1.695983436e-016
		,1.693770671e-016
		,1.691621350e-016
		,1.689526741e-016
		,1.687483348e-016
		,1.685490623e-016
		,1.683552666e-016
		,1.681671106e-016
		,1.679840704e-016
		,1.678067287e-016
		,1.676354018e-016
		,1.674719728e-016
		,1.673256494e-016
		,1.672284791e-016
		,1.672772451e-016
		,1.678064510e-016
		,1.698051129e-016
		,1.761074809e-016
		,1.928158778e-016
		,2.357884444e-016
		,2.972351141e-016
		,3.633230552e-016
		,4.031921580e-016
		,4.224776573e-016
		,4.319793503e-016
		,4.380358819e-016
		,4.432440780e-016
		,4.477287401e-016
		,4.511556877e-016
		,4.537993854e-016
		,4.560258776e-016
		,4.581752832e-016
		,4.603991690e-016
		,4.623458534e-016
		,4.638511683e-016
		,4.650597808e-016
		,1.718393599e-016
		,1.712103286e-016
		,1.707352117e-016
		,1.703784000e-016
		,1.700692545e-016
		,1.697923029e-016
		,1.695529073e-016
		,1.693169628e-016
		,1.690867132e-016
		,1.688665989e-016
		,1.686499199e-016
		,1.684377110e-016
		,1.682301033e-016
		,1.680303737e-016
		,1.678395221e-016
		,1.676527560e-016
		,1.674855123e-016
		,1.673370708e-016
		,1.672396584e-016
		,1.672913060e-016
		,1.678188444e-016
		,1.698089837e-016
		,1.759900902e-016
		,1.919816693e-016
		,2.273449002e-016
		,2.853249914e-016
		,3.540927294e-016
		,4.022349621e-016
		,4.252958653e-016
		,4.357467368e-016
		,4.411814868e-016
		,4.449446377e-016
		,4.483477991e-016
		,4.516673301e-016
		,4.545359574e-016
		,4.568234307e-016
		,4.587052660e-016
		,4.604136486e-016
		,4.622008637e-016
		,4.640888918e-016
		,4.657448617e-016
		,1.772968174e-016
		,1.751777494e-016
		,1.736383795e-016
		,1.726185262e-016
		,1.720456625e-016
		,1.712478227e-016
		,1.710023281e-016
		,1.706293867e-016
		,1.702665758e-016
		,1.699942116e-016
		,1.696774254e-016
		,1.693374486e-016
		,1.690438524e-016
		,1.686767758e-016
		,1.683750230e-016
		,1.681878661e-016
		,1.678554697e-016
		,1.676913510e-016
		,1.675976694e-016
		,1.676751973e-016
		,1.682435467e-016
		,1.702651514e-016
		,1.760497162e-016
		,1.911634370e-016
		,2.195907435e-016
		,2.706382075e-016
		,3.380205475e-016
		,3.966916586e-016
		,4.271286760e-016
		,4.402268275e-016
		,4.462306341e-016
		,4.495957616e-016
		,4.520691980e-016
		,4.542837163e-016
		,4.564751896e-016
		,4.586049923e-016
		,4.604297347e-016
		,4.619804819e-016
		,4.632874813e-016
		,4.644975883e-016
		,4.657914604e-016
		,1.873952514e-016
		,1.832953533e-016
		,1.815781383e-016
		,1.783248254e-016
		,1.772781986e-016
		,1.752344564e-016
		,1.746709192e-016
		,1.742327513e-016
		,1.736919495e-016
		,1.730033911e-016
		,1.725531597e-016
		,1.720796570e-016
		,1.713330512e-016
		,1.707254604e-016
		,1.700890531e-016
		,1.694494300e-016
		,1.692454637e-016
		,1.688664073e-016
		,1.683546409e-016
		,1.685192005e-016
		,1.692782864e-016
		,1.713006667e-016
		,1.767493060e-016
		,1.905467205e-016
		,2.158208723e-016
		,2.479123015e-016
		,3.106284935e-016
		,3.780484678e-016
		,4.226906207e-016
		,4.443975138e-016
		,4.530110945e-016
		,4.567003501e-016
		,4.587276234e-016
		,4.602189554e-016
		,4.615717481e-016
		,4.629023277e-016
		,4.642356140e-016
		,4.655245421e-016
		,4.665626636e-016
		,4.675331621e-016
		,4.684277246e-016
		,1.995193271e-016
		,1.934769580e-016
		,1.904226057e-016
		,1.862885461e-016
		,1.842159749e-016
		,1.834002368e-016
		,1.792920093e-016
		,1.794618679e-016
		,1.784220500e-016
		,1.779139880e-016
		,1.767698474e-016
		,1.760124868e-016
		,1.747777954e-016
		,1.738094046e-016
		,1.731591845e-016
		,1.720536102e-016
		,1.709909079e-016
		,1.705637750e-016
		,1.706837532e-016
		,1.699334552e-016
		,1.698445550e-016
		,1.722127984e-016
		,1.786443483e-016
		,1.892904468e-016
		,2.118464942e-016
		,2.430901736e-016
		,2.703216217e-016
		,3.406854521e-016
		,4.005347956e-016
		,4.402015886e-016
		,4.586221968e-016
		,4.665461587e-016
		,4.691729478e-016
		,4.699242161e-016
		,4.703643761e-016
		,4.707596997e-016
		,4.712203071e-016
		,4.717395653e-016
		,4.722902650e-016
		,4.728421232e-016
		,4.733239741e-016
		,2.016060268e-016
		,1.988218163e-016
		,1.975766699e-016
		,1.924108035e-016
		,1.921535891e-016
		,1.901234140e-016
		,1.849542319e-016
		,1.855916258e-016
		,1.837860724e-016
		,1.829401549e-016
		,1.795011055e-016
		,1.794349800e-016
		,1.785307929e-016
		,1.773757888e-016
		,1.762864402e-016
		,1.751453720e-016
		,1.738757269e-016
		,1.720859045e-016
		,1.715239462e-016
		,1.726923133e-016
		,1.744683249e-016
		,1.811124731e-016
		,1.903253939e-016
		,2.071600941e-016
		,2.374510961e-016
		,2.694540620e-016
		,2.870519299e-016
		,3.424607355e-016
		,3.738805805e-016
		,4.116309818e-016
		,4.502243154e-016
		,4.712183337e-016
		,4.808327979e-016
		,4.825389980e-016
		,4.824243639e-016
		,4.816571686e-016
		,4.806430124e-016
		,4.803231444e-016
		,4.801324805e-016
		,4.800158215e-016
		,4.800767248e-016
		,2.128038396e-016
		,2.041161475e-016
		,2.040854455e-016
		,2.010234029e-016
		,1.985031793e-016
		,1.976523878e-016
		,1.958438883e-016
		,1.896086874e-016
		,1.861884293e-016
		,1.844903106e-016
		,1.843787364e-016
		,1.833395547e-016
		,1.826176892e-016
		,1.812032578e-016
		,1.807684982e-016
		,1.770170300e-016
		,1.758623086e-016
		,1.753980075e-016
		,1.751042349e-016
		,1.759447127e-016
		,1.802205809e-016
		,1.857162269e-016
		,1.965620353e-016
		,2.130857635e-016
		,2.278062402e-016
		,2.588155311e-016
		,2.927227332e-016
		,3.056055062e-016
		,3.363637841e-016
		,3.771892247e-016
		,4.193416610e-016
		,4.602065982e-016
		,4.870372301e-016
		,4.985411877e-016
		,5.005618872e-016
		,4.973535745e-016
		,4.954604506e-016
		,4.934359358e-016
		,4.916243828e-016
		,4.901456170e-016
		,4.889839858e-016
		,1.780983315e-016
		,1.774790758e-016
		,1.771372300e-016
		,1.769633972e-016
		,1.769234985e-016
		,1.770134251e-016
		,1.772525378e-016
		,1.776995570e-016
		,1.785064737e-016
		,1.800746442e-016
		,1.834809523e-016
		,1.906542005e-016
		,2.033473120e-016
		,2.167118006e-016
		,2.267643913e-016
		,2.337536471e-016
		,2.416191160e-016
		,2.466338474e-016
		,2.493351335e-016
		,2.503825335e-016
		,2.566759908e-016
		,2.648528646e-016
		,2.772252699e-016
		,2.918341600e-016
		,3.079528087e-016
		,3.228117359e-016
		,3.364409341e-016
		,3.515131615e-016
		,3.663313175e-016
		,3.794520443e-016
		,3.911564720e-016
		,4.004419769e-016
		,4.079894360e-016
		,4.143735834e-016
		,4.197735737e-016
		,4.242011146e-016
		,4.277064984e-016
		,4.310231712e-016
		,4.341199825e-016
		,4.368778506e-016
		,4.393165731e-016
		,1.763296811e-016
		,1.757677823e-016
		,1.754146682e-016
		,1.751834605e-016
		,1.750426878e-016
		,1.749801368e-016
		,1.749930206e-016
		,1.750866784e-016
		,1.752782331e-016
		,1.756087566e-016
		,1.761786345e-016
		,1.772525483e-016
		,1.795761382e-016
		,1.848376296e-016
		,1.958604022e-016
		,2.108694853e-016
		,2.242343738e-016
		,2.317232156e-016
		,2.389954288e-016
		,2.448010799e-016
		,2.487697420e-016
		,2.536540678e-016
		,2.653319269e-016
		,2.840528009e-016
		,3.045298523e-016
		,3.261386188e-016
		,3.466101210e-016
		,3.642355370e-016
		,3.794446517e-016
		,3.913713147e-016
		,4.004480652e-016
		,4.077531513e-016
		,4.140692740e-016
		,4.196434684e-016
		,4.244997133e-016
		,4.286298363e-016
		,4.321440601e-016
		,4.354004444e-016
		,4.383334413e-016
		,4.409233400e-016
		,4.432126778e-016
		,1.746804587e-016
		,1.741713538e-016
		,1.738321429e-016
		,1.735905831e-016
		,1.734175429e-016
		,1.732984839e-016
		,1.732254232e-016
		,1.731948235e-016
		,1.732074057e-016
		,1.732690302e-016
		,1.733932890e-016
		,1.736088152e-016
		,1.739810331e-016
		,1.746803480e-016
		,1.761885595e-016
		,1.798088837e-016
		,1.883585201e-016
		,2.032419973e-016
		,2.193985042e-016
		,2.299658943e-016
		,2.384082687e-016
		,2.460499735e-016
		,2.575358704e-016
		,2.765569071e-016
		,2.989191425e-016
		,3.253529543e-016
		,3.509561855e-016
		,3.714106943e-016
		,3.867685280e-016
		,3.986639223e-016
		,4.082983702e-016
		,4.161145536e-016
		,4.225220169e-016
		,4.278359035e-016
		,4.322534163e-016
		,4.359058964e-016
		,4.390135782e-016
		,4.417997568e-016
		,4.442809603e-016
		,4.464831181e-016
		,4.484439290e-016
		,1.732394829e-016
		,1.727424827e-016
		,1.723885188e-016
		,1.721163423e-016
		,1.719005043e-016
		,1.717276345e-016
		,1.715896194e-016
		,1.714815394e-016
		,1.714009785e-016
		,1.713477696e-016
		,1.713239859e-016
		,1.713343323e-016
		,1.713875315e-016
		,1.715005036e-016
		,1.717110808e-016
		,1.721188278e-016
		,1.730104286e-016
		,1.752603301e-016
		,1.811108000e-016
		,1.938850993e-016
		,2.120321482e-016
		,2.292093223e-016
		,2.462693058e-016
		,2.684381331e-016
		,2.996444907e-016
		,3.333816968e-016
		,3.611552891e-016
		,3.824301849e-016
		,3.979734530e-016
		,4.093673364e-016
		,4.178811903e-016
		,4.244851701e-016
		,4.298335267e-016
		,4.342392662e-016
		,4.379241468e-016
		,4.410638898e-016
		,4.438152630e-016
		,4.462683138e-016
		,4.484605908e-016
		,4.504283271e-016
		,4.522050538e-016
		,1.723319360e-016
		,1.718288109e-016
		,1.714485558e-016
		,1.711367152e-016
		,1.708701503e-016
		,1.706363379e-016
		,1.704274052e-016
		,1.702382749e-016
		,1.700659596e-016
		,1.699091614e-016
		,1.697679495e-016
		,1.696434865e-016
		,1.695378678e-016
		,1.694542292e-016
		,1.693974780e-016
		,1.693766795e-016
		,1.694125067e-016
		,1.695617329e-016
		,1.700016671e-016
		,1.713236539e-016
		,1.754671849e-016
		,1.876859411e-016
		,2.156899573e-016
		,2.588183308e-016
		,3.051949793e-016
		,3.444588492e-016
		,3.732457506e-016
		,3.931952029e-016
		,4.071371605e-016
		,4.172344687e-016
		,4.248459114e-016
		,4.307944985e-016
		,4.355873328e-016
		,4.395473947e-016
		,4.428878620e-016
		,4.457542496e-016
		,4.482489469e-016
		,4.504459825e-016
		,4.524002041e-016
		,4.541531607e-016
		,4.557369703e-016
		,1.720135173e-016
		,1.715319450e-016
		,1.711585800e-016
		,1.708442863e-016
		,1.705678915e-016
		,1.703177198e-016
		,1.700862680e-016
		,1.698685244e-016
		,1.696612933e-016
		,1.694627725e-016
		,1.692721761e-016
		,1.690893737e-016
		,1.689145777e-016
		,1.687481429e-016
		,1.685905721e-016
		,1.684429249e-016
		,1.683082338e-016
		,1.681960628e-016
		,1.681399069e-016
		,1.682538699e-016
		,1.690180132e-016
		,1.724324944e-016
		,1.870879826e-016
		,2.327790716e-016
		,3.001287882e-016
		,3.509633582e-016
		,3.802488252e-016
		,3.990406023e-016
		,4.117377020e-016
		,4.209418238e-016
		,4.280589809e-016
		,4.337679912e-016
		,4.383618618e-016
		,4.421558785e-016
		,4.453993252e-016
		,4.481951898e-016
		,4.505870150e-016
		,4.526572830e-016
		,4.544888179e-016
		,4.561322227e-016
		,4.576211810e-016
		,1.718202146e-016
		,1.713685868e-016
		,1.710137059e-016
		,1.707113679e-016
		,1.704424541e-016
		,1.701964012e-016
		,1.699664437e-016
		,1.697481042e-016
		,1.695385674e-016
		,1.693362700e-016
		,1.691405248e-016
		,1.689511593e-016
		,1.687682036e-016
		,1.685916873e-016
		,1.684216237e-016
		,1.682583447e-016
		,1.681036955e-016
		,1.679646888e-016
		,1.678679803e-016
		,1.679070441e-016
		,1.684473454e-016
		,1.710183491e-016
		,1.817079386e-016
		,2.192444369e-016
		,2.879536710e-016
		,3.467374041e-016
		,3.809888552e-016
		,3.995946521e-016
		,4.121939947e-016
		,4.217644401e-016
		,4.288459238e-016
		,4.343703652e-016
		,4.389026174e-016
		,4.427818191e-016
		,4.461785926e-016
		,4.491443509e-016
		,4.517232675e-016
		,4.539128121e-016
		,4.557751051e-016
		,4.573967387e-016
		,4.588415512e-016
		,1.716504542e-016
		,1.712262529e-016
		,1.708887731e-016
		,1.705982492e-016
		,1.703374526e-016
		,1.700968718e-016
		,1.698704589e-016
		,1.696542758e-016
		,1.694459181e-016
		,1.692441205e-016
		,1.690483898e-016
		,1.688586535e-016
		,1.686749666e-016
		,1.684973322e-016
		,1.683257122e-016
		,1.681603930e-016
		,1.680032222e-016
		,1.678613827e-016
		,1.677602769e-016
		,1.677940969e-016
		,1.682857921e-016
		,1.706063751e-016
		,1.795746019e-016
		,2.104372161e-016
		,2.759192018e-016
		,3.395061197e-016
		,3.785591070e-016
		,4.001738832e-016
		,4.127565541e-016
		,4.216430079e-016
		,4.287867199e-016
		,4.347692267e-016
		,4.394142787e-016
		,4.431643502e-016
		,4.463652599e-016
		,4.492401960e-016
		,4.519027121e-016
		,4.542545270e-016
		,4.563283798e-016
		,4.581768338e-016
		,4.597917156e-016
		,1.714917447e-016
		,1.710915573e-016
		,1.707692522e-016
		,1.704890221e-016
		,1.702353374e-016
		,1.699996354e-016
		,1.697765165e-016
		,1.695625288e-016
		,1.693556364e-016
		,1.691548396e-016
		,1.689598156e-016
		,1.687705797e-016
		,1.685872112e-016
		,1.684096996e-016
		,1.682379842e-016
		,1.680723551e-016
		,1.679147518e-016
		,1.677727283e-016
		,1.676716269e-016
		,1.677068371e-016
		,1.681935006e-016
		,1.703765666e-016
		,1.784086801e-016
		,2.041928396e-016
		,2.657702326e-016
		,3.334294351e-016
		,3.761755715e-016
		,4.006768053e-016
		,4.152478303e-016
		,4.240859306e-016
		,4.304659986e-016
		,4.355785224e-016
		,4.401450918e-016
		,4.442238415e-016
		,4.475333329e-016
		,4.503140977e-016
		,4.528328276e-016
		,4.550768119e-016
		,4.569492562e-016
		,4.585828878e-016
		,4.600992274e-016
		,1.713419190e-016
		,1.709622913e-016
		,1.706527819e-016
		,1.703810998e-016
		,1.701332284e-016
		,1.699014520e-016
		,1.696809484e-016
		,1.694686970e-016
		,1.692629856e-016
		,1.690630423e-016
		,1.688686845e-016
		,1.686799927e-016
		,1.684970560e-016
		,1.683198436e-016
		,1.681482731e-016
		,1.679826458e-016
		,1.678250101e-016
		,1.676833334e-016
		,1.675843849e-016
		,1.676205871e-016
		,1.681181634e-016
		,1.701845783e-016
		,1.776172022e-016
		,1.996827525e-016
		,2.551038946e-016
		,3.258960533e-016
		,3.737611411e-016
		,4.005505848e-016
		,4.171902502e-016
		,4.270123905e-016
		,4.332393135e-016
		,4.379357277e-016
		,4.417775190e-016
		,4.451692944e-016
		,4.484225102e-016
		,4.514394131e-016
		,4.540420311e-016
		,4.563273968e-016
		,4.582369362e-016
		,4.597962040e-016
		,4.611428386e-016
		,1.712038837e-016
		,1.708414481e-016
		,1.705423131e-016
		,1.702773083e-016
		,1.700337634e-016
		,1.698047177e-016
		,1.695858644e-016
		,1.693745662e-016
		,1.691693952e-016
		,1.689697748e-016
		,1.687756360e-016
		,1.685871045e-016
		,1.684042663e-016
		,1.682270643e-016
		,1.680553933e-016
		,1.678895697e-016
		,1.677317584e-016
		,1.675903528e-016
		,1.674936168e-016
		,1.675318634e-016
		,1.680415504e-016
		,1.700215317e-016
		,1.770877444e-016
		,1.966129028e-016
		,2.435782435e-016
		,3.154111683e-016
		,3.698490278e-016
		,4.013068111e-016
		,4.181272219e-016
		,4.295069445e-016
		,4.362970244e-016
		,4.408196694e-016
		,4.443667289e-016
		,4.473403649e-016
		,4.499644415e-016
		,4.524655375e-016
		,4.550006975e-016
		,4.574603020e-016
		,4.595656454e-016
		,4.612040913e-016
		,4.625271279e-016
		,1.710827421e-016
		,1.707346076e-016
		,1.704437363e-016
		,1.701837338e-016
		,1.699431295e-016
		,1.697156391e-016
		,1.694974190e-016
		,1.692861765e-016
		,1.690807363e-016
		,1.688806910e-016
		,1.686860655e-016
		,1.684970169e-016
		,1.683136203e-016
		,1.681357907e-016
		,1.679634033e-016
		,1.677967946e-016
		,1.676382541e-016
		,1.674966131e-016
		,1.674016502e-016
		,1.674477851e-016
		,1.679602138e-016
		,1.699554119e-016
		,1.765589374e-016
		,1.943999685e-016
		,2.334800347e-016
		,3.022436719e-016
		,3.635269065e-016
		,4.014045870e-016
		,4.197649342e-016
		,4.306028993e-016
		,4.387848778e-016
		,4.436958747e-016
		,4.470971892e-016
		,4.498424014e-016
		,4.521962958e-016
		,4.543017890e-016
		,4.563125220e-016
		,4.584092625e-016
		,4.605438219e-016
		,4.623972294e-016
		,4.638595327e-016
		,1.709801399e-016
		,1.706442551e-016
		,1.703602499e-016
		,1.701042053e-016
		,1.698657165e-016
		,1.696391051e-016
		,1.694209415e-016
		,1.692092407e-016
		,1.690030500e-016
		,1.688021071e-016
		,1.686065114e-016
		,1.684164383e-016
		,1.682319463e-016
		,1.680529218e-016
		,1.678792237e-016
		,1.677112155e-016
		,1.675513185e-016
		,1.674088097e-016
		,1.673149689e-016
		,1.673695053e-016
		,1.678835890e-016
		,1.699105609e-016
		,1.760597815e-016
		,1.930626697e-016
		,2.261576255e-016
		,2.857771897e-016
		,3.538806207e-016
		,3.998931923e-016
		,4.222523394e-016
		,4.327441787e-016
		,4.403697252e-016
		,4.463777765e-016
		,4.499519627e-016
		,4.525174802e-016
		,4.546477319e-016
		,4.565252036e-016
		,4.582589641e-016
		,4.599689555e-016
		,4.617398425e-016
		,4.634481870e-016
		,4.649184211e-016
		,1.708929804e-016
		,1.705678364e-016
		,1.702898020e-016
		,1.700371763e-016
		,1.698004763e-016
		,1.695745710e-016
		,1.693563943e-016
		,1.691442305e-016
		,1.689373194e-016
		,1.687355179e-016
		,1.685389788e-016
		,1.683478809e-016
		,1.681622569e-016
		,1.679819609e-016
		,1.678068361e-016
		,1.676372730e-016
		,1.674758274e-016
		,1.673322230e-016
		,1.672392368e-016
		,1.673017759e-016
		,1.678322275e-016
		,1.698685151e-016
		,1.757311314e-016
		,1.919377443e-016
		,2.212015599e-016
		,2.706052762e-016
		,3.418455651e-016
		,3.947203098e-016
		,4.227493710e-016
		,4.347010652e-016
		,4.414200777e-016
		,4.477483570e-016
		,4.525873866e-016
		,4.553870291e-016
		,4.574016120e-016
		,4.591023110e-016
		,4.606554293e-016
		,4.621665304e-016
		,4.636805223e-016
		,4.651009961e-016
		,4.663480573e-016
		,1.708210613e-016
		,1.705039796e-016
		,1.702303097e-016
		,1.699802313e-016
		,1.697448138e-016
		,1.695193505e-016
		,1.693011729e-016
		,1.690885996e-016
		,1.688810635e-016
		,1.686785776e-016
		,1.684812735e-016
		,1.682893203e-016
		,1.681027339e-016
		,1.679213439e-016
		,1.677449691e-016
		,1.675740527e-016
		,1.674112584e-016
		,1.672667584e-016
		,1.671748281e-016
		,1.672455051e-016
		,1.678084563e-016
		,1.698256729e-016
		,1.757052928e-016
		,1.906035252e-016
		,2.182329098e-016
		,2.580539803e-016
		,3.257304868e-016
		,3.869782465e-016
		,4.231891603e-016
		,4.383492544e-016
		,4.444683169e-016
		,4.488802568e-016
		,4.537832360e-016
		,4.572393698e-016
		,4.593275924e-016
		,4.609605823e-016
		,4.624662073e-016
		,4.639605959e-016
		,4.654506320e-016
		,4.668114276e-016
		,4.679418106e-016
		,1.708334263e-016
		,1.705001814e-016
		,1.702149751e-016
		,1.699582802e-016
		,1.697194519e-016
		,1.694887127e-016
		,1.692696885e-016
		,1.690546981e-016
		,1.688449704e-016
		,1.686407750e-016
		,1.684415271e-016
		,1.682473367e-016
		,1.680586555e-016
		,1.678747230e-016
		,1.676962653e-016
		,1.675236857e-016
		,1.673589238e-016
		,1.672133863e-016
		,1.671225622e-016
		,1.672016160e-016
		,1.677978623e-016
		,1.698105557e-016
		,1.757442742e-016
		,1.894263502e-016
		,2.160729357e-016
		,2.488901684e-016
		,3.085063352e-016
		,3.740174456e-016
		,4.183400575e-016
		,4.403611163e-016
		,4.485679265e-016
		,4.523869533e-016
		,4.562522524e-016
		,4.602541034e-016
		,4.626423937e-016
		,4.641644948e-016
		,4.654419318e-016
		,4.666466321e-016
		,4.677687245e-016
		,4.687465777e-016
		,4.695673542e-016
		,1.718090517e-016
		,1.711736470e-016
		,1.707157577e-016
		,1.703186341e-016
		,1.700311543e-016
		,1.697088999e-016
		,1.694838631e-016
		,1.692449976e-016
		,1.690150218e-016
		,1.687921838e-016
		,1.685746402e-016
		,1.683606538e-016
		,1.681520419e-016
		,1.679436174e-016
		,1.677501097e-016
		,1.675577365e-016
		,1.673862782e-016
		,1.672367836e-016
		,1.671403722e-016
		,1.672198149e-016
		,1.678482496e-016
		,1.699474468e-016
		,1.757629753e-016
		,1.886897194e-016
		,2.138040380e-016
		,2.439855133e-016
		,2.943871744e-016
		,3.583707623e-016
		,4.103977119e-016
		,4.380143454e-016
		,4.488385063e-016
		,4.535767782e-016
		,4.579912531e-016
		,4.629330727e-016
		,4.662124859e-016
		,4.678969333e-016
		,4.690232821e-016
		,4.699428606e-016
		,4.707283745e-016
		,4.713994224e-016
		,4.719739815e-016
		,1.773063597e-016
		,1.751714713e-016
		,1.741178373e-016
		,1.727894743e-016
		,1.721300563e-016
		,1.713122692e-016
		,1.710272782e-016
		,1.707124628e-016
		,1.703826866e-016
		,1.700144216e-016
		,1.697339823e-016
		,1.694387234e-016
		,1.690803749e-016
		,1.687470788e-016
		,1.684126649e-016
		,1.681636438e-016
		,1.678494394e-016
		,1.676375904e-016
		,1.675392888e-016
		,1.676353918e-016
		,1.683025810e-016
		,1.704733306e-016
		,1.760880801e-016
		,1.889708145e-016
		,2.102303933e-016
		,2.409045436e-016
		,2.832619887e-016
		,3.419428604e-016
		,3.983944875e-016
		,4.325371296e-016
		,4.503435552e-016
		,4.554930805e-016
		,4.578285526e-016
		,4.615794038e-016
		,4.664426983e-016
		,4.699333837e-016
		,4.719114069e-016
		,4.730524458e-016
		,4.737859444e-016
		,4.743093287e-016
		,4.747236895e-016
		,1.868322087e-016
		,1.839537189e-016
		,1.815874570e-016
		,1.784858906e-016
		,1.771713228e-016
		,1.761872274e-016
		,1.747037740e-016
		,1.745451099e-016
		,1.738282388e-016
		,1.733739584e-016
		,1.728243152e-016
		,1.723575487e-016
		,1.716006102e-016
		,1.709724110e-016
		,1.704942231e-016
		,1.697923152e-016
		,1.693078861e-016
		,1.689868817e-016
		,1.683809513e-016
		,1.684592726e-016
		,1.692576000e-016
		,1.717511207e-016
		,1.779105276e-016
		,1.895980619e-016
		,2.066907479e-016
		,2.375014775e-016
		,2.741036324e-016
		,3.228489442e-016
		,3.810864815e-016
		,4.248672291e-016
		,4.464796016e-016
		,4.564744091e-016
		,4.622638266e-016
		,4.662448996e-016
		,4.682762645e-016
		,4.704777400e-016
		,4.722556678e-016
		,4.737483884e-016
		,4.750957436e-016
		,4.762302833e-016
		,4.772144478e-016
		,1.935684085e-016
		,1.897738959e-016
		,1.880225445e-016
		,1.839859087e-016
		,1.836076792e-016
		,1.806386264e-016
		,1.792374942e-016
		,1.792982486e-016
		,1.779210831e-016
		,1.775238484e-016
		,1.759482425e-016
		,1.750440455e-016
		,1.744678304e-016
		,1.735779037e-016
		,1.728530157e-016
		,1.715670730e-016
		,1.708586329e-016
		,1.705340101e-016
		,1.701128062e-016
		,1.702710027e-016
		,1.732089586e-016
		,1.804870228e-016
		,1.911546970e-016
		,2.070185037e-016
		,2.300958402e-016
		,2.648325734e-016
		,3.063078328e-016
		,3.442946169e-016
		,3.907427139e-016
		,4.194379849e-016
		,4.459083594e-016
		,4.646096230e-016
		,4.707296328e-016
		,4.720047924e-016
		,4.724959706e-016
		,4.736672578e-016
		,4.759299313e-016
		,4.779286326e-016
		,4.787677840e-016
		,4.799621679e-016
		,4.805100081e-016
		,2.004607097e-016
		,1.971193603e-016
		,1.970026337e-016
		,1.938859730e-016
		,1.918813681e-016
		,1.910813508e-016
		,1.867910781e-016
		,1.849794072e-016
		,1.854349545e-016
		,1.806488041e-016
		,1.809697608e-016
		,1.795253490e-016
		,1.790196662e-016
		,1.781927477e-016
		,1.770271794e-016
		,1.757483326e-016
		,1.746028491e-016
		,1.735908262e-016
		,1.730911564e-016
		,1.740429821e-016
		,1.756712127e-016
		,1.820022612e-016
		,1.944682314e-016
		,2.114777595e-016
		,2.278587743e-016
		,2.513254123e-016
		,2.916664356e-016
		,3.273515175e-016
		,3.517825390e-016
		,3.964533332e-016
		,4.279092188e-016
		,4.588882654e-016
		,4.820197816e-016
		,4.886050424e-016
		,4.902713886e-016
		,4.872574030e-016
		,4.853072575e-016
		,4.849933625e-016
		,4.857361067e-016
		,4.857335497e-016
		,4.854883627e-016
		,1.785216078e-016
		,1.779457922e-016
		,1.776400964e-016
		,1.774989334e-016
		,1.774893268e-016
		,1.776081212e-016
		,1.778766451e-016
		,1.783574817e-016
		,1.792099957e-016
		,1.808503082e-016
		,1.843848274e-016
		,1.918969782e-016
		,2.051094959e-016
		,2.198296983e-016
		,2.313531140e-016
		,2.377962119e-016
		,2.457464131e-016
		,2.512976882e-016
		,2.567482960e-016
		,2.595190917e-016
		,2.617968951e-016
		,2.685878464e-016
		,2.795023954e-016
		,2.946514012e-016
		,3.108138085e-016
		,3.266253718e-016
		,3.413440115e-016
		,3.549485465e-016
		,3.672668247e-016
		,3.787577610e-016
		,3.900732429e-016
		,3.994238282e-016
		,4.066835655e-016
		,4.129018364e-016
		,4.183389955e-016
		,4.230782061e-016
		,4.272091749e-016
		,4.308254736e-016
		,4.340080109e-016
		,4.368188279e-016
		,4.393048670e-016
		,1.768273824e-016
		,1.762939937e-016
		,1.759641119e-016
		,1.757560798e-016
		,1.756404198e-016
		,1.756056733e-016
		,1.756492188e-016
		,1.757763971e-016
		,1.760047951e-016
		,1.763775404e-016
		,1.770006438e-016
		,1.781525243e-016
		,1.806138870e-016
		,1.861726427e-016
		,1.977389848e-016
		,2.139135524e-016
		,2.287484838e-016
		,2.364122743e-016
		,2.437230100e-016
		,2.505927777e-016
		,2.576849204e-016
		,2.637203820e-016
		,2.728712231e-016
		,2.894802443e-016
		,3.092636176e-016
		,3.292079629e-016
		,3.486863903e-016
		,3.657102807e-016
		,3.807064751e-016
		,3.929491628e-016
		,4.022437033e-016
		,4.093769129e-016
		,4.152066792e-016
		,4.202145282e-016
		,4.245743110e-016
		,4.284336432e-016
		,4.318764905e-016
		,4.349738871e-016
		,4.377856225e-016
		,4.403417251e-016
		,4.426529283e-016
		,1.753266051e-016
		,1.748569511e-016
		,1.745450324e-016
		,1.743241792e-016
		,1.741680371e-016
		,1.740641744e-016
		,1.740065921e-016
		,1.739936957e-016
		,1.740280629e-016
		,1.741172984e-016
		,1.742767861e-016
		,1.745376638e-016
		,1.749704043e-016
		,1.757577136e-016
		,1.774200667e-016
		,1.813263942e-016
		,1.905164150e-016
		,2.065045304e-016
		,2.244934492e-016
		,2.356200668e-016
		,2.443023120e-016
		,2.544787621e-016
		,2.669651282e-016
		,2.845819122e-016
		,3.075585493e-016
		,3.302445134e-016
		,3.530883175e-016
		,3.725478660e-016
		,3.875705577e-016
		,3.993603172e-016
		,4.086049380e-016
		,4.160133343e-016
		,4.221473721e-016
		,4.272871610e-016
		,4.315673915e-016
		,4.351642856e-016
		,4.383160425e-016
		,4.411296270e-016
		,4.436379028e-016
		,4.458752650e-016
		,4.478779258e-016
		,1.738873794e-016
		,1.734525362e-016
		,1.731493309e-016
		,1.729224311e-016
		,1.727486135e-016
		,1.726155294e-016
		,1.725156343e-016
		,1.724444099e-016
		,1.723998529e-016
		,1.723823905e-016
		,1.723950582e-016
		,1.724441093e-016
		,1.725407147e-016
		,1.727057626e-016
		,1.729841659e-016
		,1.734901144e-016
		,1.745494782e-016
		,1.771171092e-016
		,1.836975335e-016
		,1.977486708e-016
		,2.182869163e-016
		,2.367339282e-016
		,2.549171340e-016
		,2.781168521e-016
		,3.060756492e-016
		,3.359854618e-016
		,3.624883067e-016
		,3.826216633e-016
		,3.973813199e-016
		,4.086298701e-016
		,4.173205243e-016
		,4.241490404e-016
		,4.296300582e-016
		,4.341138401e-016
		,4.378507836e-016
		,4.410228509e-016
		,4.437589758e-016
		,4.461502723e-016
		,4.482637983e-016
		,4.501524017e-016
		,4.518626220e-016
		,1.726629092e-016
		,1.722324401e-016
		,1.719129654e-016
		,1.716570972e-016
		,1.714446302e-016
		,1.712646789e-016
		,1.711105368e-016
		,1.709780719e-016
		,1.708651048e-016
		,1.707710479e-016
		,1.706966149e-016
		,1.706435993e-016
		,1.706148062e-016
		,1.706143351e-016
		,1.706486644e-016
		,1.707298164e-016
		,1.708847112e-016
		,1.711847623e-016
		,1.718445207e-016
		,1.735515677e-016
		,1.784517678e-016
		,1.919161773e-016
		,2.207820597e-016
		,2.632826258e-016
		,3.083492358e-016
		,3.465465246e-016
		,3.746463944e-016
		,3.941759110e-016
		,4.078556420e-016
		,4.177813535e-016
		,4.252750428e-016
		,4.311394834e-016
		,4.358701672e-016
		,4.397830726e-016
		,4.430869553e-016
		,4.459244230e-016
		,4.483958890e-016
		,4.505740006e-016
		,4.525126173e-016
		,4.542525660e-016
		,4.558254283e-016
		,1.719452602e-016
		,1.715087497e-016
		,1.711676704e-016
		,1.708797643e-016
		,1.706267301e-016
		,1.703985126e-016
		,1.701887871e-016
		,1.699935312e-016
		,1.698104359e-016
		,1.696385211e-016
		,1.694777888e-016
		,1.693288987e-016
		,1.691929104e-016
		,1.690711613e-016
		,1.689653880e-016
		,1.688783302e-016
		,1.688155629e-016
		,1.687909502e-016
		,1.688438408e-016
		,1.691085301e-016
		,1.700322599e-016
		,1.733391929e-016
		,1.856186141e-016
		,2.232939383e-016
		,2.930401572e-016
		,3.518003810e-016
		,3.845618274e-016
		,4.023807296e-016
		,4.147611075e-016
		,4.240418777e-016
		,4.308961414e-016
		,4.361998762e-016
		,4.404186328e-016
		,4.439122846e-016
		,4.468798639e-016
		,4.494477270e-016
		,4.517064253e-016
		,4.537236354e-016
		,4.555377749e-016
		,4.571593872e-016
		,4.586080073e-016
		,1.716994305e-016
		,1.712809684e-016
		,1.709467243e-016
		,1.706586202e-016
		,1.704000151e-016
		,1.701616574e-016
		,1.699376542e-016
		,1.697241856e-016
		,1.695189511e-016
		,1.693207839e-016
		,1.691292900e-016
		,1.689445041e-016
		,1.687666053e-016
		,1.685957521e-016
		,1.684321143e-016
		,1.682762805e-016
		,1.681306094e-016
		,1.680034006e-016
		,1.679219585e-016
		,1.679809232e-016
		,1.685198945e-016
		,1.706509891e-016
		,1.787913252e-016
		,2.048168441e-016
		,2.649637481e-016
		,3.395063119e-016
		,3.846972864e-016
		,4.063751036e-016
		,4.177787874e-016
		,4.259883188e-016
		,4.331822426e-016
		,4.387093785e-016
		,4.428979305e-016
		,4.464329033e-016
		,4.493576301e-016
		,4.517923186e-016
		,4.538919243e-016
		,4.557417386e-016
		,4.573927750e-016
		,4.588813318e-016
		,4.602362038e-016
		,1.715380520e-016
		,1.711425004e-016
		,1.708222817e-016
		,1.705431537e-016
		,1.702901239e-016
		,1.700548589e-016
		,1.698320846e-016
		,1.696184328e-016
		,1.694119281e-016
		,1.692116139e-016
		,1.690171968e-016
		,1.688287108e-016
		,1.686462478e-016
		,1.684698097e-016
		,1.682993558e-016
		,1.681352171e-016
		,1.679794352e-016
		,1.678399048e-016
		,1.677433976e-016
		,1.677763761e-016
		,1.682664418e-016
		,1.702302441e-016
		,1.771748152e-016
		,1.987840324e-016
		,2.483428932e-016
		,3.209463865e-016
		,3.746043400e-016
		,4.047431789e-016
		,4.192706274e-016
		,4.273254371e-016
		,4.331547106e-016
		,4.381830847e-016
		,4.432653582e-016
		,4.472342339e-016
		,4.501773968e-016
		,4.527292429e-016
		,4.550063309e-016
		,4.570041642e-016
		,4.587058098e-016
		,4.601809680e-016
		,4.614932910e-016
		,1.713915659e-016
		,1.710166193e-016
		,1.707092840e-016
		,1.704387400e-016
		,1.701914823e-016
		,1.699600184e-016
		,1.697396514e-016
		,1.695274446e-016
		,1.693217442e-016
		,1.691218172e-016
		,1.689275032e-016
		,1.687388918e-016
		,1.685560724e-016
		,1.683790123e-016
		,1.682076307e-016
		,1.680422439e-016
		,1.678849531e-016
		,1.677439260e-016
		,1.676468656e-016
		,1.676824574e-016
		,1.681579499e-016
		,1.700880597e-016
		,1.763185223e-016
		,1.955599246e-016
		,2.390950549e-016
		,3.030765148e-016
		,3.653910784e-016
		,4.022945254e-016
		,4.216170971e-016
		,4.303957112e-016
		,4.358835282e-016
		,4.400883255e-016
		,4.436963850e-016
		,4.473415640e-016
		,4.511822368e-016
		,4.540689096e-016
		,4.562205297e-016
		,4.580999247e-016
		,4.597920510e-016
		,4.613377840e-016
		,4.627500111e-016
		,1.712519290e-016
		,1.708947687e-016
		,1.705984738e-016
		,1.703352545e-016
		,1.700929254e-016
		,1.698647419e-016
		,1.696465219e-016
		,1.694357123e-016
		,1.692309436e-016
		,1.690316767e-016
		,1.688378623e-016
		,1.686496317e-016
		,1.684670675e-016
		,1.682901075e-016
		,1.681186453e-016
		,1.679530079e-016
		,1.677954033e-016
		,1.676543888e-016
		,1.675589926e-016
		,1.676024918e-016
		,1.680767826e-016
		,1.700198399e-016
		,1.759754793e-016
		,1.934723705e-016
		,2.323024790e-016
		,2.902590900e-016
		,3.548319054e-016
		,4.003163948e-016
		,4.236849692e-016
		,4.339425020e-016
		,4.393003433e-016
		,4.431025779e-016
		,4.462243490e-016
		,4.489824171e-016
		,4.517000299e-016
		,4.547976233e-016
		,4.576395979e-016
		,4.596230915e-016
		,4.611914314e-016
		,4.625947425e-016
		,4.638598949e-016
		,1.711193458e-016
		,1.707771102e-016
		,1.704898585e-016
		,1.702324777e-016
		,1.699939484e-016
		,1.697681887e-016
		,1.695514724e-016
		,1.693415859e-016
		,1.691374071e-016
		,1.689385603e-016
		,1.687450833e-016
		,1.685571318e-016
		,1.683747716e-016
		,1.681979070e-016
		,1.680264082e-016
		,1.678606205e-016
		,1.677028753e-016
		,1.675621646e-016
		,1.674689833e-016
		,1.675216844e-016
		,1.680187918e-016
		,1.699579295e-016
		,1.758798905e-016
		,1.917047137e-016
		,2.273109741e-016
		,2.802496869e-016
		,3.417907211e-016
		,3.971675028e-016
		,4.250213372e-016
		,4.374203871e-016
		,4.428928438e-016
		,4.463130132e-016
		,4.490036295e-016
		,4.513328316e-016
		,4.534452792e-016
		,4.555128635e-016
		,4.578685404e-016
		,4.604572556e-016
		,4.624391239e-016
		,4.638505015e-016
		,4.650357017e-016
		,1.709985325e-016
		,1.706684991e-016
		,1.703882936e-016
		,1.701351723e-016
		,1.698991497e-016
		,1.696747344e-016
		,1.694586087e-016
		,1.692488615e-016
		,1.690445883e-016
		,1.688455525e-016
		,1.686518596e-016
		,1.684636764e-016
		,1.682810449e-016
		,1.681038345e-016
		,1.679318948e-016
		,1.677655947e-016
		,1.676074015e-016
		,1.674667766e-016
		,1.673757891e-016
		,1.674381002e-016
		,1.679697203e-016
		,1.698969381e-016
		,1.758274031e-016
		,1.902217918e-016
		,2.234869033e-016
		,2.705290356e-016
		,3.305015489e-016
		,3.899032824e-016
		,4.256390882e-016
		,4.410534134e-016
		,4.467944275e-016
		,4.499097860e-016
		,4.521526114e-016
		,4.540810668e-016
		,4.558272146e-016
		,4.574501262e-016
		,4.590398489e-016
		,4.608166652e-016
		,4.629726574e-016
		,4.649215596e-016
		,4.662689113e-016
		,1.708942521e-016
		,1.705743049e-016
		,1.702996067e-016
		,1.700495181e-016
		,1.698149730e-016
		,1.695910091e-016
		,1.693746764e-016
		,1.691643358e-016
		,1.689592759e-016
		,1.687593789e-016
		,1.685648038e-016
		,1.683757198e-016
		,1.681921421e-016
		,1.680139079e-016
		,1.678408520e-016
		,1.676733745e-016
		,1.675140867e-016
		,1.673729292e-016
		,1.672835649e-016
		,1.673550039e-016
		,1.679207478e-016
		,1.698749860e-016
		,1.757745198e-016
		,1.896757381e-016
		,2.192965215e-016
		,2.624381013e-016
		,3.206217022e-016
		,3.778889900e-016
		,4.242098515e-016
		,4.440679577e-016
		,4.507085984e-016
		,4.536000830e-016
		,4.554553497e-016
		,4.569847139e-016
		,4.583939301e-016
		,4.597145895e-016
		,4.609615934e-016
		,4.621789829e-016
		,4.634931483e-016
		,4.651381240e-016
		,4.669785971e-016
		,1.708062724e-016
		,1.704950590e-016
		,1.702250115e-016
		,1.699773627e-016
		,1.697438632e-016
		,1.695200222e-016
		,1.693032194e-016
		,1.690920562e-016
		,1.688859884e-016
		,1.686849962e-016
		,1.684892747e-016
		,1.682989854e-016
		,1.681141120e-016
		,1.679344593e-016
		,1.677598518e-016
		,1.675907257e-016
		,1.674298443e-016
		,1.672876369e-016
		,1.671993765e-016
		,1.672794021e-016
		,1.678782675e-016
		,1.699312230e-016
		,1.756711983e-016
		,1.894659806e-016
		,2.151368952e-016
		,2.568200634e-016
		,3.095374426e-016
		,3.662826994e-016
		,4.181850071e-016
		,4.459953428e-016
		,4.548303304e-016
		,4.575292768e-016
		,4.590387753e-016
		,4.601546180e-016
		,4.611940512e-016
		,4.622109761e-016
		,4.631956038e-016
		,4.641400410e-016
		,4.650591637e-016
		,4.660158034e-016
		,4.671707765e-016
		,1.707307135e-016
		,1.704271845e-016
		,1.701612334e-016
		,1.699157430e-016
		,1.696831913e-016
		,1.694594840e-016
		,1.692423244e-016
		,1.690304967e-016
		,1.688236097e-016
		,1.686217183e-016
		,1.684250358e-016
		,1.682337024e-016
		,1.680476671e-016
		,1.678666977e-016
		,1.676906102e-016
		,1.675198768e-016
		,1.673574127e-016
		,1.672141412e-016
		,1.671269582e-016
		,1.672155553e-016
		,1.678473016e-016
		,1.699960081e-016
		,1.756117948e-016
		,1.893145163e-016
		,2.114998562e-016
		,2.517455422e-016
		,2.990765925e-016
		,3.563529882e-016
		,4.067554177e-016
		,4.461927790e-016
		,4.589297856e-016
		,4.617460055e-016
		,4.628099704e-016
		,4.635283248e-016
		,4.641783295e-016
		,4.648751311e-016
		,4.655987979e-016
		,4.663184340e-016
		,4.670172828e-016
		,4.676963889e-016
		,4.683839275e-016
		,1.706685857e-016
		,1.703701536e-016
		,1.701070031e-016
		,1.698626745e-016
		,1.696307064e-016
		,1.694067128e-016
		,1.691892801e-016
		,1.689768551e-016
		,1.687692844e-016
		,1.685666779e-016
		,1.683692198e-016
		,1.681770243e-016
		,1.679899896e-016
		,1.678078697e-016
		,1.676305132e-016
		,1.674584031e-016
		,1.672946048e-016
		,1.671505270e-016
		,1.670646962e-016
		,1.671621360e-016
		,1.678265628e-016
		,1.700647625e-016
		,1.758078212e-016
		,1.889608960e-016
		,2.098155078e-016
		,2.457747274e-016
		,2.920249032e-016
		,3.441137981e-016
		,3.942339631e-016
		,4.410923444e-016
		,4.622666727e-016
		,4.663226047e-016
		,4.669069164e-016
		,4.671906927e-016
		,4.674408155e-016
		,4.677800933e-016
		,4.682148789e-016
		,4.686987684e-016
		,4.691955548e-016
		,4.696842755e-016
		,4.701601854e-016
		,1.706993394e-016
		,1.703781500e-016
		,1.701060938e-016
		,1.698496504e-016
		,1.696123121e-016
		,1.693811546e-016
		,1.691623719e-016
		,1.689476229e-016
		,1.687377045e-016
		,1.685323720e-016
		,1.683330056e-016
		,1.681386395e-016
		,1.679489205e-016
		,1.677639694e-016
		,1.675841258e-016
		,1.674096935e-016
		,1.672438563e-016
		,1.670987003e-016
		,1.670141446e-016
		,1.671206310e-016
		,1.678183880e-016
		,1.701442497e-016
		,1.761242111e-016
		,1.885415517e-016
		,2.089243171e-016
		,2.395661441e-016
		,2.859894076e-016
		,3.319371489e-016
		,3.846942115e-016
		,4.308768397e-016
		,4.641079963e-016
		,4.707601424e-016
		,4.711997580e-016
		,4.709573975e-016
		,4.708277741e-016
		,4.708026853e-016
		,4.709256513e-016
		,4.711564169e-016
		,4.714435437e-016
		,4.717519951e-016
		,4.720650530e-016
		,1.717047357e-016
		,1.711487386e-016
		,1.707118871e-016
		,1.702937852e-016
		,1.699626650e-016
		,1.696572935e-016
		,1.694134188e-016
		,1.691836967e-016
		,1.689476480e-016
		,1.687152754e-016
		,1.685017425e-016
		,1.682889458e-016
		,1.680723567e-016
		,1.678626834e-016
		,1.676632967e-016
		,1.674666228e-016
		,1.672886517e-016
		,1.671354281e-016
		,1.670390298e-016
		,1.671509117e-016
		,1.678804036e-016
		,1.702927129e-016
		,1.765068111e-016
		,1.883178959e-016
		,2.081780995e-016
		,2.342752519e-016
		,2.802715006e-016
		,3.220956320e-016
		,3.712063246e-016
		,4.169688947e-016
		,4.625864512e-016
		,4.755970714e-016
		,4.762471760e-016
		,4.752554484e-016
		,4.745481265e-016
		,4.740890646e-016
		,4.738381729e-016
		,4.737687706e-016
		,4.738234569e-016
		,4.739493100e-016
		,4.741102398e-016
		,1.771733422e-016
		,1.757813609e-016
		,1.743660541e-016
		,1.730337541e-016
		,1.721639809e-016
		,1.715718808e-016
		,1.710449620e-016
		,1.707809461e-016
		,1.704290240e-016
		,1.701067003e-016
		,1.697833748e-016
		,1.695035883e-016
		,1.691287804e-016
		,1.688037479e-016
		,1.684802775e-016
		,1.681845024e-016
		,1.678628407e-016
		,1.676109330e-016
		,1.675000067e-016
		,1.676150300e-016
		,1.683438958e-016
		,1.707959199e-016
		,1.772667806e-016
		,1.892201375e-016
		,2.065759905e-016
		,2.319536206e-016
		,2.710321129e-016
		,3.143806518e-016
		,3.538312718e-016
		,3.999163155e-016
		,4.474516185e-016
		,4.779475316e-016
		,4.823019075e-016
		,4.810388286e-016
		,4.795050585e-016
		,4.784618139e-016
		,4.777423696e-016
		,4.772726645e-016
		,4.769950487e-016
		,4.768458424e-016
		,4.767821152e-016
		,1.846439718e-016
		,1.812731248e-016
		,1.795988046e-016
		,1.769556907e-016
		,1.764407830e-016
		,1.745179397e-016
		,1.742991338e-016
		,1.742688618e-016
		,1.736461676e-016
		,1.730579431e-016
		,1.725581852e-016
		,1.717951847e-016
		,1.712990890e-016
		,1.707883977e-016
		,1.701757496e-016
		,1.695842177e-016
		,1.691270494e-016
		,1.685686340e-016
		,1.685136445e-016
		,1.693684278e-016
		,1.721354635e-016
		,1.790806746e-016
		,1.909555636e-016
		,2.057397965e-016
		,2.305177505e-016
		,2.571220961e-016
		,3.036567580e-016
		,3.299447993e-016
		,3.453247097e-016
		,3.747932094e-016
		,4.283903965e-016
		,4.680350421e-016
		,4.855027095e-016
		,4.887874522e-016
		,4.875769388e-016
		,4.857363669e-016
		,4.841901558e-016
		,4.830235058e-016
		,4.821671694e-016
		,4.815454646e-016
		,4.810924103e-016
		,1.933581187e-016
		,1.905100328e-016
		,1.884709359e-016
		,1.851146012e-016
		,1.834208867e-016
		,1.824591564e-016
		,1.791123027e-016
		,1.790987199e-016
		,1.786396357e-016
		,1.776524335e-016
		,1.757480114e-016
		,1.755407249e-016
		,1.748055455e-016
		,1.741437469e-016
		,1.733192725e-016
		,1.724153885e-016
		,1.713546846e-016
		,1.708249964e-016
		,1.704268969e-016
		,1.706554215e-016
		,1.736069981e-016
		,1.813430125e-016
		,1.935510661e-016
		,2.106139011e-016
		,2.272602218e-016
		,2.538338559e-016
		,2.810331890e-016
		,3.220684171e-016
		,3.378714293e-016
		,3.461651703e-016
		,4.027118576e-016
		,4.494898780e-016
		,4.842723840e-016
		,4.969067991e-016
		,4.976839104e-016
		,4.952222608e-016
		,4.927561316e-016
		,4.907600389e-016
		,4.891273765e-016
		,4.878455169e-016
		,4.868490184e-016
		,1.789097379e-016
		,1.783716754e-016
		,1.780951933e-016
		,1.779781488e-016
		,1.779893124e-016
		,1.781274349e-016
		,1.784164998e-016
		,1.789229217e-016
		,1.798123228e-016
		,1.815129288e-016
		,1.851553047e-016
		,1.929557840e-016
		,2.065977104e-016
		,2.225388989e-016
		,2.349268863e-016
		,2.424567382e-016
		,2.494044086e-016
		,2.547149096e-016
		,2.596228885e-016
		,2.659366816e-016
		,2.683797047e-016
		,2.716037603e-016
		,2.811060662e-016
		,2.951328107e-016
		,3.115388170e-016
		,3.277601060e-016
		,3.423562587e-016
		,3.559499792e-016
		,3.682347206e-016
		,3.795829902e-016
		,3.904365515e-016
		,3.998493175e-016
		,4.068198874e-016
		,4.127196904e-016
		,4.179235409e-016
		,4.224800577e-016
		,4.264853639e-016
		,4.300368653e-016
		,4.332009489e-016
		,4.360225888e-016
		,4.385398488e-016
		,1.772219110e-016
		,1.767198821e-016
		,1.764179854e-016
		,1.762377215e-016
		,1.761501930e-016
		,1.761436133e-016
		,1.762148652e-016
		,1.763692133e-016
		,1.766252059e-016
		,1.770287315e-016
		,1.776915938e-016
		,1.789043074e-016
		,1.814723496e-016
		,1.872788028e-016
		,1.992532496e-016
		,2.165098556e-016
		,2.321234113e-016
		,2.413563137e-016
		,2.481270057e-016
		,2.554217750e-016
		,2.625891618e-016
		,2.722208566e-016
		,2.809865596e-016
		,2.942074162e-016
		,3.120256128e-016
		,3.305440720e-016
		,3.486097675e-016
		,3.654003291e-016
		,3.800389113e-016
		,3.921529193e-016
		,4.016559528e-016
		,4.095003455e-016
		,4.159511194e-016
		,4.212303203e-016
		,4.255545469e-016
		,4.291003582e-016
		,4.320894987e-016
		,4.348145740e-016
		,4.373614326e-016
		,4.397141999e-016
		,4.418776759e-016
		,1.758447805e-016
		,1.753930136e-016
		,1.750929401e-016
		,1.748825473e-016
		,1.747378145e-016
		,1.746477990e-016
		,1.746075199e-016
		,1.746159914e-016
		,1.746760081e-016
		,1.747951215e-016
		,1.749887825e-016
		,1.752891841e-016
		,1.757705778e-016
		,1.766258289e-016
		,1.784016767e-016
		,1.825324904e-016
		,1.921298995e-016
		,2.090897092e-016
		,2.279866118e-016
		,2.408086744e-016
		,2.493291619e-016
		,2.600330754e-016
		,2.740912842e-016
		,2.920844569e-016
		,3.129592245e-016
		,3.354977290e-016
		,3.556513164e-016
		,3.737884626e-016
		,3.880838520e-016
		,3.994010113e-016
		,4.084720212e-016
		,4.157987006e-016
		,4.217807147e-016
		,4.268132820e-016
		,4.311135307e-016
		,4.348083892e-016
		,4.380156631e-016
		,4.408236882e-016
		,4.432935972e-016
		,4.454761603e-016
		,4.474138487e-016
		,1.745105278e-016
		,1.741156487e-016
		,1.738424260e-016
		,1.736392364e-016
		,1.734843587e-016
		,1.733664815e-016
		,1.732791556e-016
		,1.732191636e-016
		,1.731860185e-016
		,1.731818244e-016
		,1.732113731e-016
		,1.732826889e-016
		,1.734087752e-016
		,1.736127992e-016
		,1.739436844e-016
		,1.745248912e-016
		,1.757089961e-016
		,1.785059786e-016
		,1.855548520e-016
		,2.005253572e-016
		,2.223143651e-016
		,2.424281360e-016
		,2.604665101e-016
		,2.836668252e-016
		,3.121453911e-016
		,3.400308715e-016
		,3.635830301e-016
		,3.827722624e-016
		,3.974558335e-016
		,4.084546260e-016
		,4.168393589e-016
		,4.235798437e-016
		,4.290999401e-016
		,4.336621505e-016
		,4.374854535e-016
		,4.407390673e-016
		,4.435485975e-016
		,4.460052540e-016
		,4.481755601e-016
		,4.501091739e-016
		,4.518448087e-016
		,1.732537533e-016
		,1.728764943e-016
		,1.726011013e-016
		,1.723850288e-016
		,1.722100716e-016
		,1.720663925e-016
		,1.719479146e-016
		,1.718508760e-016
		,1.717732747e-016
		,1.717145721e-016
		,1.716754995e-016
		,1.716579757e-016
		,1.716652211e-016
		,1.717022675e-016
		,1.717773442e-016
		,1.719055537e-016
		,1.721194040e-016
		,1.725016192e-016
		,1.732926851e-016
		,1.752416956e-016
		,1.806084833e-016
		,1.947622019e-016
		,2.239505851e-016
		,2.659226094e-016
		,3.101777412e-016
		,3.477502725e-016
		,3.754534747e-016
		,3.947414576e-016
		,4.082705166e-016
		,4.180976601e-016
		,4.255237096e-016
		,4.313398008e-016
		,4.360347520e-016
		,4.399205211e-016
		,4.432033268e-016
		,4.460241107e-016
		,4.484821549e-016
		,4.506493162e-016
		,4.525788887e-016
		,4.543112861e-016
		,4.558777831e-016
		,1.722065548e-016
		,1.718274808e-016
		,1.715345612e-016
		,1.712910689e-016
		,1.710810706e-016
		,1.708958676e-016
		,1.707301081e-016
		,1.705805518e-016
		,1.704455446e-016
		,1.703246609e-016
		,1.702183755e-016
		,1.701277654e-016
		,1.700542890e-016
		,1.699997164e-016
		,1.699663282e-016
		,1.699576529e-016
		,1.699805752e-016
		,1.700514835e-016
		,1.702152268e-016
		,1.706081390e-016
		,1.717079130e-016
		,1.750702831e-016
		,1.862794538e-016
		,2.202591286e-016
		,2.853469102e-016
		,3.511196044e-016
		,3.867644630e-016
		,4.052607425e-016
		,4.175252625e-016
		,4.258714431e-016
		,4.320904185e-016
		,4.373962299e-016
		,4.419295551e-016
		,4.454659237e-016
		,4.483293625e-016
		,4.507563069e-016
		,4.528702948e-016
		,4.547400756e-016
		,4.564116088e-016
		,4.579189189e-016
		,4.592886746e-016
		,1.716367137e-016
		,1.712514798e-016
		,1.709404524e-016
		,1.706708018e-016
		,1.704281103e-016
		,1.702043873e-016
		,1.699946457e-016
		,1.697958038e-016
		,1.696061951e-016
		,1.694252074e-016
		,1.692529414e-016
		,1.690898928e-016
		,1.689367062e-016
		,1.687940612e-016
		,1.686627726e-016
		,1.685443131e-016
		,1.684424305e-016
		,1.683681517e-016
		,1.683557632e-016
		,1.685132711e-016
		,1.691887345e-016
		,1.715828216e-016
		,1.788889580e-016
		,2.001520213e-016
		,2.520752791e-016
		,3.248342949e-016
		,3.842244377e-016
		,4.106372638e-016
		,4.228596516e-016
		,4.311400094e-016
		,4.375585422e-016
		,4.415996104e-016
		,4.449255375e-016
		,4.479401443e-016
		,4.510296652e-016
		,4.539222028e-016
		,4.561419810e-016
		,4.579727026e-016
		,4.595274975e-016
		,4.608806662e-016
		,4.620901657e-016
		,1.714413093e-016
		,1.710704594e-016
		,1.707653201e-016
		,1.704963175e-016
		,1.702503809e-016
		,1.700202115e-016
		,1.698012290e-016
		,1.695905833e-016
		,1.693866926e-016
		,1.691888862e-016
		,1.689970597e-016
		,1.688113579e-016
		,1.686319303e-016
		,1.684588192e-016
		,1.682920472e-016
		,1.681320963e-016
		,1.679813991e-016
		,1.678489927e-016
		,1.677654189e-016
		,1.678298627e-016
		,1.683488669e-016
		,1.703611661e-016
		,1.766744894e-016
		,1.930050497e-016
		,2.340732901e-016
		,2.985582797e-016
		,3.604503131e-016
		,4.076483197e-016
		,4.260627642e-016
		,4.341011559e-016
		,4.397564249e-016
		,4.453843899e-016
		,4.485245110e-016
		,4.508748213e-016
		,4.529445899e-016
		,4.548421998e-016
		,4.567059724e-016
		,4.587960261e-016
		,4.609993602e-016
		,4.627043997e-016
		,4.640273998e-016
		,1.713024239e-016
		,1.709487645e-016
		,1.706540250e-016
		,1.703915844e-016
		,1.701496633e-016
		,1.699216962e-016
		,1.697036035e-016
		,1.694929021e-016
		,1.692882718e-016
		,1.690892068e-016
		,1.688956772e-016
		,1.687078235e-016
		,1.685257327e-016
		,1.683493468e-016
		,1.681785720e-016
		,1.680137702e-016
		,1.678572488e-016
		,1.677178857e-016
		,1.676258711e-016
		,1.676791747e-016
		,1.681797468e-016
		,1.700290477e-016
		,1.759183503e-016
		,1.906025627e-016
		,2.243980484e-016
		,2.792757188e-016
		,3.427066430e-016
		,3.918149802e-016
		,4.251020368e-016
		,4.365486759e-016
		,4.419801511e-016
		,4.462134516e-016
		,4.512704138e-016
		,4.540861447e-016
		,4.559050715e-016
		,4.574798517e-016
		,4.589014408e-016
		,4.602043672e-016
		,4.614271002e-016
		,4.626431371e-016
		,4.640023727e-016
		,1.711722396e-016
		,1.708338220e-016
		,1.705484554e-016
		,1.702921320e-016
		,1.700542224e-016
		,1.698288212e-016
		,1.696123062e-016
		,1.694025343e-016
		,1.691984324e-016
		,1.689996555e-016
		,1.688062563e-016
		,1.686183938e-016
		,1.684361310e-016
		,1.682593687e-016
		,1.680879792e-016
		,1.679223239e-016
		,1.677647882e-016
		,1.676245455e-016
		,1.675327639e-016
		,1.675906166e-016
		,1.681099547e-016
		,1.699468499e-016
		,1.756152770e-016
		,1.896355882e-016
		,2.181469371e-016
		,2.676897035e-016
		,3.293425442e-016
		,3.827529183e-016
		,4.177521546e-016
		,4.387923203e-016
		,4.453716256e-016
		,4.490254424e-016
		,4.526910883e-016
		,4.570058396e-016
		,4.590497260e-016
		,4.604246067e-016
		,4.616323861e-016
		,4.627338428e-016
		,4.637465762e-016
		,4.646848507e-016
		,4.655693036e-016
		,1.710461913e-016
		,1.707207187e-016
		,1.704432034e-016
		,1.701919394e-016
		,1.699573097e-016
		,1.697339923e-016
		,1.695187710e-016
		,1.693098035e-016
		,1.691062321e-016
		,1.689078471e-016
		,1.687147649e-016
		,1.685271513e-016
		,1.683450411e-016
		,1.681682972e-016
		,1.679967690e-016
		,1.678308381e-016
		,1.676730156e-016
		,1.675328994e-016
		,1.674430467e-016
		,1.675091715e-016
		,1.680574836e-016
		,1.699817301e-016
		,1.754403544e-016
		,1.892037548e-016
		,2.142839837e-016
		,2.595042016e-016
		,3.175800138e-016
		,3.765834772e-016
		,4.134417322e-016
		,4.383681939e-016
		,4.482563721e-016
		,4.517128024e-016
		,4.544134709e-016
		,4.583197178e-016
		,4.614007864e-016
		,4.627661693e-016
		,4.638218598e-016
		,4.647732335e-016
		,4.656511476e-016
		,4.664645582e-016
		,4.672206873e-016
		,1.709267785e-016
		,1.706118856e-016
		,1.703405236e-016
		,1.700930145e-016
		,1.698606342e-016
		,1.696385784e-016
		,1.694239914e-016
		,1.692152974e-016
		,1.690118251e-016
		,1.688134767e-016
		,1.686204137e-016
		,1.684327965e-016
		,1.682506260e-016
		,1.680737263e-016
		,1.679019274e-016
		,1.677356383e-016
		,1.675775128e-016
		,1.674376283e-016
		,1.673501291e-016
		,1.674259558e-016
		,1.680076088e-016
		,1.700308024e-016
		,1.753797189e-016
		,1.889598731e-016
		,2.126365775e-016
		,2.514700402e-016
		,3.081172308e-016
		,3.682501653e-016
		,4.108958228e-016
		,4.349797256e-016
		,4.509222641e-016
		,4.549104643e-016
		,4.570489932e-016
		,4.596822204e-016
		,4.634643034e-016
		,4.651935487e-016
		,4.661229294e-016
		,4.669059497e-016
		,4.676221976e-016
		,4.682873588e-016
		,4.689070228e-016
		,1.708198350e-016
		,1.705133945e-016
		,1.702465884e-016
		,1.700015342e-016
		,1.697703011e-016
		,1.695485485e-016
		,1.693337464e-016
		,1.691245578e-016
		,1.689204758e-016
		,1.687214966e-016
		,1.685278139e-016
		,1.683395754e-016
		,1.681567460e-016
		,1.679791136e-016
		,1.678064946e-016
		,1.676393328e-016
		,1.674804377e-016
		,1.673404015e-016
		,1.672550800e-016
		,1.673410842e-016
		,1.679586750e-016
		,1.700850155e-016
		,1.756493617e-016
		,1.885882576e-016
		,2.114574836e-016
		,2.446197341e-016
		,3.011102438e-016
		,3.581903553e-016
		,4.080379505e-016
		,4.333097663e-016
		,4.510128220e-016
		,4.582141903e-016
		,4.599375485e-016
		,4.615879064e-016
		,4.647958959e-016
		,4.673361971e-016
		,4.682328385e-016
		,4.688571281e-016
		,4.694246852e-016
		,4.699620083e-016
		,4.704708277e-016
		,1.707288294e-016
		,1.704294027e-016
		,1.701661316e-016
		,1.699227275e-016
		,1.696919665e-016
		,1.694699239e-016
		,1.692543631e-016
		,1.690441610e-016
		,1.688389544e-016
		,1.686388170e-016
		,1.684439635e-016
		,1.682545230e-016
		,1.680704246e-016
		,1.678914248e-016
		,1.677173330e-016
		,1.675486368e-016
		,1.673883091e-016
		,1.672474720e-016
		,1.671637180e-016
		,1.672593664e-016
		,1.679122202e-016
		,1.701350224e-016
		,1.759495077e-016
		,1.882391726e-016
		,2.104049312e-016
		,2.395150034e-016
		,2.931516284e-016
		,3.480944079e-016
		,4.029305967e-016
		,4.332964064e-016
		,4.488832801e-016
		,4.610376922e-016
		,4.632043876e-016
		,4.641336826e-016
		,4.660551961e-016
		,4.692414735e-016
		,4.704810890e-016
		,4.709773191e-016
		,4.713834569e-016
		,4.717739993e-016
		,4.721541164e-016
		,1.706517457e-016
		,1.703585013e-016
		,1.700983097e-016
		,1.698562980e-016
		,1.696258745e-016
		,1.694034844e-016
		,1.691871556e-016
		,1.689759512e-016
		,1.687696296e-016
		,1.685683230e-016
		,1.683722526e-016
		,1.681815200e-016
		,1.679960146e-016
		,1.678154617e-016
		,1.676396664e-016
		,1.674691637e-016
		,1.673070957e-016
		,1.671651290e-016
		,1.670826400e-016
		,1.671877743e-016
		,1.678759933e-016
		,1.701925872e-016
		,1.762487756e-016
		,1.882381240e-016
		,2.092160793e-016
		,2.375307139e-016
		,2.833309556e-016
		,3.401257090e-016
		,3.939572222e-016
		,4.327224874e-016
		,4.485388344e-016
		,4.610836422e-016
		,4.665753972e-016
		,4.670725190e-016
		,4.678893824e-016
		,4.705247106e-016
		,4.726676551e-016
		,4.731867126e-016
		,4.734482025e-016
		,4.736854249e-016
		,4.739272346e-016
		,1.705844563e-016
		,1.702966743e-016
		,1.700392343e-016
		,1.697984784e-016
		,1.695684146e-016
		,1.693457930e-016
		,1.691288989e-016
		,1.689169389e-016
		,1.687097734e-016
		,1.685075739e-016
		,1.683105618e-016
		,1.681187967e-016
		,1.679321238e-016
		,1.677502402e-016
		,1.675729470e-016
		,1.674008264e-016
		,1.672371910e-016
		,1.670942525e-016
		,1.670131860e-016
		,1.671279794e-016
		,1.678515485e-016
		,1.702585351e-016
		,1.765411127e-016
		,1.888441822e-016
		,2.075463334e-016
		,2.360779193e-016
		,2.739841934e-016
		,3.324774133e-016
		,3.834979897e-016
		,4.303171114e-016
		,4.502893421e-016
		,4.592608812e-016
		,4.690485784e-016
		,4.702683739e-016
		,4.703319917e-016
		,4.715644409e-016
		,4.743474311e-016
		,4.753518584e-016
		,4.755256961e-016
		,4.756186497e-016
		,4.757244066e-016
		,1.705288565e-016
		,1.702447450e-016
		,1.699887522e-016
		,1.697481885e-016
		,1.695179585e-016
		,1.692947777e-016
		,1.690772856e-016
		,1.688646671e-016
		,1.686567234e-016
		,1.684537413e-016
		,1.682559461e-016
		,1.680632990e-016
		,1.678755792e-016
		,1.676925305e-016
		,1.675139170e-016
		,1.673403836e-016
		,1.671754140e-016
		,1.670317739e-016
		,1.669524566e-016
		,1.670773574e-016
		,1.678366795e-016
		,1.703324351e-016
		,1.768307943e-016
		,1.893949035e-016
		,2.060944461e-016
		,2.348004892e-016
		,2.661616864e-016
		,3.238112662e-016
		,3.739034130e-016
		,4.239796387e-016
		,4.516412690e-016
		,4.602386425e-016
		,4.686678114e-016
		,4.737163985e-016
		,4.734059153e-016
		,4.734502760e-016
		,4.754488206e-016
		,4.774835292e-016
		,4.777672164e-016
		,4.777382436e-016
		,4.776981816e-016
		,1.705724156e-016
		,1.702726403e-016
		,1.700002597e-016
		,1.697449488e-016
		,1.695059129e-016
		,1.692767264e-016
		,1.690547925e-016
		,1.688402420e-016
		,1.686291923e-016
		,1.684236613e-016
		,1.682232798e-016
		,1.680283358e-016
		,1.678375515e-016
		,1.676513570e-016
		,1.674698773e-016
		,1.672933966e-016
		,1.671261604e-016
		,1.669812457e-016
		,1.669033340e-016
		,1.670383030e-016
		,1.678332059e-016
		,1.704166543e-016
		,1.771189081e-016
		,1.898354377e-016
		,2.055113343e-016
		,2.329930858e-016
		,2.631969335e-016
		,3.118457361e-016
		,3.662481337e-016
		,4.138048682e-016
		,4.516100488e-016
		,4.634589086e-016
		,4.671858024e-016
		,4.755955042e-016
		,4.766620437e-016
		,4.760070870e-016
		,4.765010910e-016
		,4.789429754e-016
		,4.799263682e-016
		,4.798425013e-016
		,4.796544216e-016
		,1.718143902e-016
		,1.712018259e-016
		,1.707050790e-016
		,1.702774904e-016
		,1.699114446e-016
		,1.696273283e-016
		,1.693398318e-016
		,1.691172595e-016
		,1.688815248e-016
		,1.686540081e-016
		,1.684250327e-016
		,1.682150724e-016
		,1.679949927e-016
		,1.677830065e-016
		,1.675808471e-016
		,1.673776309e-016
		,1.671935403e-016
		,1.670310297e-016
		,1.669443034e-016
		,1.670841484e-016
		,1.679110760e-016
		,1.705829263e-016
		,1.774829808e-016
		,1.902472581e-016
		,2.063251183e-016
		,2.300761017e-016
		,2.613058529e-016
		,2.990346602e-016
		,3.573563101e-016
		,4.025647361e-016
		,4.479860405e-016
		,4.662654550e-016
		,4.694186151e-016
		,4.738073170e-016
		,4.795278057e-016
		,4.789496178e-016
		,4.783630438e-016
		,4.796238393e-016
		,4.817588840e-016
		,4.820135035e-016
		,4.817446361e-016
		,1.788369150e-016
		,1.761478834e-016
		,1.744521453e-016
		,1.734898189e-016
		,1.722529038e-016
		,1.718072129e-016
		,1.710530547e-016
		,1.708326118e-016
		,1.705399856e-016
		,1.701845246e-016
		,1.698341666e-016
		,1.695413891e-016
		,1.691591330e-016
		,1.688703158e-016
		,1.685388316e-016
		,1.682372805e-016
		,1.679009218e-016
		,1.676141147e-016
		,1.674816215e-016
		,1.675981633e-016
		,1.683660489e-016
		,1.711434753e-016
		,1.782559917e-016
		,1.908765761e-016
		,2.074786866e-016
		,2.270518639e-016
		,2.590903141e-016
		,2.860971055e-016
		,3.436881713e-016
		,3.900127262e-016
		,4.334395254e-016
		,4.656050723e-016
		,4.734755159e-016
		,4.732127262e-016
		,4.797068040e-016
		,4.826737132e-016
		,4.815452914e-016
		,4.812116152e-016
		,4.832552279e-016
		,4.845859759e-016
		,4.843927900e-016
		,1.928667718e-016
		,1.840307144e-016
		,1.819486203e-016
		,1.799831269e-016
		,1.777766005e-016
		,1.764897304e-016
		,1.752845044e-016
		,1.742251605e-016
		,1.740438910e-016
		,1.735611270e-016
		,1.732662410e-016
		,1.721219067e-016
		,1.720497812e-016
		,1.716248014e-016
		,1.711049300e-016
		,1.704830770e-016
		,1.699304448e-016
		,1.693907083e-016
		,1.688220714e-016
		,1.686875882e-016
		,1.695445780e-016
		,1.725812540e-016
		,1.800131473e-016
		,1.921054176e-016
		,2.094864024e-016
		,2.284295606e-016
		,2.518119987e-016
		,2.817882821e-016
		,3.163489014e-016
		,3.714467238e-016
		,4.106095188e-016
		,4.539426824e-016
		,4.765189120e-016
		,4.802206753e-016
		,4.786367418e-016
		,4.862168174e-016
		,4.877176519e-016
		,4.861816313e-016
		,4.863922607e-016
		,4.884938936e-016
		,4.886715655e-016
		,1.792760534e-016
		,1.787664968e-016
		,1.785098877e-016
		,1.784079849e-016
		,1.784320468e-016
		,1.785831722e-016
		,1.788878735e-016
		,1.794156411e-016
		,1.803369272e-016
		,1.820895785e-016
		,1.858234189e-016
		,1.938655368e-016
		,2.078506181e-016
		,2.247964212e-016
		,2.373076104e-016
		,2.462759417e-016
		,2.529094050e-016
		,2.577228802e-016
		,2.617530782e-016
		,2.687895625e-016
		,2.745182701e-016
		,2.753592342e-016
		,2.811891845e-016
		,2.942117601e-016
		,3.111412054e-016
		,3.287117882e-016
		,3.443127610e-016
		,3.576694707e-016
		,3.697179921e-016
		,3.805255599e-016
		,3.906176690e-016
		,4.000262792e-016
		,4.075846711e-016
		,4.137612722e-016
		,4.188979187e-016
		,4.231148211e-016
		,4.266592064e-016
		,4.299124143e-016
		,4.329254052e-016
		,4.356433250e-016
		,4.380692304e-016
		,1.775693447e-016
		,1.771008338e-016
		,1.768283479e-016
		,1.766752212e-016
		,1.766125129e-016
		,1.766280948e-016
		,1.767189434e-016
		,1.768912583e-016
		,1.771655840e-016
		,1.775911110e-016
		,1.782850054e-016
		,1.795478733e-016
		,1.822051021e-016
		,1.882186264e-016
		,2.005266590e-016
		,2.187392134e-016
		,2.347782361e-016
		,2.458096963e-016
		,2.525493152e-016
		,2.594677135e-016
		,2.659605937e-016
		,2.754223822e-016
		,2.872965930e-016
		,2.992724999e-016
		,3.147181854e-016
		,3.316231678e-016
		,3.483975155e-016
		,3.640824828e-016
		,3.784969139e-016
		,3.910001672e-016
		,4.005985126e-016
		,4.083812315e-016
		,4.149615320e-016
		,4.205391841e-016
		,4.252367908e-016
		,4.291972492e-016
		,4.325697211e-016
		,4.354841895e-016
		,4.380322224e-016
		,4.402724130e-016
		,4.422438156e-016
		,1.762367453e-016
		,1.758030228e-016
		,1.755187242e-016
		,1.753249433e-016
		,1.751988694e-016
		,1.751299666e-016
		,1.751131366e-016
		,1.751468681e-016
		,1.752332124e-016
		,1.753791261e-016
		,1.756001822e-016
		,1.759301892e-016
		,1.764477115e-016
		,1.773551258e-016
		,1.792190365e-016
		,1.835336002e-016
		,1.934431402e-016
		,2.112106464e-016
		,2.307171074e-016
		,2.453652382e-016
		,2.540655922e-016
		,2.650023940e-016
		,2.792841248e-016
		,2.973592058e-016
		,3.184886273e-016
		,3.384917460e-016
		,3.580794011e-016
		,3.749819234e-016
		,3.886255150e-016
		,3.994648283e-016
		,4.081744434e-016
		,4.153119161e-016
		,4.212260579e-016
		,4.261674247e-016
		,4.303937142e-016
		,4.340816983e-016
		,4.373130769e-016
		,4.401447168e-016
		,4.426352905e-016
		,4.448439988e-016
		,4.468229433e-016
		,1.750520896e-016
		,1.746726693e-016
		,1.744074182e-016
		,1.742085729e-016
		,1.740566099e-016
		,1.739418875e-016
		,1.738593856e-016
		,1.738071232e-016
		,1.737856265e-016
		,1.737977310e-016
		,1.738486255e-016
		,1.739464141e-016
		,1.741040717e-016
		,1.743452381e-016
		,1.747212040e-016
		,1.753627149e-016
		,1.766423699e-016
		,1.796171380e-016
		,1.869914400e-016
		,2.026652035e-016
		,2.251627764e-016
		,2.469597752e-016
		,2.650589563e-016
		,2.880566317e-016
		,3.159459255e-016
		,3.437128008e-016
		,3.662198407e-016
		,3.835353592e-016
		,3.972895278e-016
		,4.081937611e-016
		,4.166785535e-016
		,4.233251875e-016
		,4.286730978e-016
		,4.331716707e-016
		,4.370051372e-016
		,4.402933048e-016
		,4.431442444e-016
		,4.456438733e-016
		,4.478571938e-016
		,4.498331544e-016
		,4.516089950e-016
		,1.738418368e-016
		,1.735016215e-016
		,1.732564090e-016
		,1.730664396e-016
		,1.729143195e-016
		,1.727904365e-016
		,1.726888332e-016
		,1.726059793e-016
		,1.725403372e-016
		,1.724921303e-016
		,1.724631673e-016
		,1.724567341e-016
		,1.724776516e-016
		,1.725327203e-016
		,1.726320919e-016
		,1.727931416e-016
		,1.730518221e-016
		,1.734979886e-016
		,1.743896446e-016
		,1.765179736e-016
		,1.822142111e-016
		,1.968141210e-016
		,2.261471637e-016
		,2.677085474e-016
		,3.114051266e-016
		,3.485579351e-016
		,3.759959354e-016
		,3.951224388e-016
		,4.085506497e-016
		,4.183117307e-016
		,4.256923844e-016
		,4.314759811e-016
		,4.361468831e-016
		,4.400143613e-016
		,4.432829386e-016
		,4.460924427e-016
		,4.485413984e-016
		,4.507011336e-016
		,4.526245633e-016
		,4.543518247e-016
		,4.559139861e-016
		,1.727419347e-016
		,1.724081375e-016
		,1.721532806e-016
		,1.719444894e-016
		,1.717674787e-016
		,1.716144793e-016
		,1.714807744e-016
		,1.713635809e-016
		,1.712615484e-016
		,1.711743998e-016
		,1.711026084e-016
		,1.710471274e-016
		,1.710092355e-016
		,1.709905772e-016
		,1.709935162e-016
		,1.710220729e-016
		,1.710842859e-016
		,1.711987314e-016
		,1.714141734e-016
		,1.718708566e-016
		,1.730326806e-016
		,1.764360284e-016
		,1.867622078e-016
		,2.178530500e-016
		,2.793663872e-016
		,3.457397625e-016
		,3.877644096e-016
		,4.075703177e-016
		,4.190504772e-016
		,4.271380456e-016
		,4.336209527e-016
		,4.387135125e-016
		,4.426022872e-016
		,4.459521908e-016
		,4.489792203e-016
		,4.516555780e-016
		,4.538221618e-016
		,4.556503514e-016
		,4.572602646e-016
		,4.587045440e-016
		,4.600137604e-016
		,1.718407359e-016
		,1.715003197e-016
		,1.712269714e-016
		,1.709921628e-016
		,1.707833531e-016
		,1.705936469e-016
		,1.704188504e-016
		,1.702565202e-016
		,1.701055187e-016
		,1.699656721e-016
		,1.698374423e-016
		,1.697216306e-016
		,1.696191599e-016
		,1.695309963e-016
		,1.694582908e-016
		,1.694029586e-016
		,1.693694062e-016
		,1.693698383e-016
		,1.694411371e-016
		,1.696982514e-016
		,1.704926649e-016
		,1.729033382e-016
		,1.801020930e-016
		,1.982787282e-016
		,2.431527033e-016
		,3.173213973e-016
		,3.774338622e-016
		,4.142082335e-016
		,4.280308711e-016
		,4.346421608e-016
		,4.393011658e-016
		,4.432445327e-016
		,4.473538193e-016
		,4.505502690e-016
		,4.527708524e-016
		,4.547424377e-016
		,4.566128856e-016
		,4.584147319e-016
		,4.602321620e-016
		,4.619307930e-016
		,4.632894575e-016
		,1.713849850e-016
		,1.710384294e-016
		,1.707498416e-016
		,1.704936412e-016
		,1.702584635e-016
		,1.700379837e-016
		,1.698283173e-016
		,1.696271697e-016
		,1.694334170e-016
		,1.692467647e-016
		,1.690674179e-016
		,1.688957856e-016
		,1.687322713e-016
		,1.685772023e-016
		,1.684309739e-016
		,1.682946353e-016
		,1.681716683e-016
		,1.680736325e-016
		,1.680385573e-016
		,1.681902551e-016
		,1.689164352e-016
		,1.713013578e-016
		,1.780554879e-016
		,1.944440257e-016
		,2.254037544e-016
		,2.831933481e-016
		,3.527126976e-016
		,4.017861881e-016
		,4.281651930e-016
		,4.411917104e-016
		,4.454439490e-016
		,4.482538619e-016
		,4.506867043e-016
		,4.531514378e-016
		,4.564569956e-016
		,4.588107129e-016
		,4.602241238e-016
		,4.614439682e-016
		,4.625786792e-016
		,4.636788270e-016
		,4.647734393e-016
		,1.712240487e-016
		,1.708885962e-016
		,1.706047291e-016
		,1.703493733e-016
		,1.701122271e-016
		,1.698875355e-016
		,1.696717683e-016
		,1.694628500e-016
		,1.692597603e-016
		,1.690621952e-016
		,1.688702403e-016
		,1.686840829e-016
		,1.685038159e-016
		,1.683293793e-016
		,1.681607074e-016
		,1.679982827e-016
		,1.678447966e-016
		,1.677103698e-016
		,1.676294396e-016
		,1.677148843e-016
		,1.683199147e-016
		,1.704338043e-016
		,1.761395751e-016
		,1.906885653e-016
		,2.175818328e-016
		,2.589386798e-016
		,3.259451526e-016
		,3.884411062e-016
		,4.223475398e-016
		,4.382841598e-016
		,4.499796136e-016
		,4.531733225e-016
		,4.549549139e-016
		,4.564891261e-016
		,4.580308091e-016
		,4.599711109e-016
		,4.629305031e-016
		,4.646163294e-016
		,4.655387045e-016
		,4.663148310e-016
		,4.670269879e-016
		,1.711004064e-016
		,1.707776812e-016
		,1.705014025e-016
		,1.702507479e-016
		,1.700164128e-016
		,1.697932192e-016
		,1.695780366e-016
		,1.693690823e-016
		,1.691655393e-016
		,1.689672233e-016
		,1.687742624e-016
		,1.685868257e-016
		,1.684049475e-016
		,1.682284918e-016
		,1.680573192e-016
		,1.678918474e-016
		,1.677347004e-016
		,1.675958511e-016
		,1.675091801e-016
		,1.675851782e-016
		,1.681672302e-016
		,1.702089351e-016
		,1.756549974e-016
		,1.885726318e-016
		,2.131127305e-016
		,2.460060370e-016
		,3.069366431e-016
		,3.697593659e-016
		,4.170082959e-016
		,4.361562247e-016
		,4.446023474e-016
		,4.544262754e-016
		,4.577466550e-016
		,4.595998909e-016
		,4.615553334e-016
		,4.633671916e-016
		,4.647392289e-016
		,4.668253208e-016
		,4.691272693e-016
		,4.699915623e-016
		,4.705146633e-016
		,1.709812299e-016
		,1.706696376e-016
		,1.704000657e-016
		,1.701536750e-016
		,1.699220420e-016
		,1.697005045e-016
		,1.694862935e-016
		,1.692778929e-016
		,1.690746712e-016
		,1.688765532e-016
		,1.686837088e-016
		,1.684962970e-016
		,1.683143137e-016
		,1.681375794e-016
		,1.679659283e-016
		,1.677997898e-016
		,1.676418795e-016
		,1.675024622e-016
		,1.674163056e-016
		,1.674966124e-016
		,1.680945405e-016
		,1.701770357e-016
		,1.757035440e-016
		,1.876106382e-016
		,2.106780940e-016
		,2.411850758e-016
		,2.901622839e-016
		,3.549922878e-016
		,4.100867741e-016
		,4.384968510e-016
		,4.477069922e-016
		,4.539567450e-016
		,4.616361182e-016
		,4.635232086e-016
		,4.644260359e-016
		,4.652049488e-016
		,4.660313767e-016
		,4.670654877e-016
		,4.690989733e-016
		,4.713406017e-016
		,4.721628934e-016
		,1.708649095e-016
		,1.705625550e-016
		,1.702983947e-016
		,1.700553310e-016
		,1.698257161e-016
		,1.696053437e-016
		,1.693917661e-016
		,1.691837020e-016
		,1.689806795e-016
		,1.687827115e-016
		,1.685899941e-016
		,1.684026675e-016
		,1.682206864e-016
		,1.680438314e-016
		,1.678719193e-016
		,1.677054099e-016
		,1.675471604e-016
		,1.674079073e-016
		,1.673239672e-016
		,1.674135113e-016
		,1.680423490e-016
		,1.702048574e-016
		,1.759213944e-016
		,1.876038704e-016
		,2.088632557e-016
		,2.386139544e-016
		,2.788986983e-016
		,3.451902659e-016
		,3.992346436e-016
		,4.376781394e-016
		,4.509454163e-016
		,4.547683544e-016
		,4.614300824e-016
		,4.662840791e-016
		,4.672223926e-016
		,4.677330133e-016
		,4.682424093e-016
		,4.688577211e-016
		,4.698323172e-016
		,4.720150616e-016
		,4.737657400e-016
		,1.707559814e-016
		,1.704609094e-016
		,1.702006992e-016
		,1.699597906e-016
		,1.697312224e-016
		,1.695111961e-016
		,1.692975521e-016
		,1.690892177e-016
		,1.688858589e-016
		,1.686875592e-016
		,1.684945277e-016
		,1.683068787e-016
		,1.681245238e-016
		,1.679472058e-016
		,1.677747296e-016
		,1.676075942e-016
		,1.674488184e-016
		,1.673096697e-016
		,1.672281983e-016
		,1.673282289e-016
		,1.679926371e-016
		,1.702469213e-016
		,1.761902594e-016
		,1.882326420e-016
		,2.070560964e-016
		,2.367450629e-016
		,2.720974017e-016
		,3.335858746e-016
		,3.895767624e-016
		,4.353544909e-016
		,4.537282698e-016
		,4.579743644e-016
		,4.602888493e-016
		,4.674011935e-016
		,4.696258777e-016
		,4.700726095e-016
		,4.703636726e-016
		,4.707181857e-016
		,4.712370928e-016
		,4.723950409e-016
		,4.746868672e-016
		,1.706604179e-016
		,1.703710490e-016
		,1.701135816e-016
		,1.698738193e-016
		,1.696454141e-016
		,1.694249360e-016
		,1.692104869e-016
		,1.690011823e-016
		,1.687968088e-016
		,1.685975075e-016
		,1.684034924e-016
		,1.682148490e-016
		,1.680314481e-016
		,1.678530007e-016
		,1.676793069e-016
		,1.675109140e-016
		,1.673510154e-016
		,1.672114411e-016
		,1.671321035e-016
		,1.672429328e-016
		,1.679452760e-016
		,1.702974606e-016
		,1.764839225e-016
		,1.888940484e-016
		,2.056877417e-016
		,2.353648235e-016
		,2.692578269e-016
		,3.204836147e-016
		,3.821510655e-016
		,4.293333975e-016
		,4.553724657e-016
		,4.614806083e-016
		,4.619862049e-016
		,4.661641418e-016
		,4.715504376e-016
		,4.723611106e-016
		,4.725182066e-016
		,4.726567131e-016
		,4.729013166e-016
		,4.734150187e-016
		,4.749650185e-016
		,1.705797585e-016
		,1.702952064e-016
		,1.700398963e-016
		,1.698008461e-016
		,1.695722557e-016
		,1.693510261e-016
		,1.691354943e-016
		,1.689249423e-016
		,1.687192585e-016
		,1.685186269e-016
		,1.683232569e-016
		,1.681332009e-016
		,1.679482896e-016
		,1.677682069e-016
		,1.675927549e-016
		,1.674225360e-016
		,1.672609298e-016
		,1.671203464e-016
		,1.670426284e-016
		,1.671639664e-016
		,1.679043044e-016
		,1.703528816e-016
		,1.767732794e-016
		,1.894742593e-016
		,2.055938229e-016
		,2.330992980e-016
		,2.669478701e-016
		,3.084403693e-016
		,3.747236265e-016
		,4.214627087e-016
		,4.561638438e-016
		,4.653492816e-016
		,4.656659069e-016
		,4.657752860e-016
		,4.718559341e-016
		,4.745098468e-016
		,4.746721842e-016
		,4.746279495e-016
		,4.746458963e-016
		,4.748293710e-016
		,4.754983795e-016
		,1.705106368e-016
		,1.702304311e-016
		,1.699770894e-016
		,1.697387156e-016
		,1.695100029e-016
		,1.692881488e-016
		,1.690717011e-016
		,1.688600859e-016
		,1.686532738e-016
		,1.684514757e-016
		,1.682548842e-016
		,1.680635111e-016
		,1.678771445e-016
		,1.676954414e-016
		,1.675182069e-016
		,1.673461008e-016
		,1.671826905e-016
		,1.670409816e-016
		,1.669647957e-016
		,1.670967375e-016
		,1.678753704e-016
		,1.704202405e-016
		,1.770682077e-016
		,1.899708957e-016
		,2.063412087e-016
		,2.304025141e-016
		,2.649199746e-016
		,2.989658340e-016
		,3.648430482e-016
		,4.139032981e-016
		,4.546241334e-016
		,4.690933513e-016
		,4.701724605e-016
		,4.683994960e-016
		,4.705353347e-016
		,4.760513486e-016
		,4.768304407e-016
		,4.766631177e-016
		,4.764681858e-016
		,4.763922224e-016
		,4.765516093e-016
		,1.704491756e-016
		,1.701728007e-016
		,1.699211981e-016
		,1.696834413e-016
		,1.694546757e-016
		,1.692323590e-016
		,1.690152176e-016
		,1.688028125e-016
		,1.685951624e-016
		,1.683924991e-016
		,1.681949854e-016
		,1.680025905e-016
		,1.678150537e-016
		,1.676320096e-016
		,1.674532692e-016
		,1.672795490e-016
		,1.671146055e-016
		,1.669720546e-016
		,1.668977133e-016
		,1.670407279e-016
		,1.678575549e-016
		,1.704985943e-016
		,1.773634378e-016
		,1.903693088e-016
		,2.070694524e-016
		,2.280744518e-016
		,2.630498103e-016
		,2.952063468e-016
		,3.500164704e-016
		,4.076930231e-016
		,4.486182897e-016
		,4.717348371e-016
		,4.746484545e-016
		,4.723782706e-016
		,4.706912760e-016
		,4.753271955e-016
		,4.787222376e-016
		,4.788158213e-016
		,4.785374696e-016
		,4.782782117e-016
		,4.781483872e-016
		,1.704000216e-016
		,1.701248289e-016
		,1.698733149e-016
		,1.696351511e-016
		,1.694055834e-016
		,1.691825468e-016
		,1.689644347e-016
		,1.687513303e-016
		,1.685428768e-016
		,1.683394197e-016
		,1.681410145e-016
		,1.679477200e-016
		,1.677590545e-016
		,1.675747590e-016
		,1.673946306e-016
		,1.672194452e-016
		,1.670531687e-016
		,1.669100267e-016
		,1.668378298e-016
		,1.669923841e-016
		,1.678462270e-016
		,1.705853346e-016
		,1.776546621e-016
		,1.906801645e-016
		,2.077407081e-016
		,2.272128324e-016
		,2.600648287e-016
		,2.925745134e-016
		,3.350805479e-016
		,4.003943853e-016
		,4.413332245e-016
		,4.732921156e-016
		,4.795551574e-016
		,4.774584340e-016
		,4.741281438e-016
		,4.740584499e-016
		,4.797050817e-016
		,4.809969136e-016
		,4.806191190e-016
		,4.801455434e-016
		,4.797774893e-016
		,1.704874873e-016
		,1.701711436e-016
		,1.698958264e-016
		,1.696448588e-016
		,1.694009367e-016
		,1.691727182e-016
		,1.689463648e-016
		,1.687317219e-016
		,1.685203571e-016
		,1.683138011e-016
		,1.681120214e-016
		,1.679162720e-016
		,1.677238760e-016
		,1.675366480e-016
		,1.673529514e-016
		,1.671745109e-016
		,1.670054924e-016
		,1.668606415e-016
		,1.667898726e-016
		,1.669558372e-016
		,1.678449522e-016
		,1.706857485e-016
		,1.779486022e-016
		,1.909424535e-016
		,2.083887806e-016
		,2.284077535e-016
		,2.555518599e-016
		,2.902753312e-016
		,3.220246152e-016
		,3.908785459e-016
		,4.348674384e-016
		,4.713063713e-016
		,4.838296698e-016
		,4.825058320e-016
		,4.785021014e-016
		,4.753831435e-016
		,4.779373534e-016
		,4.824930315e-016
		,4.826517246e-016
		,4.820697879e-016
		,4.815090099e-016
		,1.721615862e-016
		,1.712080521e-016
		,1.706934535e-016
		,1.702877885e-016
		,1.698894407e-016
		,1.695913239e-016
		,1.692857594e-016
		,1.690522676e-016
		,1.688229163e-016
		,1.685846768e-016
		,1.683602667e-016
		,1.681334886e-016
		,1.679147388e-016
		,1.677094084e-016
		,1.674983615e-016
		,1.672925524e-016
		,1.670985405e-016
		,1.669319120e-016
		,1.668506228e-016
		,1.670203995e-016
		,1.679381481e-016
		,1.708798022e-016
		,1.783163504e-016
		,1.912090973e-016
		,2.090146319e-016
		,2.294948844e-016
		,2.512184138e-016
		,2.877822820e-016
		,3.158776201e-016
		,3.736467199e-016
		,4.283008006e-016
		,4.637053821e-016
		,4.865102121e-016
		,4.875899943e-016
		,4.834390200e-016
		,4.789784732e-016
		,4.766489912e-016
		,4.813322695e-016
		,4.843014886e-016
		,4.839990369e-016
		,4.833257064e-016
		,1.806936722e-016
		,1.759938180e-016
		,1.748641728e-016
		,1.736845189e-016
		,1.726838090e-016
		,1.719207959e-016
		,1.712614505e-016
		,1.708211411e-016
		,1.705836621e-016
		,1.702747320e-016
		,1.699830218e-016
		,1.694568524e-016
		,1.692076468e-016
		,1.689301252e-016
		,1.686173596e-016
		,1.682835955e-016
		,1.679595582e-016
		,1.676447520e-016
		,1.674833061e-016
		,1.675627894e-016
		,1.684606947e-016
		,1.715163745e-016
		,1.791252688e-016
		,1.917751720e-016
		,2.099531565e-016
		,2.307253107e-016
		,2.480924233e-016
		,2.823582730e-016
		,3.114564674e-016
		,3.486564071e-016
		,4.145377706e-016
		,4.512841906e-016
		,4.837057438e-016
		,4.920321557e-016
		,4.893892247e-016
		,4.844192858e-016
		,4.799110622e-016
		,4.787254999e-016
		,4.843933501e-016
		,4.864265421e-016
		,4.858705887e-016
		,1.796190962e-016
		,1.791284914e-016
		,1.788837649e-016
		,1.787908025e-016
		,1.788234330e-016
		,1.789848085e-016
		,1.793033091e-016
		,1.798505508e-016
		,1.808005202e-016
		,1.825984013e-016
		,1.864075563e-016
		,1.946399296e-016
		,2.088571999e-016
		,2.264904775e-016
		,2.392170196e-016
		,2.491353112e-016
		,2.561039150e-016
		,2.611771816e-016
		,2.633289891e-016
		,2.690376996e-016
		,2.767631529e-016
		,2.800961231e-016
		,2.844376045e-016
		,2.953841806e-016
		,3.115426429e-016
		,3.291738593e-016
		,3.455974605e-016
		,3.593505500e-016
		,3.710947766e-016
		,3.814692318e-016
		,3.910821356e-016
		,4.001152596e-016
		,4.074648319e-016
		,4.135422518e-016
		,4.187965351e-016
		,4.233239261e-016
		,4.272206626e-016
		,4.305944958e-016
		,4.335253438e-016
		,4.360464966e-016
		,4.381996141e-016
		,1.778997735e-016
		,1.774626534e-016
		,1.772157238e-016
		,1.770837345e-016
		,1.770380814e-016
		,1.770671945e-016
		,1.771692312e-016
		,1.773522130e-016
		,1.776390458e-016
		,1.780818872e-016
		,1.788021708e-016
		,1.801084694e-016
		,1.828419141e-016
		,1.890282237e-016
		,2.015982115e-016
		,2.205596846e-016
		,2.369041230e-016
		,2.490692828e-016
		,2.556764917e-016
		,2.633602597e-016
		,2.692359432e-016
		,2.775298673e-016
		,2.900567394e-016
		,3.038129120e-016
		,3.171374750e-016
		,3.318810763e-016
		,3.476922371e-016
		,3.631116118e-016
		,3.773890892e-016
		,3.902352875e-016
		,4.002502615e-016
		,4.082800893e-016
		,4.149041927e-016
		,4.204403238e-016
		,4.251539193e-016
		,4.292044962e-016
		,4.326840827e-016
		,4.356812548e-016
		,4.382883005e-016
		,4.405825159e-016
		,4.426171728e-016
		,1.765571459e-016
		,1.761467875e-016
		,1.758843850e-016
		,1.757130337e-016
		,1.756102459e-016
		,1.755650537e-016
		,1.755715396e-016
		,1.756273074e-016
		,1.757338437e-016
		,1.758982668e-016
		,1.761373777e-016
		,1.764875811e-016
		,1.770320148e-016
		,1.779814245e-016
		,1.799186495e-016
		,1.843862055e-016
		,1.945489214e-016
		,2.129656960e-016
		,2.330400946e-016
		,2.490755760e-016
		,2.581297052e-016
		,2.697425004e-016
		,2.834746601e-016
		,3.003900218e-016
		,3.211190397e-016
		,3.415840292e-016
		,3.590929746e-016
		,3.756215958e-016
		,3.888254813e-016
		,3.996529566e-016
		,4.082811164e-016
		,4.151889390e-016
		,4.209173175e-016
		,4.257622457e-016
		,4.298942926e-016
		,4.334719594e-016
		,4.366255257e-016
		,4.394330242e-016
		,4.419383957e-016
		,4.441787254e-016
		,4.461889250e-016
		,1.754649727e-016
		,1.750932888e-016
		,1.748331696e-016
		,1.746396770e-016
		,1.744947192e-016
		,1.743895712e-016
		,1.743198295e-016
		,1.742838400e-016
		,1.742821131e-016
		,1.743170864e-016
		,1.743932185e-016
		,1.745177766e-016
		,1.747032560e-016
		,1.749739160e-016
		,1.753839283e-016
		,1.760713524e-016
		,1.774251586e-016
		,1.805442126e-016
		,1.881731238e-016
		,2.043755488e-016
		,2.274737923e-016
		,2.504788332e-016
		,2.691172415e-016
		,2.919507480e-016
		,3.194051250e-016
		,3.462328270e-016
		,3.683067051e-016
		,3.852999998e-016
		,3.980425539e-016
		,4.080590445e-016
		,4.163479093e-016
		,4.230531289e-016
		,4.284763587e-016
		,4.328985407e-016
		,4.366225341e-016
		,4.398689859e-016
		,4.427202077e-016
		,4.452350663e-016
		,4.474685725e-016
		,4.494664561e-016
		,4.512650144e-016
		,1.743889119e-016
		,1.740680764e-016
		,1.738343777e-016
		,1.736507344e-016
		,1.735012958e-016
		,1.733777556e-016
		,1.732754408e-016
		,1.731921063e-016
		,1.731274703e-016
		,1.730829377e-016
		,1.730613725e-016
		,1.730669296e-016
		,1.731050491e-016
		,1.731828657e-016
		,1.733106575e-016
		,1.735060848e-016
		,1.738065490e-016
		,1.743069021e-016
		,1.752790932e-016
		,1.775472644e-016
		,1.834934307e-016
		,1.984115770e-016
		,2.278131349e-016
		,2.690427253e-016
		,3.123183942e-016
		,3.491592719e-016
		,3.764005809e-016
		,3.954072331e-016
		,4.087604955e-016
		,4.184724122e-016
		,4.258192368e-016
		,4.315785866e-016
		,4.362315197e-016
		,4.400853137e-016
		,4.433432321e-016
		,4.461442751e-016
		,4.485864048e-016
		,4.507405555e-016
		,4.526593603e-016
		,4.543827501e-016
		,4.559416397e-016
		,1.732944207e-016
		,1.729919162e-016
		,1.727636387e-016
		,1.725792451e-016
		,1.724253046e-016
		,1.722942514e-016
		,1.721812538e-016
		,1.720832556e-016
		,1.719985997e-016
		,1.719267912e-016
		,1.718682901e-016
		,1.718243386e-016
		,1.717968691e-016
		,1.717885664e-016
		,1.718031960e-016
		,1.718464855e-016
		,1.719284285e-016
		,1.720698335e-016
		,1.723222782e-016
		,1.728303909e-016
		,1.740402625e-016
		,1.774845780e-016
		,1.876033620e-016
		,2.161066841e-016
		,2.752218816e-016
		,3.403883135e-016
		,3.859948371e-016
		,4.083915421e-016
		,4.203114676e-016
		,4.283191763e-016
		,4.343024493e-016
		,4.390517749e-016
		,4.431349245e-016
		,4.467272503e-016
		,4.495177103e-016
		,4.519007875e-016
		,4.540614129e-016
		,4.560610806e-016
		,4.578266489e-016
		,4.593160371e-016
		,4.606148736e-016
		,1.723225357e-016
		,1.720203375e-016
		,1.717796970e-016
		,1.715751170e-016
		,1.713953520e-016
		,1.712342365e-016
		,1.710880844e-016
		,1.709548420e-016
		,1.708336731e-016
		,1.707246214e-016
		,1.706282773e-016
		,1.705454765e-016
		,1.704770827e-016
		,1.704239203e-016
		,1.703869454e-016
		,1.703678803e-016
		,1.703710080e-016
		,1.704085047e-016
		,1.705170610e-016
		,1.708100414e-016
		,1.716323469e-016
		,1.739473593e-016
		,1.806533543e-016
		,1.976380790e-016
		,2.345786201e-016
		,3.059477421e-016
		,3.740395288e-016
		,4.114120527e-016
		,4.313561484e-016
		,4.386301419e-016
		,4.426757010e-016
		,4.459009673e-016
		,4.487150776e-016
		,4.512389401e-016
		,4.537280704e-016
		,4.564060335e-016
		,4.582303534e-016
		,4.597066796e-016
		,4.610716640e-016
		,4.623208275e-016
		,4.635030353e-016
		,1.715420208e-016
		,1.712300871e-016
		,1.709706952e-016
		,1.707415855e-016
		,1.705328611e-016
		,1.703390690e-016
		,1.701569637e-016
		,1.699847640e-016
		,1.698217658e-016
		,1.696680132e-016
		,1.695239824e-016
		,1.693903061e-016
		,1.692675920e-016
		,1.691563831e-016
		,1.690573374e-016
		,1.689718630e-016
		,1.689040176e-016
		,1.688665239e-016
		,1.689003469e-016
		,1.691377010e-016
		,1.699910858e-016
		,1.726164204e-016
		,1.793821464e-016
		,1.951723641e-016
		,2.248791329e-016
		,2.679434347e-016
		,3.424894273e-016
		,4.028569506e-016
		,4.289131698e-016
		,4.405789579e-016
		,4.496164795e-016
		,4.523874887e-016
		,4.542475893e-016
		,4.559772016e-016
		,4.576415426e-016
		,4.592394281e-016
		,4.608900770e-016
		,4.631329070e-016
		,4.648823333e-016
		,4.658480555e-016
		,4.666576717e-016
		,1.711736514e-016
		,1.708558500e-016
		,1.705836950e-016
		,1.703371426e-016
		,1.701071949e-016
		,1.698888489e-016
		,1.696791127e-016
		,1.694763326e-016
		,1.692798200e-016
		,1.690895231e-016
		,1.689057129e-016
		,1.687287182e-016
		,1.685587610e-016
		,1.683959366e-016
		,1.682404136e-016
		,1.680930965e-016
		,1.679576282e-016
		,1.678468264e-016
		,1.678039610e-016
		,1.679719840e-016
		,1.688012226e-016
		,1.715358050e-016
		,1.785565975e-016
		,1.924405367e-016
		,2.182949911e-016
		,2.517762132e-016
		,3.049481526e-016
		,3.770537918e-016
		,4.261546320e-016
		,4.440528201e-016
		,4.486680498e-016
		,4.554447912e-016
		,4.599477310e-016
		,4.610845576e-016
		,4.619654579e-016
		,4.628806506e-016
		,4.638181383e-016
		,4.647600579e-016
		,4.657621355e-016
		,4.672670677e-016
		,4.692780672e-016
		,1.710357904e-016
		,1.707263908e-016
		,1.704578629e-016
		,1.702120765e-016
		,1.699808618e-016
		,1.697596767e-016
		,1.695458282e-016
		,1.693378547e-016
		,1.691351647e-016
		,1.689377109e-016
		,1.687456815e-016
		,1.685592494e-016
		,1.683784247e-016
		,1.682030509e-016
		,1.680330084e-016
		,1.678688391e-016
		,1.677135906e-016
		,1.675786459e-016
		,1.675027412e-016
		,1.676133637e-016
		,1.683107670e-016
		,1.707010160e-016
		,1.770149483e-016
		,1.898848035e-016
		,2.110465657e-016
		,2.427015615e-016
		,2.827994214e-016
		,3.498239412e-016
		,4.104458896e-016
		,4.450464058e-016
		,4.534360364e-016
		,4.544252053e-016
		,4.565707116e-016
		,4.631058676e-016
		,4.653868373e-016
		,4.663514725e-016
		,4.675169761e-016
		,4.693096914e-016
		,4.708624959e-016
		,4.714342650e-016
		,4.718275172e-016
		,1.709220097e-016
		,1.706219462e-016
		,1.703588820e-016
		,1.701163964e-016
		,1.698870861e-016
		,1.696668627e-016
		,1.694533520e-016
		,1.692453233e-016
		,1.690423380e-016
		,1.688444273e-016
		,1.686517936e-016
		,1.684645759e-016
		,1.682827260e-016
		,1.681060252e-016
		,1.679343030e-016
		,1.677680623e-016
		,1.676102966e-016
		,1.674722042e-016
		,1.673917035e-016
		,1.674925589e-016
		,1.681592444e-016
		,1.704370348e-016
		,1.764792469e-016
		,1.889284452e-016
		,2.066965066e-016
		,2.372895313e-016
		,2.742549251e-016
		,3.218822662e-016
		,3.915701045e-016
		,4.358127264e-016
		,4.605290845e-016
		,4.642035734e-016
		,4.629510148e-016
		,4.634454861e-016
		,4.691515257e-016
		,4.714450261e-016
		,4.717717405e-016
		,4.719919659e-016
		,4.722627199e-016
		,4.725801958e-016
		,4.729301480e-016
		,1.708100764e-016
		,1.705180339e-016
		,1.702596620e-016
		,1.700200421e-016
		,1.697924478e-016
		,1.695731959e-016
		,1.693601991e-016
		,1.691524344e-016
		,1.689495981e-016
		,1.687517883e-016
		,1.685592163e-016
		,1.683719908e-016
		,1.681900169e-016
		,1.680130345e-016
		,1.678408555e-016
		,1.676740052e-016
		,1.675155810e-016
		,1.673770909e-016
		,1.672973640e-016
		,1.674027427e-016
		,1.680838418e-016
		,1.703825136e-016
		,1.764582089e-016
		,1.888599598e-016
		,2.053993743e-016
		,2.326988870e-016
		,2.689405254e-016
		,3.077175801e-016
		,3.774782106e-016
		,4.286165744e-016
		,4.607858186e-016
		,4.675030945e-016
		,4.668327656e-016
		,4.654094885e-016
		,4.662797427e-016
		,4.718385123e-016
		,4.738953638e-016
		,4.741645278e-016
		,4.742990532e-016
		,4.744658199e-016
		,4.746729035e-016
		,1.707010335e-016
		,1.704154018e-016
		,1.701605646e-016
		,1.699229254e-016
		,1.696963555e-016
		,1.694775330e-016
		,1.692646266e-016
		,1.690567955e-016
		,1.688538505e-016
		,1.686559394e-016
		,1.684632710e-016
		,1.682759178e-016
		,1.680937377e-016
		,1.679164337e-016
		,1.677438080e-016
		,1.675764271e-016
		,1.674175454e-016
		,1.672791641e-016
		,1.672017287e-016
		,1.673167436e-016
		,1.680300708e-016
		,1.704065614e-016
		,1.766672291e-016
		,1.892690277e-016
		,2.057861120e-016
		,2.292521382e-016
		,2.655552690e-016
		,3.021683188e-016
		,3.583362161e-016
		,4.205048177e-016
		,4.582755728e-016
		,4.714508361e-016
		,4.715024412e-016
		,4.693602928e-016
		,4.679221435e-016
		,4.699575041e-016
		,4.750798825e-016
		,4.762432438e-016
		,4.763250885e-016
		,4.763352101e-016
		,4.763815546e-016
		,1.706009102e-016
		,1.703200930e-016
		,1.700675449e-016
		,1.698308408e-016
		,1.696043869e-016
		,1.693851876e-016
		,1.691716439e-016
		,1.689630783e-016
		,1.687593994e-016
		,1.685607927e-016
		,1.683674564e-016
		,1.681794245e-016
		,1.679965094e-016
		,1.678183823e-016
		,1.676448427e-016
		,1.674765078e-016
		,1.673168103e-016
		,1.671783227e-016
		,1.671033996e-016
		,1.672297689e-016
		,1.679814766e-016
		,1.704514066e-016
		,1.769296056e-016
		,1.897301350e-016
		,2.063507985e-016
		,2.267641095e-016
		,2.630990869e-016
		,2.983753803e-016
		,3.419278839e-016
		,4.130091875e-016
		,4.518126022e-016
		,4.741046924e-016
		,4.760181507e-016
		,4.735815183e-016
		,4.711844274e-016
		,4.702334100e-016
		,4.739250405e-016
		,4.777980093e-016
		,4.782742067e-016
		,4.782074137e-016
		,4.781216981e-016
		,1.705147624e-016
		,1.702376783e-016
		,1.699865917e-016
		,1.697501215e-016
		,1.695231541e-016
		,1.693029905e-016
		,1.690882429e-016
		,1.688783797e-016
		,1.686733932e-016
		,1.684734965e-016
		,1.682788721e-016
		,1.680895153e-016
		,1.679051977e-016
		,1.677255662e-016
		,1.675504261e-016
		,1.673804554e-016
		,1.672192795e-016
		,1.670800889e-016
		,1.670072627e-016
		,1.671451830e-016
		,1.679368120e-016
		,1.705064900e-016
		,1.772147711e-016
		,1.901631810e-016
		,2.070154521e-016
		,2.266908948e-016
		,2.593968200e-016
		,2.953264595e-016
		,3.302405057e-016
		,4.020891320e-016
		,4.450595317e-016
		,4.749231882e-016
		,4.803017808e-016
		,4.779954873e-016
		,4.749088511e-016
		,4.726955610e-016
		,4.727987204e-016
		,4.776672116e-016
		,4.798930786e-016
		,4.799408297e-016
		,4.797635140e-016
		,1.704420377e-016
		,1.701682142e-016
		,1.699183386e-016
		,1.696819627e-016
		,1.694544041e-016
		,1.692332313e-016
		,1.690172450e-016
		,1.688060397e-016
		,1.685996744e-016
		,1.683983759e-016
		,1.682023024e-016
		,1.680114068e-016
		,1.678254207e-016
		,1.676439701e-016
		,1.674668705e-016
		,1.672948663e-016
		,1.671317849e-016
		,1.669914666e-016
		,1.669203976e-016
		,1.670698960e-016
		,1.679011207e-016
		,1.705739714e-016
		,1.775088649e-016
		,1.905294239e-016
		,2.076981145e-016
		,2.279478385e-016
		,2.550179288e-016
		,2.926822845e-016
		,3.256098646e-016
		,3.854466402e-016
		,4.402644152e-016
		,4.723691722e-016
		,4.841316519e-016
		,4.824889646e-016
		,4.789259855e-016
		,4.759087925e-016
		,4.741159205e-016
		,4.759503267e-016
		,4.805966309e-016
		,4.814993946e-016
		,4.813130647e-016
		,1.703786160e-016
		,1.701078015e-016
		,1.698591046e-016
		,1.696229154e-016
		,1.693949384e-016
		,1.691729866e-016
		,1.689560266e-016
		,1.687437634e-016
		,1.685363042e-016
		,1.683338773e-016
		,1.681366064e-016
		,1.679443980e-016
		,1.677569416e-016
		,1.675738430e-016
		,1.673949290e-016
		,1.672210103e-016
		,1.670561203e-016
		,1.669147563e-016
		,1.668455895e-016
		,1.670070210e-016
		,1.678764445e-016
		,1.706569435e-016
		,1.778104390e-016
		,1.908445382e-016
		,2.083700438e-016
		,2.291073125e-016
		,2.512261284e-016
		,2.902746707e-016
		,3.225285131e-016
		,3.688066161e-016
		,4.355538643e-016
		,4.677460174e-016
		,4.872667695e-016
		,4.870191880e-016
		,4.830021651e-016
		,4.792558729e-016
		,4.765251724e-016
		,4.754719928e-016
		,4.791144607e-016
		,4.824761220e-016
		,4.827023679e-016
		,1.703212323e-016
		,1.700529386e-016
		,1.698052540e-016
		,1.695692328e-016
		,1.693408965e-016
		,1.691183298e-016
		,1.689005967e-016
		,1.686875322e-016
		,1.684792519e-016
		,1.682759738e-016
		,1.680777875e-016
		,1.678845492e-016
		,1.676959020e-016
		,1.675114420e-016
		,1.673310034e-016
		,1.671554681e-016
		,1.669890783e-016
		,1.668469976e-016
		,1.667801675e-016
		,1.669541683e-016
		,1.678609996e-016
		,1.707524347e-016
		,1.781130911e-016
		,1.911195309e-016
		,2.090152169e-016
		,2.301491445e-016
		,2.486413778e-016
		,2.873002564e-016
		,3.196045075e-016
		,3.535980099e-016
		,4.275783910e-016
		,4.625837518e-016
		,4.885234403e-016
		,4.918170084e-016
		,4.880259013e-016
		,4.835946942e-016
		,4.801103374e-016
		,4.777606667e-016
		,4.779341386e-016
		,4.825850466e-016
		,4.843571339e-016
		,1.702782346e-016
		,1.700076349e-016
		,1.697593310e-016
		,1.695224008e-016
		,1.692928114e-016
		,1.690692055e-016
		,1.688503313e-016
		,1.686364224e-016
		,1.684273298e-016
		,1.682231595e-016
		,1.680240701e-016
		,1.678297619e-016
		,1.676399325e-016
		,1.674541663e-016
		,1.672722267e-016
		,1.670951482e-016
		,1.669273654e-016
		,1.667847340e-016
		,1.667205070e-016
		,1.669075560e-016
		,1.678512754e-016
		,1.708534172e-016
		,1.784038165e-016
		,1.913519103e-016
		,2.096056303e-016
		,2.310532039e-016
		,2.498817628e-016
		,2.810238406e-016
		,3.168648861e-016
		,3.454837757e-016
		,4.126085965e-016
		,4.599292478e-016
		,4.871423928e-016
		,4.966024545e-016
		,4.929710759e-016
		,4.877937344e-016
		,4.835863557e-016
		,4.805008838e-016
		,4.786585539e-016
		,4.805545637e-016
		,4.848648631e-016
		,1.704200559e-016
		,1.700652824e-016
		,1.697984618e-016
		,1.695440065e-016
		,1.693003976e-016
		,1.690668057e-016
		,1.688400651e-016
		,1.686217474e-016
		,1.684098673e-016
		,1.682024587e-016
		,1.680002591e-016
		,1.678008483e-016
		,1.676080990e-016
		,1.674192449e-016
		,1.672333598e-016
		,1.670524857e-016
		,1.668814074e-016
		,1.667366302e-016
		,1.666739610e-016
		,1.668739416e-016
		,1.678547681e-016
		,1.709701626e-016
		,1.786975287e-016
		,1.915894824e-016
		,2.101981910e-016
		,2.319133853e-016
		,2.513819018e-016
		,2.750953769e-016
		,3.142052552e-016
		,3.425668466e-016
		,3.928063592e-016
		,4.557729087e-016
		,4.828660160e-016
		,5.003253187e-016
		,4.980017288e-016
		,4.924574782e-016
		,4.875315632e-016
		,4.837641127e-016
		,4.809753885e-016
		,4.797275474e-016
		,4.831433682e-016
		,1.725694751e-016
		,1.711749391e-016
		,1.707375537e-016
		,1.702857973e-016
		,1.699100101e-016
		,1.695535916e-016
		,1.692538255e-016
		,1.689784033e-016
		,1.687593828e-016
		,1.685295255e-016
		,1.683013765e-016
		,1.680451316e-016
		,1.678368158e-016
		,1.676288490e-016
		,1.674204786e-016
		,1.672073300e-016
		,1.670067710e-016
		,1.668362699e-016
		,1.667597954e-016
		,1.669601034e-016
		,1.679673570e-016
		,1.711881859e-016
		,1.790461155e-016
		,1.918650209e-016
		,2.107740259e-016
		,2.326689720e-016
		,2.526435784e-016
		,2.695021820e-016
		,3.111348228e-016
		,3.393354612e-016
		,3.723789016e-016
		,4.469408862e-016
		,4.772865786e-016
		,5.005241805e-016
		,5.026837311e-016
		,4.973094221e-016
		,4.916155134e-016
		,4.871113730e-016
		,4.837171723e-016
		,4.812255894e-016
		,4.806707904e-016
		,1.799339564e-016
		,1.794552651e-016
		,1.792176827e-016
		,1.791308636e-016
		,1.791707526e-016
		,1.793419476e-016
		,1.796739932e-016
		,1.802399006e-016
		,1.812163962e-016
		,1.830547461e-016
		,1.869289307e-016
		,1.953204485e-016
		,2.097136997e-016
		,2.277835859e-016
		,2.410113101e-016
		,2.513686069e-016
		,2.579606011e-016
		,2.641998077e-016
		,2.652358044e-016
		,2.692544171e-016
		,2.776537260e-016
		,2.848078096e-016
		,2.886975336e-016
		,2.985114720e-016
		,3.121603811e-016
		,3.292513081e-016
		,3.459856867e-016
		,3.602928855e-016
		,3.722461525e-016
		,3.824774253e-016
		,3.915758571e-016
		,4.003470901e-016
		,4.076663007e-016
		,4.135301178e-016
		,4.186039293e-016
		,4.230746009e-016
		,4.269938573e-016
		,4.304144965e-016
		,4.334102433e-016
		,4.360553518e-016
		,4.384059971e-016
		,1.782229367e-016
		,1.778108555e-016
		,1.775818688e-016
		,1.774626389e-016
		,1.774258332e-016
		,1.774613614e-016
		,1.775691491e-016
		,1.777591366e-016
		,1.780561938e-016
		,1.785146353e-016
		,1.792589971e-016
		,1.806040001e-016
		,1.834027713e-016
		,1.897299721e-016
		,2.024873809e-016
		,2.218687669e-016
		,2.387322126e-016
		,2.514988987e-016
		,2.580861930e-016
		,2.666604440e-016
		,2.728918558e-016
		,2.787698165e-016
		,2.901904889e-016
		,3.052523043e-016
		,3.205018359e-016
		,3.346856375e-016
		,3.489638628e-016
		,3.636654349e-016
		,3.772098574e-016
		,3.897482726e-016
		,3.998275885e-016
		,4.079364140e-016
		,4.146836030e-016
		,4.203341327e-016
		,4.250958696e-016
		,4.291465733e-016
		,4.326343370e-016
		,4.356669496e-016
		,4.383149648e-016
		,4.406379430e-016
		,4.426923223e-016
		,1.768480066e-016
		,1.764644351e-016
		,1.762268023e-016
		,1.760792338e-016
		,1.759988695e-016
		,1.759739371e-016
		,1.759978015e-016
		,1.760678245e-016
		,1.761859828e-016
		,1.763606964e-016
		,1.766108238e-016
		,1.769755626e-016
		,1.775419997e-016
		,1.785276023e-016
		,1.805281639e-016
		,1.851246744e-016
		,1.954905175e-016
		,2.143173228e-016
		,2.350301134e-016
		,2.516300289e-016
		,2.612900243e-016
		,2.727731113e-016
		,2.875418903e-016
		,3.035490050e-016
		,3.226134794e-016
		,3.431195987e-016
		,3.608553135e-016
		,3.758702041e-016
		,3.885013784e-016
		,3.989630017e-016
		,4.077508670e-016
		,4.148608002e-016
		,4.206114660e-016
		,4.254095654e-016
		,4.295208687e-016
		,4.330971178e-016
		,4.362396163e-016
		,4.390265018e-016
		,4.415237605e-016
		,4.437752698e-016
		,4.458099541e-016
		,1.757808200e-016
		,1.754216950e-016
		,1.751732493e-016
		,1.749925741e-016
		,1.748624463e-016
		,1.747744932e-016
		,1.747242704e-016
		,1.747096871e-016
		,1.747304445e-016
		,1.747879371e-016
		,1.748856390e-016
		,1.750303074e-016
		,1.752348526e-016
		,1.755253049e-016
		,1.759595409e-016
		,1.766826641e-016
		,1.780975353e-016
		,1.813370097e-016
		,1.891742679e-016
		,2.057594055e-016
		,2.294323298e-016
		,2.530637371e-016
		,2.728454699e-016
		,2.950376881e-016
		,3.222199953e-016
		,3.486536794e-016
		,3.699676824e-016
		,3.862006190e-016
		,3.989882066e-016
		,4.087371198e-016
		,4.162190119e-016
		,4.226527304e-016
		,4.280844160e-016
		,4.326007500e-016
		,4.363663245e-016
		,4.395528248e-016
		,4.423439416e-016
		,4.448398771e-016
		,4.470773636e-016
		,4.490878654e-016
		,4.509020589e-016
		,1.748345809e-016
		,1.745162225e-016
		,1.742814002e-016
		,1.740955672e-016
		,1.739443079e-016
		,1.738203578e-016
		,1.737198975e-016
		,1.736414005e-016
		,1.735851633e-016
		,1.735529850e-016
		,1.735478693e-016
		,1.735737823e-016
		,1.736356171e-016
		,1.737396967e-016
		,1.738955343e-016
		,1.741206893e-016
		,1.744541816e-016
		,1.749961168e-016
		,1.760313161e-016
		,1.784115139e-016
		,1.845568840e-016
		,1.997172368e-016
		,2.291496038e-016
		,2.701021430e-016
		,3.130420326e-016
		,3.496362346e-016
		,3.767221135e-016
		,3.956339626e-016
		,4.089278635e-016
		,4.186007911e-016
		,4.259207552e-016
		,4.316608302e-016
		,4.362994627e-016
		,4.401423534e-016
		,4.433917697e-016
		,4.461860561e-016
		,4.486227290e-016
		,4.507724106e-016
		,4.526875106e-016
		,4.544077959e-016
		,4.559640594e-016
		,1.738218431e-016
		,1.735431984e-016
		,1.733326567e-016
		,1.731613139e-016
		,1.730162894e-016
		,1.728904711e-016
		,1.727796167e-016
		,1.726814458e-016
		,1.725952446e-016
		,1.725215827e-016
		,1.724620506e-016
		,1.724190337e-016
		,1.723955700e-016
		,1.723953571e-016
		,1.724230175e-016
		,1.724849160e-016
		,1.725914455e-016
		,1.727637166e-016
		,1.730540322e-016
		,1.736094683e-016
		,1.748666043e-016
		,1.783465237e-016
		,1.883651477e-016
		,2.151212972e-016
		,2.719585579e-016
		,3.373338226e-016
		,3.825270601e-016
		,4.082783011e-016
		,4.211047980e-016
		,4.292323027e-016
		,4.351663849e-016
		,4.398095720e-016
		,4.436015559e-016
		,4.468115722e-016
		,4.497020324e-016
		,4.523957422e-016
		,4.545182450e-016
		,4.563372046e-016
		,4.579957033e-016
		,4.595105925e-016
		,4.609103978e-016
		,1.728425923e-016
		,1.725664130e-016
		,1.723479853e-016
		,1.721640760e-016
		,1.720044423e-016
		,1.718634262e-016
		,1.717375519e-016
		,1.716247300e-016
		,1.715238704e-016
		,1.714345921e-016
		,1.713569708e-016
		,1.712913471e-016
		,1.712382362e-016
		,1.711983832e-016
		,1.711730310e-016
		,1.711646053e-016
		,1.711784937e-016
		,1.712282528e-016
		,1.713518355e-016
		,1.716625633e-016
		,1.725006180e-016
		,1.748117410e-016
		,1.810541572e-016
		,1.971792972e-016
		,2.307199934e-016
		,2.929194500e-016
		,3.667904031e-016
		,4.104207890e-016
		,4.291146295e-016
		,4.410089555e-016
		,4.454947952e-016
		,4.483883306e-016
		,4.508604156e-016
		,4.530731678e-016
		,4.550681074e-016
		,4.568806410e-016
		,4.585894620e-016
		,4.604967005e-016
		,4.622576039e-016
		,4.634807841e-016
		,4.645259569e-016
		,1.719731390e-016
		,1.716932172e-016
		,1.714616985e-016
		,1.712587199e-016
		,1.710754213e-016
		,1.709069350e-016
		,1.707504136e-016
		,1.706043674e-016
		,1.704683063e-016
		,1.703424263e-016
		,1.702273070e-016
		,1.701236507e-016
		,1.700321095e-016
		,1.699532468e-016
		,1.698877073e-016
		,1.698368240e-016
		,1.698044579e-016
		,1.698028102e-016
		,1.698712350e-016
		,1.701364145e-016
		,1.709923084e-016
		,1.735437427e-016
		,1.800961810e-016
		,1.940736066e-016
		,2.224332658e-016
		,2.611663527e-016
		,3.257360746e-016
		,3.982159035e-016
		,4.335918340e-016
		,4.431609400e-016
		,4.486485220e-016
		,4.554350103e-016
		,4.574599814e-016
		,4.587997343e-016
		,4.600926448e-016
		,4.613410147e-016
		,4.625236994e-016
		,4.636379856e-016
		,4.647061898e-016
		,4.658662253e-016
		,4.675099263e-016
		,1.712923077e-016
		,1.710010605e-016
		,1.707513602e-016
		,1.705257144e-016
		,1.703162681e-016
		,1.701187114e-016
		,1.699305663e-016
		,1.697505898e-016
		,1.695784203e-016
		,1.694142595e-016
		,1.692585714e-016
		,1.691118405e-016
		,1.689744350e-016
		,1.688466173e-016
		,1.687287796e-016
		,1.686221613e-016
		,1.685310183e-016
		,1.684696041e-016
		,1.684852397e-016
		,1.687331385e-016
		,1.696999482e-016
		,1.727205505e-016
		,1.803839908e-016
		,1.953963690e-016
		,2.172079973e-016
		,2.505639911e-016
		,2.931294279e-016
		,3.608584187e-016
		,4.223852674e-016
		,4.501654704e-016
		,4.550088243e-016
		,4.552629164e-016
		,4.584297451e-016
		,4.637865482e-016
		,4.650497883e-016
		,4.656976279e-016
		,4.663500024e-016
		,4.670264550e-016
		,4.677040901e-016
		,4.683677059e-016
		,4.690154528e-016
		,1.709904013e-016
		,1.706937717e-016
		,1.704334700e-016
		,1.701936664e-016
		,1.699671902e-016
		,1.697500855e-016
		,1.695400805e-016
		,1.693360357e-016
		,1.691375986e-016
		,1.689448844e-016
		,1.687581824e-016
		,1.685777279e-016
		,1.684035862e-016
		,1.682356841e-016
		,1.680740630e-016
		,1.679196202e-016
		,1.677763535e-016
		,1.676586690e-016
		,1.676157746e-016
		,1.678112977e-016
		,1.687593794e-016
		,1.718204413e-016
		,1.795189442e-016
		,1.941603121e-016
		,2.123039156e-016
		,2.404643440e-016
		,2.795157837e-016
		,3.229923724e-016
		,3.975905046e-016
		,4.444898698e-016
		,4.620348059e-016
		,4.628649349e-016
		,4.613504773e-016
		,4.607225040e-016
		,4.635415592e-016
		,4.685961512e-016
		,4.701252325e-016
		,4.710714657e-016
		,4.726730058e-016
		,4.749525009e-016
		,4.755530542e-016
		,1.708675608e-016
		,1.705772100e-016
		,1.703196129e-016
		,1.700803972e-016
		,1.698530368e-016
		,1.696339479e-016
		,1.694211074e-016
		,1.692135372e-016
		,1.690109645e-016
		,1.688135059e-016
		,1.686213818e-016
		,1.684347062e-016
		,1.682533909e-016
		,1.680771919e-016
		,1.679059629e-016
		,1.677403489e-016
		,1.675838390e-016
		,1.674493168e-016
		,1.673805883e-016
		,1.675216203e-016
		,1.683211886e-016
		,1.709692412e-016
		,1.778899815e-016
		,1.916633100e-016
		,2.093699224e-016
		,2.316242590e-016
		,2.703157325e-016
		,3.098424102e-016
		,3.583679669e-016
		,4.269991298e-016
		,4.592800431e-016
		,4.719924913e-016
		,4.768716369e-016
		,4.726725401e-016
		,4.700930422e-016
		,4.700098957e-016
		,4.742666069e-016
		,4.763136131e-016
		,4.764240464e-016
		,4.764041755e-016
		,4.764193424e-016
		,1.707597971e-016
		,1.704762354e-016
		,1.702225080e-016
		,1.699855418e-016
		,1.697594029e-016
		,1.695408676e-016
		,1.693281678e-016
		,1.691205055e-016
		,1.689177173e-016
		,1.687199633e-016
		,1.685274532e-016
		,1.683402559e-016
		,1.681582253e-016
		,1.679810665e-016
		,1.678085972e-016
		,1.676414346e-016
		,1.674829972e-016
		,1.673458490e-016
		,1.672724427e-016
		,1.674012753e-016
		,1.681607670e-016
		,1.706688208e-016
		,1.772640560e-016
		,1.904456632e-016
		,2.076593827e-016
		,2.274147539e-016
		,2.619882703e-016
		,2.999400208e-016
		,3.375915536e-016
		,4.080774703e-016
		,4.578968055e-016
		,4.805984572e-016
		,4.809340143e-016
		,4.772475586e-016
		,4.741765769e-016
		,4.722930561e-016
		,4.719590797e-016
		,4.753077200e-016
		,4.783856643e-016
		,4.787552609e-016
		,4.786980823e-016
		,1.706526534e-016
		,1.703747493e-016
		,1.701241719e-016
		,1.698889915e-016
		,1.696637993e-016
		,1.694456940e-016
		,1.692331367e-016
		,1.690254888e-016
		,1.688226801e-016
		,1.686249028e-016
		,1.684323507e-016
		,1.682450489e-016
		,1.680628017e-016
		,1.678852786e-016
		,1.677122885e-016
		,1.675444813e-016
		,1.673853858e-016
		,1.672478836e-016
		,1.671753314e-016
		,1.673087390e-016
		,1.680816698e-016
		,1.706043108e-016
		,1.772121075e-016
		,1.901868771e-016
		,2.072018079e-016
		,2.274789514e-016
		,2.549897267e-016
		,2.951385546e-016
		,3.320860054e-016
		,3.817742028e-016
		,4.488701569e-016
		,4.772195986e-016
		,4.855059431e-016
		,4.824326183e-016
		,4.787446016e-016
		,4.760973227e-016
		,4.744615316e-016
		,4.740458590e-016
		,4.767756725e-016
		,4.801923116e-016
		,4.807344508e-016
		,1.705495457e-016
		,1.702758915e-016
		,1.700273897e-016
		,1.697931218e-016
		,1.695681476e-016
		,1.693498565e-016
		,1.691369155e-016
		,1.689288258e-016
		,1.687255944e-016
		,1.685274328e-016
		,1.683345112e-016
		,1.681468084e-016
		,1.679640812e-016
		,1.677859689e-016
		,1.676122800e-016
		,1.674437165e-016
		,1.672839766e-016
		,1.671464815e-016
		,1.670762973e-016
		,1.672199262e-016
		,1.680251604e-016
		,1.706223812e-016
		,1.773864285e-016
		,1.903231316e-016
		,2.074404458e-016
		,2.281399219e-016
		,2.500596896e-016
		,2.911662309e-016
		,3.268106837e-016
		,3.630889644e-016
		,4.396886803e-016
		,4.720237799e-016
		,4.892767269e-016
		,4.876822146e-016
		,4.833541982e-016
		,4.798004951e-016
		,4.773620603e-016
		,4.758803111e-016
		,4.756666397e-016
		,4.787014859e-016
		,4.817030476e-016
		,1.704571479e-016
		,1.701864926e-016
		,1.699390520e-016
		,1.697048099e-016
		,1.694792497e-016
		,1.692600268e-016
		,1.690459963e-016
		,1.688367849e-016
		,1.686324644e-016
		,1.684332578e-016
		,1.682393082e-016
		,1.680505496e-016
		,1.678666965e-016
		,1.676873650e-016
		,1.675123717e-016
		,1.673424810e-016
		,1.671815860e-016
		,1.670437248e-016
		,1.669759979e-016
		,1.671314989e-016
		,1.679740111e-016
		,1.706698244e-016
		,1.776386549e-016
		,1.905709006e-016
		,2.079561494e-016
		,2.289999213e-016
		,2.478468821e-016
		,2.865233275e-016
		,3.223939268e-016
		,3.554229326e-016
		,4.210159953e-016
		,4.674590245e-016
		,4.903479166e-016
		,4.928496889e-016
		,4.883230102e-016
		,4.839374527e-016
		,4.807352602e-016
		,4.785685393e-016
		,4.772910587e-016
		,4.775483257e-016
		,4.811604797e-016
		,1.703787437e-016
		,1.701104373e-016
		,1.698635817e-016
		,1.696289689e-016
		,1.694024648e-016
		,1.691819664e-016
		,1.689664986e-016
		,1.687557978e-016
		,1.685499875e-016
		,1.683492931e-016
		,1.681538268e-016
		,1.679634788e-016
		,1.677779267e-016
		,1.675967704e-016
		,1.674198428e-016
		,1.672479792e-016
		,1.670852857e-016
		,1.669464666e-016
		,1.668808653e-016
		,1.670486999e-016
		,1.679291489e-016
		,1.707354192e-016
		,1.779190507e-016
		,1.908378294e-016
		,2.085679935e-016
		,2.299263667e-016
		,2.492165343e-016
		,2.797928249e-016
		,3.186979306e-016
		,3.510730072e-016
		,4.008516956e-016
		,4.641384539e-016
		,4.877730684e-016
		,4.971688799e-016
		,4.931394810e-016
		,4.880965230e-016
		,4.841603997e-016
		,4.813770423e-016
		,4.794846193e-016
		,4.784394397e-016
		,4.794321158e-016
		,1.703119675e-016
		,1.700458193e-016
		,1.697995278e-016
		,1.695646111e-016
		,1.693372808e-016
		,1.691156526e-016
		,1.688989016e-016
		,1.686868558e-016
		,1.684796751e-016
		,1.682775751e-016
		,1.680806296e-016
		,1.678886818e-016
		,1.677013726e-016
		,1.675182879e-016
		,1.673392792e-016
		,1.671652552e-016
		,1.670005448e-016
		,1.668605509e-016
		,1.667969844e-016
		,1.669775942e-016
		,1.678963408e-016
		,1.708184507e-016
		,1.782130992e-016
		,1.911030964e-016
		,2.092031392e-016
		,2.308431273e-016
		,2.506687797e-016
		,2.740944574e-016
		,3.156666911e-016
		,3.475098242e-016
		,3.831380551e-016
		,4.587722739e-016
		,4.844469328e-016
		,5.004518436e-016
		,4.977297295e-016
		,4.921698936e-016
		,4.875136963e-016
		,4.841323047e-016
		,4.817461111e-016
		,4.801175123e-016
		,4.793477619e-016
		,1.702525058e-016
		,1.699883815e-016
		,1.697427041e-016
		,1.695076321e-016
		,1.692796926e-016
		,1.690572024e-016
		,1.688394687e-016
		,1.686263974e-016
		,1.684181706e-016
		,1.682149835e-016
		,1.680168658e-016
		,1.678236105e-016
		,1.676348232e-016
		,1.674500766e-016
		,1.672692409e-016
		,1.670932996e-016
		,1.669268056e-016
		,1.667858920e-016
		,1.667247020e-016
		,1.669188986e-016
		,1.678765369e-016
		,1.709171390e-016
		,1.785125649e-016
		,1.913693034e-016
		,2.098422648e-016
		,2.317282060e-016
		,2.520098197e-016
		,2.693344932e-016
		,3.129646377e-016
		,3.443237873e-016
		,3.723436723e-016
		,4.463367726e-016
		,4.815175767e-016
		,5.007859712e-016
		,5.018660951e-016
		,4.962731529e-016
		,4.910290234e-016
		,4.871260248e-016
		,4.844582758e-016
		,4.827131751e-016
		,4.814028258e-016
		,1.701979094e-016
		,1.699352038e-016
		,1.696900132e-016
		,1.694547585e-016
		,1.692262688e-016
		,1.690030560e-016
		,1.687845153e-016
		,1.685706241e-016
		,1.683615801e-016
		,1.681575389e-016
		,1.679584876e-016
		,1.677641568e-016
		,1.675741403e-016
		,1.673879869e-016
		,1.672055892e-016
		,1.670280082e-016
		,1.668600249e-016
		,1.667185212e-016
		,1.666601089e-016
		,1.668685729e-016
		,1.678655747e-016
		,1.710249614e-016
		,1.787968088e-016
		,1.916248619e-016
		,2.104458521e-016
		,2.325322960e-016
		,2.531751910e-016
		,2.681330402e-016
		,3.072372833e-016
		,3.411028782e-016
		,3.686165881e-016
		,4.255165054e-016
		,4.804217363e-016
		,4.999620925e-016
		,5.073941899e-016
		,5.019138403e-016
		,4.957723690e-016
		,4.909620628e-016
		,4.874777661e-016
		,4.849530737e-016
		,4.831111919e-016
		,1.701606641e-016
		,1.698919848e-016
		,1.696458445e-016
		,1.694090175e-016
		,1.691790735e-016
		,1.689543282e-016
		,1.687345561e-016
		,1.685195394e-016
		,1.683096842e-016
		,1.681047161e-016
		,1.679046398e-016
		,1.677090107e-016
		,1.675177687e-016
		,1.673301956e-016
		,1.671462182e-016
		,1.669669549e-016
		,1.667975121e-016
		,1.666555105e-016
		,1.666001412e-016
		,1.668232961e-016
		,1.678605337e-016
		,1.711380160e-016
		,1.790482280e-016
		,1.918862409e-016
		,2.110198821e-016
		,2.332809256e-016
		,2.542310288e-016
		,2.700315352e-016
		,2.992616448e-016
		,3.382875771e-016
		,3.662518645e-016
		,4.060333451e-016
		,4.775457092e-016
		,4.974372568e-016
		,5.109711166e-016
		,5.067856303e-016
		,5.001233394e-016
		,4.945764858e-016
		,4.904694138e-016
		,4.874683762e-016
		,4.852381947e-016
		,1.699683759e-016
		,1.697030012e-016
		,1.694456739e-016
		,1.692013495e-016
		,1.689609558e-016
		,1.687338283e-016
		,1.685096932e-016
		,1.682983564e-016
		,1.680898968e-016
		,1.678854939e-016
		,1.676838533e-016
		,1.674891912e-016
		,1.672984737e-016
		,1.671108294e-016
		,1.669269607e-016
		,1.667535844e-016
		,1.666090886e-016
		,1.665552960e-016
		,1.667920789e-016
		,1.678711747e-016
		,1.712674518e-016
		,1.792697569e-016
		,1.921946271e-016
		,2.115972982e-016
		,2.340064093e-016
		,2.552019429e-016
		,2.717832477e-016
		,2.920943738e-016
		,3.354144480e-016
		,3.634408564e-016
		,3.888732386e-016
		,4.569066227e-016
		,4.815859529e-016
		,4.956527189e-016
		,5.122803723e-016
		,5.116177049e-016
		,5.047041276e-016
		,4.983983944e-016
		,4.935977271e-016
		,4.900743141e-016
		,4.874454291e-016
		,1.802180394e-016
		,1.797475367e-016
		,1.795153781e-016
		,1.794343277e-016
		,1.794818611e-016
		,1.796634498e-016
		,1.800092645e-016
		,1.805932458e-016
		,1.815944198e-016
		,1.834694051e-016
		,1.874009913e-016
		,1.959286396e-016
		,2.104547731e-016
		,2.288259328e-016
		,2.425736822e-016
		,2.529310142e-016
		,2.594544454e-016
		,2.663395046e-016
		,2.682246023e-016
		,2.699452721e-016
		,2.781460980e-016
		,2.875904458e-016
		,2.927284522e-016
		,3.016133005e-016
		,3.143133360e-016
		,3.293640058e-016
		,3.459677656e-016
		,3.607177013e-016
		,3.728975154e-016
		,3.832655326e-016
		,3.922706675e-016
		,4.006279228e-016
		,4.079048197e-016
		,4.137302255e-016
		,4.186817935e-016
		,4.230123336e-016
		,4.268450522e-016
		,4.302384506e-016
		,4.332322273e-016
		,4.358740857e-016
		,4.382170912e-016
		,1.785365405e-016
		,1.781409855e-016
		,1.779217118e-016
		,1.778079918e-016
		,1.777743814e-016
		,1.778125391e-016
		,1.779240328e-016
		,1.781202702e-016
		,1.784274219e-016
		,1.789011858e-016
		,1.796683708e-016
		,1.810487747e-016
		,1.839054925e-016
		,1.903531798e-016
		,2.032583908e-016
		,2.228871670e-016
		,2.403771223e-016
		,2.531957832e-016
		,2.602651111e-016
		,2.683545936e-016
		,2.760911729e-016
		,2.808296738e-016
		,2.907621244e-016
		,3.061546646e-016
		,3.227337606e-016
		,3.381810668e-016
		,3.515820626e-016
		,3.645973038e-016
		,3.774755576e-016
		,3.894373219e-016
		,3.994082685e-016
		,4.074946595e-016
		,4.142805395e-016
		,4.200056174e-016
		,4.248569448e-016
		,4.289931835e-016
		,4.325459999e-016
		,4.356181648e-016
		,4.382885934e-016
		,4.406239938e-016
		,4.426825444e-016
		,1.771318831e-016
		,1.767753241e-016
		,1.765611323e-016
		,1.764338709e-016
		,1.763702546e-016
		,1.763581854e-016
		,1.763912225e-016
		,1.764675743e-016
		,1.765906436e-016
		,1.767706677e-016
		,1.770285352e-016
		,1.774056858e-016
		,1.779921532e-016
		,1.790106106e-016
		,1.810671970e-016
		,1.857731376e-016
		,1.962977641e-016
		,2.153426710e-016
		,2.366825400e-016
		,2.534000804e-016
		,2.641419272e-016
		,2.748522813e-016
		,2.904569373e-016
		,3.070712440e-016
		,3.238297897e-016
		,3.430280685e-016
		,3.611215713e-016
		,3.766587751e-016
		,3.889304733e-016
		,3.987592314e-016
		,4.073237528e-016
		,4.146140450e-016
		,4.206227820e-016
		,4.255653254e-016
		,4.297185940e-016
		,4.332756060e-016
		,4.363681241e-016
		,4.390915313e-016
		,4.415131237e-016
		,4.436911392e-016
		,4.456697755e-016
		,1.760467620e-016
		,1.757054359e-016
		,1.754743820e-016
		,1.753121217e-016
		,1.752017457e-016
		,1.751346029e-016
		,1.751055343e-016
		,1.751114370e-016
		,1.751509408e-016
		,1.752246391e-016
		,1.753358142e-016
		,1.754918745e-016
		,1.757072997e-016
		,1.760106124e-016
		,1.764633460e-016
		,1.772165688e-016
		,1.786844451e-016
		,1.820270525e-016
		,1.900360485e-016
		,2.068650656e-016
		,2.310689013e-016
		,2.549510997e-016
		,2.758236394e-016
		,2.972024314e-016
		,3.238019902e-016
		,3.500522979e-016
		,3.713633924e-016
		,3.874326772e-016
		,3.996659128e-016
		,4.094027063e-016
		,4.170568772e-016
		,4.228937349e-016
		,4.278842188e-016
		,4.323233820e-016
		,4.361245910e-016
		,4.393679375e-016
		,4.421539619e-016
		,4.445947355e-016
		,4.467915824e-016
		,4.487877014e-016
		,4.506014434e-016
		,1.751659054e-016
		,1.748513155e-016
		,1.746192850e-016
		,1.744370283e-016
		,1.742910473e-016
		,1.741746976e-016
		,1.740846132e-016
		,1.740195494e-016
		,1.739798489e-016
		,1.739670412e-016
		,1.739834880e-016
		,1.740321711e-016
		,1.741168353e-016
		,1.742428407e-016
		,1.744194028e-016
		,1.746649831e-016
		,1.750213361e-016
		,1.755943128e-016
		,1.766804057e-016
		,1.791543710e-016
		,1.854654799e-016
		,2.008191763e-016
		,2.302619623e-016
		,2.709774739e-016
		,3.136392319e-016
		,3.500303119e-016
		,3.769882175e-016
		,3.958219275e-016
		,4.090668418e-016
		,4.187075571e-016
		,4.260053047e-016
		,4.317294205e-016
		,4.363562001e-016
		,4.401900448e-016
		,4.434324001e-016
		,4.462210699e-016
		,4.486532024e-016
		,4.507991623e-016
		,4.527111740e-016
		,4.544288695e-016
		,4.559829406e-016
		,1.742956695e-016
		,1.740205340e-016
		,1.738085715e-016
		,1.736330491e-016
		,1.734824505e-016
		,1.733507474e-016
		,1.732346406e-016
		,1.731326925e-016
		,1.730449469e-016
		,1.729726489e-016
		,1.729179751e-016
		,1.728837795e-016
		,1.728733985e-016
		,1.728905831e-016
		,1.729396914e-016
		,1.730264962e-016
		,1.731606116e-016
		,1.733625872e-016
		,1.736851510e-016
		,1.742781024e-016
		,1.755830971e-016
		,1.790754889e-016
		,1.890389246e-016
		,2.146625091e-016
		,2.691496149e-016
		,3.344229018e-016
		,3.797525177e-016
		,4.066458706e-016
		,4.214011796e-016
		,4.298377613e-016
		,4.358121804e-016
		,4.404307293e-016
		,4.441754676e-016
		,4.473102811e-016
		,4.500084171e-016
		,4.524026826e-016
		,4.545818292e-016
		,4.566423326e-016
		,4.583511342e-016
		,4.598123439e-016
		,4.611354614e-016
		,1.733358695e-016
		,1.730833740e-016
		,1.728853860e-016
		,1.727195191e-016
		,1.725754719e-016
		,1.724472990e-016
		,1.723312696e-016
		,1.722251993e-016
		,1.721281316e-016
		,1.720400717e-016
		,1.719617269e-016
		,1.718942805e-016
		,1.718392527e-016
		,1.717985004e-016
		,1.717744257e-016
		,1.717705961e-016
		,1.717934377e-016
		,1.718573003e-016
		,1.720003692e-016
		,1.723347605e-016
		,1.731954331e-016
		,1.755129399e-016
		,1.814350360e-016
		,1.968952096e-016
		,2.287437403e-016
		,2.828933635e-016
		,3.588305181e-016
		,4.093538283e-016
		,4.291667363e-016
		,4.396682858e-016
		,4.470799736e-016
		,4.500873358e-016
		,4.523820494e-016
		,4.544261719e-016
		,4.562777257e-016
		,4.579574373e-016
		,4.594842011e-016
		,4.608815396e-016
		,4.621916295e-016
		,4.635581328e-016
		,4.651244506e-016
		,1.724612069e-016
		,1.722039512e-016
		,1.719918116e-016
		,1.718067131e-016
		,1.716406713e-016
		,1.714893947e-016
		,1.713504623e-016
		,1.712226761e-016
		,1.711056776e-016
		,1.709996087e-016
		,1.709047982e-016
		,1.708215199e-016
		,1.707498736e-016
		,1.706898325e-016
		,1.706415212e-016
		,1.706059312e-016
		,1.705868316e-016
		,1.705965077e-016
		,1.706740287e-016
		,1.709433082e-016
		,1.717861262e-016
		,1.742676078e-016
		,1.806162834e-016
		,1.938020819e-016
		,2.192856443e-016
		,2.563601885e-016
		,3.080660786e-016
		,3.878645754e-016
		,4.352720893e-016
		,4.483266273e-016
		,4.507663070e-016
		,4.543301689e-016
		,4.598651506e-016
		,4.614227084e-016
		,4.623899762e-016
		,4.633374664e-016
		,4.642786168e-016
		,4.651921773e-016
		,4.660641060e-016
		,4.668899319e-016
		,4.676752035e-016
		,1.714117719e-016
		,1.711857510e-016
		,1.709825535e-016
		,1.707951690e-016
		,1.706197848e-016
		,1.704542680e-016
		,1.702976217e-016
		,1.701496482e-016
		,1.700106433e-016
		,1.698811135e-016
		,1.697615582e-016
		,1.696523592e-016
		,1.695538089e-016
		,1.694663501e-016
		,1.693912678e-016
		,1.693327637e-016
		,1.693046142e-016
		,1.693520501e-016
		,1.696223341e-016
		,1.705751572e-016
		,1.734690165e-016
		,1.808613401e-016
		,1.957857469e-016
		,2.156900517e-016
		,2.472210491e-016
		,2.897237705e-016
		,3.247381638e-016
		,3.545091168e-016
		,4.154595912e-016
		,4.538683043e-016
		,4.613350646e-016
		,4.604688250e-016
		,4.594801236e-016
		,4.610548581e-016
		,4.661022494e-016
		,4.677791467e-016
		,4.683582263e-016
		,4.688762056e-016
		,4.694066493e-016
		,4.699408894e-016
		,4.704667372e-016
		,1.710779081e-016
		,1.708015397e-016
		,1.705584001e-016
		,1.703346197e-016
		,1.701239205e-016
		,1.699229007e-016
		,1.697297035e-016
		,1.695435165e-016
		,1.693642374e-016
		,1.691921639e-016
		,1.690277146e-016
		,1.688712258e-016
		,1.687228644e-016
		,1.685826884e-016
		,1.684509368e-016
		,1.683288413e-016
		,1.682211077e-016
		,1.681440202e-016
		,1.681525299e-016
		,1.684282949e-016
		,1.695392673e-016
		,1.729600810e-016
		,1.814810429e-016
		,1.973653297e-016
		,2.161583469e-016
		,2.372358424e-016
		,2.772917933e-016
		,3.191409718e-016
		,3.699225654e-016
		,4.382847052e-016
		,4.661201628e-016
		,4.696767998e-016
		,4.674482152e-016
		,4.654765832e-016
		,4.645773631e-016
		,4.651932362e-016
		,4.691656970e-016
		,4.727044238e-016
		,4.742557314e-016
		,4.769538132e-016
		,4.794035508e-016
		,1.708262168e-016
		,1.705450758e-016
		,1.702932029e-016
		,1.700579806e-016
		,1.698336563e-016
		,1.696171104e-016
		,1.694066533e-016
		,1.692015533e-016
		,1.690017056e-016
		,1.688073234e-016
		,1.686186691e-016
		,1.684358693e-016
		,1.682588488e-016
		,1.680874108e-016
		,1.679215373e-016
		,1.677622077e-016
		,1.676138899e-016
		,1.674927197e-016
		,1.674542100e-016
		,1.676838492e-016
		,1.687595027e-016
		,1.721194159e-016
		,1.804078103e-016
		,1.954802302e-016
		,2.134023212e-016
		,2.337400544e-016
		,2.639306812e-016
		,3.058035484e-016
		,3.452782058e-016
		,3.993693377e-016
		,4.541817765e-016
		,4.749919695e-016
		,4.805949417e-016
		,4.853889103e-016
		,4.788636716e-016
		,4.754014520e-016
		,4.738532164e-016
		,4.744584214e-016
		,4.780468528e-016
		,4.793284533e-016
		,4.793194276e-016
		,1.707127572e-016
		,1.704362634e-016
		,1.701863497e-016
		,1.699515132e-016
		,1.697265070e-016
		,1.695085138e-016
		,1.692960499e-016
		,1.690885141e-016
		,1.688858595e-016
		,1.686882895e-016
		,1.684960013e-016
		,1.683090203e-016
		,1.681271543e-016
		,1.679500870e-016
		,1.677776705e-016
		,1.676106906e-016
		,1.674531385e-016
		,1.673195741e-016
		,1.672594488e-016
		,1.674354441e-016
		,1.683509584e-016
		,1.712788854e-016
		,1.788135497e-016
		,1.930125045e-016
		,2.107866008e-016
		,2.317988933e-016
		,2.525090493e-016
		,2.951963472e-016
		,3.321439764e-016
		,3.671506846e-016
		,4.412530546e-016
		,4.839880184e-016
		,4.944216496e-016
		,4.894152517e-016
		,4.839961507e-016
		,4.802060466e-016
		,4.778035864e-016
		,4.764405908e-016
		,4.760733057e-016
		,4.782017327e-016
		,4.811464985e-016
		,1.706084019e-016
		,1.703367770e-016
		,1.700895232e-016
		,1.698561311e-016
		,1.696318179e-016
		,1.694140556e-016
		,1.692015647e-016
		,1.689938812e-016
		,1.687910308e-016
		,1.685932308e-016
		,1.684006485e-016
		,1.682132566e-016
		,1.680308083e-016
		,1.678529466e-016
		,1.676794984e-016
		,1.675112253e-016
		,1.673520171e-016
		,1.672159660e-016
		,1.671505370e-016
		,1.673106288e-016
		,1.681698533e-016
		,1.709206044e-016
		,1.780501337e-016
		,1.914336848e-016
		,2.090238199e-016
		,2.303232070e-016
		,2.495591067e-016
		,2.829851395e-016
		,3.254118088e-016
		,3.625380101e-016
		,4.095694262e-016
		,4.761030993e-016
		,4.954571764e-016
		,4.968542896e-016
		,4.908581441e-016
		,4.858223648e-016
		,4.823699680e-016
		,4.801248499e-016
		,4.787428103e-016
		,4.780270701e-016
		,4.787069727e-016
		,1.705046705e-016
		,1.702368809e-016
		,1.699915645e-016
		,1.697590908e-016
		,1.695350913e-016
		,1.693172989e-016
		,1.691046173e-016
		,1.688967022e-016
		,1.686936373e-016
		,1.684956441e-016
		,1.683028560e-016
		,1.681151944e-016
		,1.679323653e-016
		,1.677539836e-016
		,1.675798775e-016
		,1.674108499e-016
		,1.672509103e-016
		,1.671144662e-016
		,1.670498909e-016
		,1.672143698e-016
		,1.680818628e-016
		,1.708464174e-016
		,1.779615760e-016
		,1.909851176e-016
		,2.086853202e-016
		,2.303104269e-016
		,2.504918838e-016
		,2.748553677e-016
		,3.188872953e-016
		,3.543730295e-016
		,3.872171769e-016
		,4.609637568e-016
		,4.906193090e-016
		,5.022868125e-016
		,4.975412902e-016
		,4.915489019e-016
		,4.870450556e-016
		,4.839620283e-016
		,4.818977440e-016
		,4.805522854e-016
		,4.796967143e-016
		,1.704069188e-016
		,1.701417274e-016
		,1.698973465e-016
		,1.696649302e-016
		,1.694404848e-016
		,1.692219811e-016
		,1.690084891e-016
		,1.687997693e-016
		,1.685959516e-016
		,1.683972534e-016
		,1.682037702e-016
		,1.680153734e-016
		,1.678317261e-016
		,1.676524216e-016
		,1.674772984e-016
		,1.673072194e-016
		,1.671463815e-016
		,1.670097667e-016
		,1.669476442e-016
		,1.671229843e-016
		,1.680193648e-016
		,1.708666985e-016
		,1.781132301e-016
		,1.909678488e-016
		,2.088934893e-016
		,2.306666286e-016
		,2.512391863e-016
		,2.685546660e-016
		,3.141588372e-016
		,3.485856259e-016
		,3.803868755e-016
		,4.374248565e-016
		,4.875948163e-016
		,5.030557614e-016
		,5.026922382e-016
		,4.963915214e-016
		,4.910880535e-016
		,4.873018519e-016
		,4.846774512e-016
		,4.828631962e-016
		,4.816151807e-016
		,1.703214274e-016
		,1.700579296e-016
		,1.698137322e-016
		,1.695806942e-016
		,1.693551637e-016
		,1.691353308e-016
		,1.689204171e-016
		,1.687102757e-016
		,1.685050736e-016
		,1.683050184e-016
		,1.681101677e-016
		,1.679203471e-016
		,1.677351840e-016
		,1.675542586e-016
		,1.673774284e-016
		,1.672056274e-016
		,1.670432650e-016
		,1.669059948e-016
		,1.668462913e-016
		,1.670342440e-016
		,1.679655267e-016
		,1.709180440e-016
		,1.783383500e-016
		,1.910995139e-016
		,2.093276189e-016
		,2.312426462e-016
		,2.520833825e-016
		,2.677665270e-016
		,3.062897230e-016
		,3.437845937e-016
		,3.754325375e-016
		,4.151828615e-016
		,4.853683600e-016
		,5.018013321e-016
		,5.078318917e-016
		,5.016180663e-016
		,4.954099051e-016
		,4.907682246e-016
		,4.875010850e-016
		,4.852055664e-016
		,4.835869499e-016
		,1.699871591e-016
		,1.697429653e-016
		,1.695091800e-016
		,1.692824614e-016
		,1.690611982e-016
		,1.688447463e-016
		,1.686330363e-016
		,1.684262589e-016
		,1.682246040e-016
		,1.680280877e-016
		,1.678364904e-016
		,1.676494082e-016
		,1.674664138e-016
		,1.672873889e-016
		,1.671133476e-016
		,1.669489269e-016
		,1.668105150e-016
		,1.667529978e-016
		,1.669543472e-016
		,1.679234990e-016
		,1.709917326e-016
		,1.785942278e-016
		,1.913081269e-016
		,2.098725483e-016
		,2.319359738e-016
		,2.529910300e-016
		,2.693662134e-016
		,2.977728950e-016
		,3.397494230e-016
		,3.710777853e-016
		,3.986378495e-016
		,4.644126804e-016
		,4.889979749e-016
		,4.999008042e-016
		,5.113720753e-016
		,5.066963262e-016
		,4.997937304e-016
		,4.943083460e-016
		,4.903685779e-016
		,4.875789785e-016
		,4.855848814e-016
		,1.699260769e-016
		,1.696820015e-016
		,1.694476575e-016
		,1.692199860e-016
		,1.689975554e-016
		,1.687798394e-016
		,1.685668301e-016
		,1.683587289e-016
		,1.681556979e-016
		,1.679577056e-016
		,1.677644856e-016
		,1.675756029e-016
		,1.673906237e-016
		,1.672094545e-016
		,1.670331918e-016
		,1.668667086e-016
		,1.667271780e-016
		,1.666720664e-016
		,1.668876177e-016
		,1.678970716e-016
		,1.710865073e-016
		,1.788547289e-016
		,1.915692086e-016
		,2.104705555e-016
		,2.326933300e-016
		,2.539534239e-016
		,2.709371351e-016
		,2.907318491e-016
		,3.364119484e-016
		,3.672641987e-016
		,3.933253724e-016
		,4.311401335e-016
		,4.831674320e-016
		,4.985577503e-016
		,5.113695621e-016
		,5.111200721e-016
		,5.040522199e-016
		,4.978795317e-016
		,4.933144988e-016
		,4.900521063e-016
		,4.877062936e-016
		,1.701299881e-016
		,1.698705371e-016
		,1.696266602e-016
		,1.693919167e-016
		,1.691635108e-016
		,1.689401737e-016
		,1.687214850e-016
		,1.685074841e-016
		,1.682983743e-016
		,1.680942807e-016
		,1.678951218e-016
		,1.677005831e-016
		,1.675102025e-016
		,1.673235400e-016
		,1.671405282e-016
		,1.669623454e-016
		,1.667941089e-016
		,1.666537972e-016
		,1.666016069e-016
		,1.668319953e-016
		,1.678841022e-016
		,1.711965292e-016
		,1.790917684e-016
		,1.918776222e-016
		,2.110890527e-016
		,2.334712681e-016
		,2.549163461e-016
		,2.724083936e-016
		,2.850215084e-016
		,3.332152966e-016
		,3.637587308e-016
		,3.901438698e-016
