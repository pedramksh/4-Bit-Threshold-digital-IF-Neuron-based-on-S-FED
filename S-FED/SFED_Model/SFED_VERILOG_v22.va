	,1.046354490e-007
	,1.061059031e-007
	,1.078490813e-007
	,1.099211705e-007
	,1.124340428e-007
	,1.155458487e-007
	,1.194467685e-007
	,1.243876885e-007
	,-2.489758015e-004
	,-2.337879089e-004
	,-2.184831540e-004
	,-2.032184075e-004
	,-1.882162662e-004
	,-1.736034380e-004
	,-1.594200479e-004
	,-1.456747778e-004
	,-1.324238076e-004
	,-1.197270886e-004
	,-1.075969998e-004
	,-9.602268696e-005
	,-8.497266040e-005
	,-7.439852433e-005
	,-6.437676188e-005
	,-5.504704811e-005
	,-4.647483713e-005
	,-3.870649220e-005
	,-3.177883859e-005
	,-2.570143735e-005
	,-2.046129169e-005
	,-1.602634219e-005
	,-1.234432894e-005
	,-9.339844647e-006
	,-6.946986954e-006
	,-5.096983656e-006
	,-3.695920283e-006
	,-2.651400688e-006
	,-1.884401438e-006
	,-1.328597496e-006
	,-9.298358637e-007
	,-6.459576799e-007
	,-4.450833018e-007
	,-3.035979370e-007
	,-2.042823509e-007
	,-1.347323997e-007
	,-8.609490157e-008
	,-5.208604437e-008
	,-2.830132188e-008
	,-1.166808333e-008
	,9.919412657e-019
	,8.226703702e-009
	,1.407019352e-008
	,1.826454628e-008
	,2.131867199e-008
	,2.358520486e-008
	,2.530839706e-008
	,2.665737674e-008
	,2.774922354e-008
	,2.866496779e-008
	,2.946067932e-008
	,3.017514872e-008
	,3.083520711e-008
	,3.145940939e-008
	,3.206058389e-008
	,3.264759682e-008
	,3.322657349e-008
	,3.380174287e-008
	,3.437602192e-008
	,3.495141920e-008
	,3.552931425e-008
	,3.611064966e-008
	,3.669606379e-008
	,3.728598176e-008
	,3.788067757e-008
	,3.848031622e-008
	,3.908498215e-008
	,3.969469780e-008
	,4.030943552e-008
	,4.092912509e-008
	,4.155365781e-008
	,4.218288833e-008
	,4.281663531e-008
	,4.345468099e-008
	,4.409677030e-008
	,4.474260993e-008
	,4.539186749e-008
	,4.604417128e-008
	,4.669911072e-008
	,4.735623793e-008
	,4.801506960e-008
	,4.867509063e-008
	,4.933575722e-008
	,4.999650047e-008
	,5.065672889e-008
	,5.131582916e-008
	,5.197316497e-008
	,5.262807416e-008
	,5.327986417e-008
	,5.392780765e-008
	,5.457113957e-008
	,5.520905768e-008
	,5.584072706e-008
	,5.646528854e-008
	,5.708187221e-008
	,5.768961390e-008
	,5.828767580e-008
	,5.887527014e-008
	,5.945168897e-008
	,6.001633612e-008
	,6.056877135e-008
	,6.110879405e-008
	,6.163648885e-008
	,6.215223953e-008
	,6.265674893e-008
	,6.315102196e-008
	,6.363630556e-008
	,6.411400897e-008
	,6.458563367e-008
	,6.505265157e-008
	,6.551640833e-008
	,6.597808123e-008
	,6.643866467e-008
	,6.689897435e-008
	,6.735966444e-008
	,6.782125089e-008
	,6.828413570e-008
	,6.874862919e-008
	,6.921497011e-008
	,6.968334127e-008
	,7.015388282e-008
	,7.062670215e-008
	,7.110188196e-008
	,7.157948590e-008
	,7.205956329e-008
	,7.254215289e-008
	,7.302728487e-008
	,7.351498315e-008
	,7.400526647e-008
	,7.449814796e-008
	,7.499362629e-008
	,7.549168299e-008
	,7.599234833e-008
	,7.649564673e-008
	,7.700158474e-008
	,7.751016427e-008
	,7.802138359e-008
	,7.853524496e-008
	,7.905175691e-008
	,7.957092416e-008
	,8.009275003e-008
	,8.061723753e-008
	,8.114438998e-008
	,8.167421117e-008
	,8.220670608e-008
	,8.274188072e-008
	,8.327974215e-008
	,8.382029807e-008
	,8.436355773e-008
	,8.490953185e-008
	,8.545823313e-008
	,8.600967644e-008
	,8.656387840e-008
	,8.712085746e-008
	,8.768063398e-008
	,8.824323037e-008
	,8.880867155e-008
	,8.937698474e-008
	,8.994819899e-008
	,9.052234524e-008
	,9.109945603e-008
	,9.167956474e-008
	,9.226271123e-008
	,9.284893630e-008
	,9.343828233e-008
	,9.403079321e-008
	,9.462651502e-008
	,9.522549570e-008
	,9.582778539e-008
	,9.643343642e-008
	,9.704250366e-008
	,9.765504295e-008
	,9.827110044e-008
	,9.889074409e-008
	,9.951404481e-008
	,1.001410752e-007
	,1.007719140e-007
	,1.014066482e-007
	,1.020453757e-007
	,1.026882090e-007
	,1.033352795e-007
	,1.039867442e-007
	,1.046427916e-007
	,1.053036549e-007
	,1.059696233e-007
	,1.066410618e-007
	,1.073184256e-007
	,1.080022929e-007
	,1.086934398e-007
	,1.093928544e-007
	,1.101018231e-007
	,1.108220252e-007
	,1.115556461e-007
	,1.123055679e-007
	,1.130755786e-007
	,1.138706571e-007
	,1.146973637e-007
	,1.155643500e-007
	,1.164830382e-007
	,1.174685212e-007
	,1.185407649e-007
	,-2.535707255e-004
	,-2.377977965e-004
	,-2.219751414e-004
	,-2.063559667e-004
	,-1.911059817e-004
	,-1.762854102e-004
	,-1.618982629e-004
	,-1.479671404e-004
	,-1.345624452e-004
	,-1.217149770e-004
	,-1.094143108e-004
	,-9.762143593e-005
	,-8.627214615e-005
	,-7.542564688e-005
	,-6.523408022e-005
	,-5.577264862e-005
	,-4.708301034e-005
	,-3.921319730e-005
	,-3.219507514e-005
	,-2.603533342e-005
	,-2.072080310e-005
	,-1.621767338e-005
	,-1.246628722e-005
	,-9.411088152e-006
	,-6.994726851e-006
	,-5.130847417e-006
	,-3.719400678e-006
	,-2.667384841e-006
	,-1.895544383e-006
	,-1.336416038e-006
	,-9.353188516e-007
	,-6.497936387e-007
	,-4.477563330e-007
	,-3.054485481e-007
	,-2.055498422e-007
	,-1.355843406e-007
	,-8.664203459e-008
	,-5.240008856e-008
	,-2.847793019e-008
	,-1.174443782e-008
	,-2.125223213e-017
	,8.285644445e-009
	,1.417539293e-008
	,1.840685168e-008
	,2.149155394e-008
	,2.378407387e-008
	,2.553009357e-008
	,2.689979308e-008
	,2.801102533e-008
	,2.894539030e-008
	,2.975937833e-008
	,3.049209227e-008
	,3.117059617e-008
	,3.181362073e-008
	,3.243412818e-008
	,3.304108830e-008
	,3.364070809e-008
	,3.423728247e-008
	,3.483378353e-008
	,3.543226833e-008
	,3.603416069e-008
	,3.664044668e-008
	,3.725180950e-008
	,3.786872255e-008
	,3.849151370e-008
	,3.912040924e-008
	,3.975556386e-008
	,4.039708090e-008
	,4.104502549e-008
	,4.169943312e-008
	,4.236031498e-008
	,4.302766060e-008
	,4.370143892e-008
	,4.438159847e-008
	,4.506806642e-008
	,4.576074685e-008
	,4.645951937e-008
	,4.716423668e-008
	,4.787472227e-008
	,4.859076842e-008
	,4.931213368e-008
	,5.003854120e-008
	,5.076967707e-008
	,5.150518959e-008
	,5.224468912e-008
	,5.298774933e-008
	,5.373390896e-008
	,5.448267546e-008
	,5.523352879e-008
	,5.598592593e-008
	,5.673930493e-008
	,5.749308747e-008
	,5.824667973e-008
	,5.899947007e-008
	,5.975082441e-008
	,6.050007958e-008
	,6.124653591e-008
	,6.198945119e-008
	,6.272803710e-008
	,6.346146009e-008
	,6.418884695e-008
	,6.490929355e-008
	,6.562187663e-008
	,6.632566881e-008
	,6.701975428e-008
	,6.770324864e-008
	,6.837532301e-008
	,6.903523617e-008
	,6.968237563e-008
	,7.031630609e-008
	,7.093682030e-008
	,7.154398025e-008
	,7.213815639e-008
	,7.272012470e-008
	,7.329103888e-008
	,7.385230344e-008
	,7.440548800e-008
	,7.495222474e-008
	,7.549410400e-008
	,7.603259163e-008
	,7.656897674e-008
	,7.710435091e-008
	,7.763961113e-008
	,7.817547736e-008
	,7.871251736e-008
	,7.925117343e-008
	,7.979178688e-008
	,8.033461975e-008
	,8.087987222e-008
	,8.142769742e-008
	,8.197821218e-008
	,8.253150618e-008
	,8.308764842e-008
	,8.364669279e-008
	,8.420868152e-008
	,8.477364777e-008
	,8.534161679e-008
	,8.591260284e-008
	,8.648658597e-008
	,8.706354995e-008
	,8.764355691e-008
	,8.822663278e-008
	,8.881278292e-008
	,8.940201162e-008
	,8.999432719e-008
	,9.058973586e-008
	,9.118824123e-008
	,9.178984482e-008
	,9.239454367e-008
	,9.300234428e-008
	,9.361326023e-008
	,9.422730068e-008
	,9.484447460e-008
	,9.546479182e-008
	,9.608826362e-008
	,9.671490270e-008
	,9.734472342e-008
	,9.797774231e-008
	,9.861397836e-008
	,9.925345263e-008
	,9.989618834e-008
	,1.005422111e-007
	,1.011915486e-007
	,1.018442313e-007
	,1.025002918e-007
	,1.031597647e-007
	,1.038226865e-007
	,1.044890953e-007
	,1.051590350e-007
	,1.058325522e-007
	,1.065096946e-007
	,1.071905110e-007
	,1.078750518e-007
	,1.085633690e-007
	,1.092555162e-007
	,1.099515482e-007
	,1.106515212e-007
	,1.113554927e-007
	,1.120635186e-007
	,1.127756559e-007
	,1.134919696e-007
	,1.142125244e-007
	,1.149373871e-007
	,1.156666264e-007
	,1.164003150e-007
	,1.171385317e-007
	,1.178813619e-007
	,1.186289018e-007
	,1.193812585e-007
	,1.201385557e-007
	,1.209009397e-007
	,1.216685858e-007
	,1.224417088e-007
	,1.232205755e-007
	,1.240055215e-007
	,1.247969735e-007
	,1.255954793e-007
	,1.264017459e-007
	,1.272166871e-007
	,1.280414999e-007
	,1.288777246e-007
	,-2.575696138e-004
	,-2.412689580e-004
	,-2.250780337e-004
	,-2.092144416e-004
	,-1.937702724e-004
	,-1.787624694e-004
	,-1.641859546e-004
	,-1.500934751e-004
	,-1.365422745e-004
	,-1.235334040e-004
	,-1.110262336e-004
	,-9.894247506e-005
	,-8.730996851e-005
	,-7.628899458e-005
	,-6.597088409e-005
	,-5.639564946e-005
	,-4.760574169e-005
	,-3.964958685e-005
	,-3.255344650e-005
	,-2.632170060e-005
	,-2.093864182e-005
	,-1.636182875e-005
	,-1.255316346e-005
	,-9.467253201e-006
	,-7.034884963e-006
	,-5.159703324e-006
	,-3.739315241e-006
	,-2.681161373e-006
	,-1.905250530e-006
	,-1.343263037e-006
	,-9.401371370e-007
	,-6.531725658e-007
	,-4.501146497e-007
	,-3.070828188e-007
	,-2.066692627e-007
	,-1.363337588e-007
	,-8.709914889e-008
	,-5.267634481e-008
	,-2.863525588e-008
	,-1.181242773e-008
	,1.461888591e-018
	,8.337980263e-009
	,1.426866365e-008
	,1.853283250e-008
	,2.164437747e-008
	,2.395961301e-008
	,2.572550153e-008
	,2.711316345e-008
	,2.824114244e-008
	,2.919154677e-008
	,3.002124221e-008
	,3.076961034e-008
	,3.146392421e-008
	,3.212307232e-008
	,3.276013778e-008
	,3.338418413e-008
	,3.400149193e-008
	,3.461641480e-008
	,3.523197243e-008
	,3.585026092e-008
	,3.647273694e-008
	,3.710041475e-008
	,3.773400288e-008
	,3.837399846e-008
	,3.902075299e-008
	,3.967451771e-008
	,4.033547507e-008
	,4.100376017e-008
	,4.167947565e-008
	,4.236270146e-008
	,4.305350117e-008
	,4.375192612e-008
	,4.445801737e-008
	,4.517180670e-008
	,4.589331665e-008
	,4.662255962e-008
	,4.735953702e-008
	,4.810423729e-008
	,4.885663465e-008
	,4.961668667e-008
	,5.038433245e-008
	,5.115949011e-008
	,5.194205452e-008
	,5.273189502e-008
	,5.352885264e-008
	,5.433273794e-008
	,5.514332856e-008
	,5.596036722e-008
	,5.678355989e-008
	,5.761257487e-008
	,5.844704237e-008
	,5.928655535e-008
	,6.013067110e-008
	,6.097891466e-008
	,6.183078299e-008
	,6.268574991e-008
	,6.354327233e-008
	,6.440279486e-008
	,6.526375238e-008
	,6.612557005e-008
	,6.698766103e-008
	,6.784941987e-008
	,6.871021432e-008
	,6.956937513e-008
	,7.042618725e-008
	,7.127988324e-008
	,7.212964107e-008
	,7.297458667e-008
	,7.381380070e-008
	,7.464632888e-008
	,7.547119340e-008
	,7.628740466e-008
	,7.709397217e-008
	,7.788991734e-008
	,7.867428903e-008
	,7.944618863e-008
	,8.020481171e-008
	,8.094950581e-008
	,8.167982409e-008
	,8.239557524e-008
	,8.309687579e-008
	,8.378419318e-008
	,8.445835983e-008
	,8.512053464e-008
	,8.577212664e-008
	,8.641485589e-008
	,8.705058763e-008
	,8.768110017e-008
	,8.830802027e-008
	,8.893277897e-008
	,8.955658973e-008
	,9.018045114e-008
	,9.080516590e-008
	,9.143136761e-008
	,9.205954988e-008
	,9.269009387e-008
	,9.332329183e-008
	,9.395936737e-008
	,9.459849119e-008
	,9.524079370e-008
	,9.588637502e-008
	,9.653531188e-008
	,9.718766387e-008
	,9.784347683e-008
	,9.850278388e-008
	,9.916559315e-008
	,9.983184561e-008
	,1.005015619e-007
	,1.011748312e-007
	,1.018516780e-007
	,1.025321213e-007
	,1.032161733e-007
	,1.039038400e-007
	,1.045951252e-007
	,1.052900332e-007
	,1.059885688e-007
	,1.066907372e-007
	,1.073965448e-007
	,1.081059986e-007
	,1.088191032e-007
	,1.095358579e-007
	,1.102562791e-007
	,1.109803921e-007
	,1.117082152e-007
	,1.124397668e-007
	,1.131750670e-007
	,1.139141375e-007
	,1.146570026e-007
	,1.154036884e-007
	,1.161542229e-007
	,1.169086364e-007
	,1.176669603e-007
	,1.184292271e-007
	,1.191954697e-007
	,1.199657264e-007
	,1.207400397e-007
	,1.215184505e-007
	,1.223009993e-007
	,1.230877263e-007
	,1.238786709e-007
	,1.246738719e-007
	,1.254733668e-007
	,1.262771915e-007
	,1.270853790e-007
	,1.278979586e-007
	,1.287149544e-007
	,1.295363911e-007
	,1.303622884e-007
	,1.311926603e-007
	,1.320275146e-007
	,1.328668527e-007
	,1.337106687e-007
	,1.345589491e-007
	,1.354116729e-007
	,1.362688110e-007
	,1.371303257e-007
	,1.379961728e-007
	,1.388663061e-007
	,1.397406745e-007
	,1.406192213e-007
	,1.415018968e-007
	,-2.610758463e-004
	,-2.443776345e-004
	,-2.279327198e-004
	,-2.118817183e-004
	,-1.962667306e-004
	,-1.810794114e-004
	,-1.663320563e-004
	,-1.520939825e-004
	,-1.383923570e-004
	,-1.251941650e-004
	,-1.124134822e-004
	,-1.000351506e-004
	,-8.821661776e-005
	,-7.706966192e-005
	,-6.664116671e-005
	,-5.696275769e-005
	,-4.808341022e-005
	,-4.004825335e-005
	,-3.287882946e-005
	,-2.657591916e-005
	,-2.111344316e-005
	,-1.647051955e-005
	,-1.262342303e-005
	,-9.515808638e-006
	,-7.070383972e-006
	,-5.185107790e-006
	,-3.756775144e-006
	,-2.693390269e-006
	,-1.913906713e-006
	,-1.349382545e-006
	,-9.444494265e-007
	,-6.561995815e-007
	,-4.522287121e-007
	,-3.085481825e-007
	,-2.076719599e-007
	,-1.369929347e-007
	,-8.749535180e-008
	,-5.292575300e-008
	,-2.877746196e-008
	,-1.187382292e-008
	,3.587247608e-017
	,8.385120311e-009
	,1.435256499e-008
	,1.864600854e-008
	,2.178148405e-008
	,2.411688481e-008
	,2.590033253e-008
	,2.730379753e-008
	,2.844644677e-008
	,2.941084661e-008
	,3.025420104e-008
	,3.101614351e-008
	,3.172413620e-008
	,3.239721183e-008
	,3.304856538e-008
	,3.368734848e-008
	,3.431991299e-008
	,3.495067102e-008
	,3.558269110e-008
	,3.621811043e-008
	,3.685842105e-008
	,3.750466715e-008
	,3.815758284e-008
	,3.881768709e-008
	,3.948534981e-008
	,4.016083815e-008
	,4.084434868e-008
	,4.153602958e-008
	,4.223599656e-008
	,4.294434414e-008
	,4.366115265e-008
	,4.438649401e-008
	,4.512043491e-008
	,4.586303884e-008
	,4.661436722e-008
	,4.737447977e-008
	,4.814343412e-008
	,4.892128501e-008
	,4.970808332e-008
	,5.050387454e-008
	,5.130869718e-008
	,5.212258131e-008
	,5.294554648e-008
	,5.377759995e-008
	,5.461873454e-008
	,5.546892687e-008
	,5.632813490e-008
	,5.719629605e-008
	,5.807332452e-008
	,5.895910940e-008
	,5.985351176e-008
	,6.075636249e-008
	,6.166745999e-008
	,6.258656756e-008
	,6.351341262e-008
	,6.444768494e-008
	,6.538903531e-008
	,6.633707575e-008
	,6.729138112e-008
	,6.825149201e-008
	,6.921691892e-008
	,7.018714789e-008
	,7.116164678e-008
	,7.213987135e-008
	,7.312127134e-008
	,7.410529323e-008
	,7.509138073e-008
	,7.607897085e-008
	,7.706748670e-008
	,7.805632691e-008
	,7.904485271e-008
	,8.003237603e-008
	,8.101815135e-008
	,8.200137364e-008
	,8.298117533e-008
	,8.395662873e-008
	,8.492675655e-008
	,8.589054335e-008
	,8.684694864e-008
	,8.779491950e-008
	,8.873339904e-008
	,8.966133179e-008
	,9.057767174e-008
	,9.148139964e-008
	,9.237155332e-008
	,9.324727009e-008
	,9.410784054e-008
	,9.495276934e-008
	,9.578183830e-008
	,9.659516643e-008
	,9.739325614e-008
	,9.817701450e-008
	,9.894773539e-008
	,9.970703557e-008
	,1.004567411e-007
	,1.011987187e-007
	,1.019347591e-007
	,1.026667558e-007
	,1.033964315e-007
	,1.041251828e-007
	,1.048541415e-007
	,1.055842144e-007
	,1.063161161e-007
	,1.070504034e-007
	,1.077875051e-007
	,1.085277496e-007
	,1.092713871e-007
	,1.100186075e-007
	,1.107695551e-007
	,1.115243390e-007
	,1.122830416e-007
	,1.130457237e-007
	,1.138124211e-007
	,1.145831044e-007
	,1.153576483e-007
	,1.161361625e-007
	,1.169187774e-007
	,1.177055263e-007
	,1.184964116e-007
	,1.192914272e-007
	,1.200905647e-007
	,1.208938144e-007
	,1.217011658e-007
	,1.225126076e-007
	,1.233281275e-007
	,1.241477125e-007
	,1.249713481e-007
	,1.257990191e-007
	,1.266307080e-007
	,1.274663958e-007
	,1.283060598e-007
	,1.291496701e-007
	,1.299971830e-007
	,1.308485744e-007
	,1.317038252e-007
	,1.325628980e-007
	,1.334257451e-007
	,1.342923099e-007
	,1.351625244e-007
	,1.360363077e-007
	,1.369135710e-007
	,1.377942173e-007
	,1.386781314e-007
	,1.395651769e-007
	,1.404551968e-007
	,1.413480131e-007
	,1.422434246e-007
	,1.431412057e-007
	,1.440411062e-007
	,1.449428501e-007
	,1.458461382e-007
	,1.467506513e-007
	,1.476560578e-007
	,1.485620222e-007
	,1.494682114e-007
	,1.503743073e-007
	,1.512800198e-007
	,1.521851006e-007
	,1.530893561e-007
	,1.539926597e-007
	,1.548949608e-007
	,-2.564650578e-007
	,-1.986598291e-007
	,-1.530317164e-007
	,-1.172772295e-007
	,-8.962545527e-008
	,-6.845164091e-008
	,-5.230634704e-008
	,-4.000388042e-008
	,-3.061418671e-008
	,-2.342280461e-008
	,-1.789596723e-008
	,-1.364972387e-008
	,-1.039835251e-008
	,-7.912844735e-009
	,-6.012386586e-009
	,-4.558746686e-009
	,-3.446549845e-009
	,-2.597374876e-009
	,-1.951908742e-009
	,-1.463447512e-009
	,-1.095514910e-009
	,-8.196771205e-010
	,-6.134987264e-010
	,-4.594980746e-010
	,-3.443573694e-010
	,-2.581007164e-010
	,-1.933729208e-010
	,-1.447930440e-010
	,-1.083483969e-010
	,-8.099700994e-011
	,-6.044754873e-011
	,-4.498939122e-011
	,-3.334051095e-011
	,-2.453648768e-011
	,-1.785336082e-011
	,-1.275039800e-011
	,-8.826436467e-012
	,-5.786298397e-012
	,-3.409294069e-012
	,-1.524650787e-012
	,3.169516654e-017
	,1.265732263e-012
	,2.347961113e-012
	,3.303000547e-012
	,4.175437236e-012
	,5.005892068e-012
	,5.835018149e-012
	,6.698694132e-012
	,7.636962399e-012
	,8.692250423e-012
	,9.911872238e-012
	,1.135511071e-011
	,1.310790938e-011
	,1.526742370e-011
	,1.797980244e-011
	,2.142984470e-011
	,2.587279846e-011
	,3.165110436e-011
	,3.922951179e-011
	,4.923987037e-011
	,6.254031628e-011
	,8.022934159e-011
	,1.038850744e-010
	,1.356512821e-010
	,1.784221942e-010
	,2.361320655e-010
	,3.139834426e-010
	,4.188014173e-010
	,5.604796056e-010
	,7.520084674e-010
	,1.010825419e-009
	,1.360240399e-009
	,1.831277361e-009
	,2.465047930e-009
	,3.315816508e-009
	,4.454978076e-009
	,5.976248357e-009
	,7.987077512e-009
	,1.056315517e-008
	,1.391960009e-008
	,1.826918492e-008
	,2.378059792e-008
	,3.073473148e-008
	,3.962585377e-008
	,5.096786512e-008
	,6.540526002e-008
	,8.374527908e-008
	,1.069975210e-007
	,1.364237788e-007
	,1.735986420e-007
	,2.204849609e-007
	,2.795270639e-007
	,3.537661407e-007
	,4.469833443e-007
	,5.634754713e-007
	,7.077330824e-007
	,8.848938818e-007
	,1.102371544e-006
	,1.370462777e-006
	,1.700088996e-006
	,2.104458332e-006
	,2.599364443e-006
	,3.182032571e-006
	,3.834573715e-006
	,4.588155078e-006
	,5.409966924e-006
	,6.366701898e-006
	,7.480092796e-006
	,8.769876228e-006
	,1.025719326e-005
	,1.196451478e-005
	,1.391557106e-005
	,1.613529951e-005
	,1.864982135e-005
	,2.148645374e-005
	,2.467375428e-005
	,2.824157699e-005
	,3.200013527e-005
	,3.611852763e-005
	,4.062427881e-005
	,4.553506780e-005
	,5.086867861e-005
	,5.662535114e-005
	,6.230761972e-005
	,6.811177657e-005
	,7.360087506e-005
	,7.917008640e-005
	,8.514534629e-005
	,9.152285415e-005
	,9.830406947e-005
	,1.054933082e-004
	,1.130974153e-004
	,1.211253152e-004
	,1.295875851e-004
	,1.384962197e-004
	,1.478603353e-004
	,1.574538790e-004
	,1.671040594e-004
	,1.771546674e-004
	,1.876201564e-004
	,1.984223883e-004
	,2.094927179e-004
	,2.207887079e-004
	,2.322566841e-004
	,2.431517856e-004
	,2.545005892e-004
	,2.661807178e-004
	,2.780210162e-004
	,2.902638848e-004
	,3.029237034e-004
	,3.157767269e-004
	,3.285876505e-004
	,3.407159156e-004
	,3.533199311e-004
	,3.664929566e-004
	,3.793406313e-004
	,3.919599713e-004
	,4.050213244e-004
	,4.185305839e-004
	,4.324985433e-004
	,4.469390972e-004
	,4.618581517e-004
	,4.772978000e-004
	,4.912227775e-004
	,5.053264408e-004
	,5.202193643e-004
	,5.359582955e-004
	,5.513216955e-004
	,5.647251985e-004
	,5.788826447e-004
	,5.937280155e-004
	,6.091679302e-004
	,6.251696919e-004
	,6.415248956e-004
	,6.557464275e-004
	,6.688725693e-004
	,6.825147831e-004
	,6.965683867e-004
	,7.109299993e-004
	,7.254168330e-004
	,7.399667231e-004
	,7.547790130e-004
	,7.687121876e-004
	,7.811169164e-004
	,7.939208101e-004
	,8.070706132e-004
	,8.205306378e-004
	,8.342749447e-004
	,8.482831407e-004
	,8.625106162e-004
	,8.768676240e-004
	,8.913822923e-004
	,9.061360839e-004
	,9.211174915e-004
	,9.363077308e-004
	,9.516998468e-004
	,9.672877939e-004
	,9.830662964e-004
	,9.990307096e-004
	,1.015209851e-003
	,1.031635367e-003
	,-7.925208320e-007
	,-6.144023007e-007
	,-4.750892688e-007
	,-3.672448721e-007
	,-2.840908033e-007
	,-2.199193826e-007
	,-1.701944517e-007
	,-1.314881990e-007
	,-1.013466847e-007
	,-7.790875857e-008
	,-5.965970286e-008
	,-4.541753923e-008
	,-3.436737662e-008
	,-2.591257659e-008
	,-1.951748555e-008
	,-1.470603538e-008
	,-1.109018988e-008
	,-8.370733260e-009
	,-6.322844084e-009
	,-4.778028475e-009
	,-3.610176267e-009
	,-2.725648680e-009
	,-2.055827219e-009
	,-1.549512765e-009
	,-1.167252712e-009
	,-8.786729331e-010
	,-6.606840884e-010
	,-4.958931820e-010
	,-3.712324397e-010
	,-2.769200372e-010
	,-2.056705365e-010
	,-1.519291087e-010
	,-1.114045275e-010
	,-8.085317729e-011
	,-5.786390611e-011
	,-4.060316527e-011
	,-2.763464138e-011
	,-1.783927133e-011
	,-1.036536117e-011
	,-4.576106807e-012
	,-1.566660823e-018
	,3.710117116e-012
	,6.810659657e-012
	,9.494486171e-012
	,1.190986175e-011
	,1.417169087e-011
	,1.636980155e-011
	,1.857674572e-011
	,2.085493350e-011
	,2.326076089e-011
	,2.584676839e-011
	,2.866400789e-011
	,3.176358338e-011
	,3.519789468e-011
	,3.902089795e-011
	,4.329474675e-011
	,4.811103089e-011
	,5.360694221e-011
	,5.996471326e-011
	,6.738632214e-011
	,7.617638249e-011
	,8.675834453e-011
	,9.956111606e-011
	,1.152991617e-010
	,1.349940300e-010
	,1.598692784e-010
	,1.914249402e-010
	,2.322125841e-010
	,2.854844960e-010
	,3.545002136e-010
	,4.457314563e-010
	,5.670489199e-010
	,7.287678680e-010
	,9.452501887e-010
	,1.235808932e-009
	,1.626346273e-009
	,2.151929678e-009
	,2.859504542e-009
	,3.811810715e-009
	,5.092305811e-009
	,6.811372770e-009
	,9.114117990e-009
	,1.219014548e-008
	,1.628582777e-008
	,2.171980308e-008
	,2.890265268e-008
	,3.836189694e-008
	,5.077376671e-008
	,6.700398232e-008
	,8.815872170e-008
	,1.156497574e-007
	,1.509562250e-007
	,1.957488200e-007
	,2.530214104e-007
	,3.260331959e-007
	,4.188413982e-007
	,5.364832953e-007
	,6.851962341e-007
	,8.726240421e-007
	,1.106932434e-006
	,1.381130915e-006
	,1.710901574e-006
	,2.095020331e-006
	,2.540493318e-006
	,3.073551145e-006
	,3.708701302e-006
	,4.462131098e-006
	,5.351739751e-006
	,6.397139419e-006
	,7.619628878e-006
	,9.042147927e-006
	,1.068922240e-005
	,1.258691374e-005
	,1.476278454e-005
	,1.724588484e-005
	,1.997675107e-005
	,2.298151863e-005
	,2.632651023e-005
	,3.003099629e-005
	,3.411593335e-005
	,3.860068919e-005
	,4.331693345e-005
	,4.804444259e-005
	,5.279891099e-005
	,5.744151199e-005
	,6.244739210e-005
	,6.781648861e-005
	,7.355093932e-005
	,7.965821581e-005
	,8.614535153e-005
	,9.299917885e-005
	,1.002418692e-004
	,1.078902074e-004
	,1.159559476e-004
	,1.244516949e-004
	,1.332584209e-004
	,1.421449158e-004
	,1.514188373e-004
	,1.610882810e-004
	,1.711622919e-004
	,1.815381946e-004
	,1.922705268e-004
	,2.030254190e-004
	,2.134034793e-004
	,2.241573745e-004
	,2.352005928e-004
	,2.466230742e-004
	,2.584835418e-004
	,2.708015238e-004
	,2.827131649e-004
	,2.939396368e-004
	,3.056922628e-004
	,3.178559675e-004
	,3.303395304e-004
	,3.433410626e-004
	,3.556576323e-004
	,3.681635281e-004
	,3.810627835e-004
	,3.943359076e-004
	,4.080314193e-004
	,4.221648020e-004
	,4.367554318e-004
	,4.500041020e-004
	,4.626921536e-004
	,4.761034406e-004
	,4.902608377e-004
	,5.052119300e-004
	,5.204086453e-004
	,5.340454116e-004
	,5.483139857e-004
	,5.631880972e-004
	,5.786690676e-004
	,5.946120758e-004
	,6.102700032e-004
	,6.235161947e-004
	,6.370503437e-004
	,6.507984190e-004
	,6.649117271e-004
	,6.792601232e-004
	,6.934391512e-004
	,7.050045392e-004
	,7.169994986e-004
	,7.292871819e-004
	,7.419411921e-004
	,7.549535499e-004
	,7.682644550e-004
	,7.818312395e-004
	,7.956368852e-004
	,8.096692783e-004
	,8.239191065e-004
	,8.383830278e-004
	,8.530461313e-004
	,8.678932730e-004
	,8.829454883e-004
	,8.982056615e-004
	,9.136489940e-004
	,9.292713993e-004
	,9.450692047e-004
	,9.610391391e-004
	,9.771782775e-004
	,9.934974375e-004
	,-2.515796657e-006
	,-1.990364021e-006
	,-1.563942124e-006
	,-1.222176837e-006
	,-9.496073571e-007
	,-7.336231774e-007
	,-5.645041313e-007
	,-4.335325949e-007
	,-3.327905249e-007
	,-2.553439932e-007
	,-1.956422838e-007
	,-1.496177644e-007
	,-1.142735298e-007
	,-8.727086998e-008
	,-6.668346559e-008
	,-5.096574638e-008
	,-3.892460459e-008
	,-2.967947866e-008
	,-2.259733263e-008
	,-1.718475968e-008
	,-1.304411480e-008
	,-9.866097268e-009
	,-7.423185714e-009
	,-5.554064342e-009
	,-4.137826457e-009
	,-3.074858478e-009
	,-2.282083987e-009
	,-1.692774561e-009
	,-1.255169099e-009
	,-9.300625610e-010
	,-6.881948941e-010
	,-5.078888761e-010
	,-3.731344278e-010
	,-2.721121794e-010
	,-1.961034574e-010
	,-1.386950743e-010
	,-9.514226058e-011
	,-6.187627721e-011
	,-3.619864944e-011
	,-1.607940820e-011
	,-2.114779938e-017
	,1.317300951e-011
	,2.428599490e-011
	,3.396857404e-011
	,4.268154052e-011
	,5.076572375e-011
	,5.849424406e-011
	,6.609681493e-011
	,7.375466033e-011
	,8.159203364e-011
	,8.967254799e-011
	,9.800929799e-011
	,1.066106071e-010
	,1.155455098e-010
	,1.249585419e-010
	,1.350216715e-010
	,1.459003204e-010
	,1.577451585e-010
	,1.706966484e-010
	,1.848923942e-010
	,2.004760648e-010
	,2.176196828e-010
	,2.365691426e-010
	,2.576377368e-010
	,2.812119888e-010
	,3.077683406e-010
	,3.379149452e-010
	,3.723485948e-010
	,4.121497511e-010
	,4.587958898e-010
	,5.142446324e-010
	,5.808722729e-010
	,6.617644117e-010
	,7.620717271e-010
	,8.880504380e-010
	,1.047707598e-009
	,1.253320767e-009
	,1.520339421e-009
	,1.871234824e-009
	,2.335430884e-009
	,2.953936240e-009
	,3.778211475e-009
	,4.884405064e-009
	,6.374981750e-009
	,8.388192069e-009
	,1.111126899e-008
	,1.479697776e-008
	,1.978482644e-008
	,2.652841507e-008
	,3.562994145e-008
	,4.788342823e-008
	,6.432866431e-008
	,8.631864464e-008
	,1.153786997e-007
	,1.526477596e-007
	,2.010058681e-007
	,2.635907390e-007
	,3.422876604e-007
	,4.399186631e-007
	,5.629073843e-007
	,7.170837308e-007
	,9.094054566e-007
	,1.148114540e-006
	,1.442895140e-006
	,1.805026203e-006
	,2.247521644e-006
	,2.785250823e-006
	,3.435032806e-006
	,4.215699845e-006
	,5.148128628e-006
	,6.255241628e-006
	,7.561983305e-006
	,9.089668886e-006
	,1.081012914e-005
	,1.277710431e-005
	,1.502103037e-005
	,1.756463396e-005
	,2.043134760e-005
	,2.364386840e-005
	,2.711491148e-005
	,3.061354017e-005
	,3.426311658e-005
	,3.795258906e-005
	,4.195842443e-005
	,4.628757353e-005
	,5.092879735e-005
	,5.590254473e-005
	,6.121968645e-005
	,6.688888062e-005
	,7.291946204e-005
	,7.932150675e-005
	,8.610585993e-005
	,9.328410861e-005
	,1.008685165e-004
	,1.087360489e-004
	,1.167736254e-004
	,1.251829710e-004
	,1.339711340e-004
	,1.431458752e-004
	,1.526654447e-004
	,1.625199035e-004
	,1.721356044e-004
	,1.818772098e-004
	,1.919797401e-004
	,2.024463746e-004
	,2.132732604e-004
	,2.243497603e-004
	,2.348050361e-004
	,2.454180541e-004
	,2.563964691e-004
	,2.678135923e-004
	,2.796726762e-004
	,2.918264693e-004
	,3.041795561e-004
	,3.168018177e-004
	,3.289658412e-004
	,3.412053746e-004
	,3.533847434e-004
	,3.659121412e-004
	,3.788780944e-004
	,3.922609428e-004
	,4.045354135e-004
	,4.168374273e-004
	,4.296812001e-004
	,4.429363471e-004
	,4.568168109e-004
	,4.713779930e-004
	,4.866855253e-004
	,5.003162240e-004
	,5.144728402e-004
	,5.291665060e-004
	,5.444016844e-004
	,5.601959067e-004
	,5.736636111e-004
	,5.870303077e-004
	,6.008290790e-004
	,6.148645049e-004
	,6.260756487e-004
	,6.376778366e-004
	,6.497543859e-004
	,6.622329783e-004
	,6.750175412e-004
	,6.879638557e-004
	,7.011752081e-004
	,7.144922335e-004
	,7.280557874e-004
	,7.418712603e-004
	,7.558904162e-004
	,7.700984928e-004
	,7.844900696e-004
	,7.990619080e-004
	,8.138113446e-004
	,8.287616871e-004
	,8.438597591e-004
	,8.591164133e-004
	,8.745539427e-004
	,8.901687922e-004
	,9.059476653e-004
	,9.218882071e-004
	,9.379882656e-004
	,9.542458885e-004
	,-7.661518400e-006
	,-6.171331432e-006
	,-4.931705342e-006
	,-3.909960367e-006
	,-3.082766601e-006
	,-2.425497582e-006
	,-1.907245943e-006
	,-1.497240093e-006
	,-1.171628093e-006
	,-9.139338884e-007
	,-7.111104477e-007
	,-5.511853778e-007
	,-4.245330117e-007
	,-3.247448944e-007
	,-2.470020925e-007
	,-1.870278564e-007
	,-1.412564593e-007
	,-1.066257803e-007
	,-8.051102414e-008
	,-6.080104906e-008
	,-4.590083238e-008
	,-3.464549528e-008
	,-2.615490889e-008
	,-1.974913762e-008
	,-1.491242272e-008
	,-1.125881380e-008
	,-8.498051303e-009
	,-6.405795509e-009
	,-4.814310137e-009
	,-3.605203877e-009
	,-2.690876600e-009
	,-2.000507650e-009
	,-1.478442340e-009
	,-1.082400396e-009
	,-7.809185294e-010
	,-5.510190509e-010
	,-3.757970622e-010
	,-2.422296435e-010
	,-1.400724972e-010
	,-6.137378301e-011
	,-1.070452549e-017
	,4.878919251e-011
	,8.863187053e-011
	,1.222778983e-010
	,1.517794399e-010
	,1.786639835e-010
	,2.040778227e-010
	,2.288949337e-010
	,2.537879591e-010
	,2.792719512e-010
	,3.057527447e-010
	,3.335937728e-010
	,3.631532135e-010
	,3.947770771e-010
	,4.287913280e-010
	,4.655149999e-010
	,5.052787059e-010
	,5.484285670e-010
	,5.953403533e-010
	,6.464165469e-010
	,7.020692887e-010
	,7.627008777e-010
	,8.286778284e-010
	,9.003046368e-010
	,9.778389993e-010
	,1.061603295e-009
	,1.152156945e-009
	,1.250300871e-009
	,1.356969393e-009
	,1.473137582e-009
	,1.599779180e-009
	,1.737854477e-009
	,1.888324335e-009
	,2.052143446e-009
	,2.230539138e-009
	,2.425561212e-009
	,2.639851023e-009
	,2.878071885e-009
	,3.147204543e-009
	,3.456213584e-009
	,3.812506507e-009
	,4.235822291e-009
	,4.748799968e-009
	,5.381941314e-009
	,6.169147597e-009
	,7.167126026e-009
	,8.448802673e-009
	,1.010896952e-008
	,1.228874496e-008
	,1.516541289e-008
	,1.899172521e-008
	,2.410154892e-008
	,3.094950693e-008
	,4.014668442e-008
	,5.250871001e-008
	,6.912437665e-008
	,9.142908680e-008
	,1.212998632e-007
	,1.611655039e-007
	,2.141316992e-007
	,2.841210428e-007
	,3.760287417e-007
	,4.958938856e-007
	,6.510861353e-007
	,8.505053485e-007
	,1.104788390e-006
	,1.426513813e-006
	,1.830392159e-006
	,2.329729098e-006
	,2.933555797e-006
	,3.667725770e-006
	,4.552889554e-006
	,5.611108203e-006
	,6.865249326e-006
	,8.339410595e-006
	,1.005859836e-005
	,1.196836100e-005
	,1.404021502e-005
	,1.629534121e-005
	,1.868800895e-005
	,2.132816594e-005
	,2.423373666e-005
	,2.741887721e-005
	,3.089418058e-005
	,3.466964255e-005
	,3.875514302e-005
	,4.316033600e-005
	,4.789489994e-005
	,5.296869667e-005
	,5.839191611e-005
	,6.417518458e-005
	,7.032963125e-005
	,7.686692630e-005
	,8.360240067e-005
	,9.064969304e-005
	,9.805584338e-005
	,1.058273384e-004
	,1.139709569e-004
	,1.224728896e-004
	,1.310712197e-004
	,1.396285545e-004
	,1.485204785e-004
	,1.577517862e-004
	,1.673286017e-004
	,1.766783032e-004
	,1.859804913e-004
	,1.956609061e-004
	,2.057246272e-004
	,2.161767990e-004
	,2.268340959e-004
	,2.377436678e-004
	,2.485779062e-004
	,2.596830877e-004
	,2.711966495e-004
	,2.825899178e-004
	,2.941677566e-004
	,3.059821536e-004
	,3.180531092e-004
	,3.305139975e-004
	,3.432488513e-004
	,3.548512031e-004
	,3.667484509e-004
	,3.790589145e-004
	,3.917884862e-004
	,4.049915265e-004
	,4.187161836e-004
	,4.330117036e-004
	,4.479274868e-004
	,4.622829347e-004
	,4.763801741e-004
	,4.909445924e-004
	,5.059827486e-004
	,5.203039281e-004
	,5.334885127e-004
	,5.443178437e-004
	,5.557391018e-004
	,5.675658494e-004
	,5.798024091e-004
	,5.923889361e-004
	,6.052558558e-004
	,6.182168623e-004
	,6.314480098e-004
	,6.449292930e-004
	,6.583781950e-004
	,6.720404669e-004
	,6.859060903e-004
	,6.998570563e-004
	,7.139845651e-004
	,7.283034814e-004
	,7.427883781e-004
	,7.574300519e-004
	,7.722273473e-004
	,7.871804631e-004
	,8.022894405e-004
	,8.175904616e-004
	,8.330149974e-004
	,8.485747086e-004
	,8.643029566e-004
	,8.801887418e-004
	,8.962261410e-004
	,9.124137348e-004
	,-2.142278552e-005
	,-1.779203840e-005
	,-1.472987903e-005
	,-1.213876245e-005
	,-9.948946780e-006
	,-8.112934158e-006
	,-6.562453144e-006
	,-5.242027293e-006
	,-4.141722104e-006
	,-3.250924442e-006
	,-2.543317099e-006
	,-1.985243146e-006
	,-1.543894829e-006
	,-1.195612189e-006
	,-9.245122764e-007
	,-7.149092195e-007
	,-5.523657713e-007
	,-4.255005667e-007
	,-3.265066961e-007
	,-2.498968542e-007
	,-1.908016808e-007
	,-1.450975648e-007
	,-1.097455557e-007
	,-8.258305110e-008
	,-6.190245450e-008
	,-4.625893262e-008
	,-3.448720852e-008
	,-2.567434629e-008
	,-1.909930202e-008
	,-1.419680964e-008
	,-1.053484879e-008
	,-7.790492818e-009
	,-5.723605692e-009
	,-4.166080517e-009
	,-2.992803492e-009
	,-2.109119469e-009
	,-1.441990624e-009
	,-9.347997643e-010
	,-5.450324560e-010
	,-2.411804178e-010
	,-1.258431479e-017
	,1.958390301e-010
	,3.595185746e-010
	,5.011203316e-010
	,6.282784231e-010
	,7.466608777e-010
	,8.603277552e-010
	,9.720758421e-010
	,1.083844970e-009
	,1.197155996e-009
	,1.313562535e-009
	,1.434831784e-009
	,1.562602663e-009
	,1.697859595e-009
	,1.840616231e-009
	,1.989951282e-009
	,2.144444898e-009
	,2.302998432e-009
	,2.465651631e-009
	,2.633688993e-009
	,2.809076638e-009
	,2.993961071e-009
	,3.190447850e-009
	,3.400373841e-009
	,3.625311619e-009
	,3.866663372e-009
	,4.125719446e-009
	,4.403720526e-009
	,4.701996054e-009
	,5.022139200e-009
	,5.366039547e-009
	,5.735803325e-009
	,6.133711393e-009
	,6.562252882e-009
	,7.024154082e-009
	,7.522396146e-009
	,8.060253802e-009
	,8.641382131e-009
	,9.269954272e-009
	,9.950869642e-009
	,1.069009397e-008
	,1.149479796e-008
	,1.237342138e-008
	,1.333668807e-008
	,1.439760062e-008
	,1.557243185e-008
	,1.688220701e-008
	,1.835246945e-008
	,2.002019862e-008
	,2.193712542e-008
	,2.417246146e-008
	,2.681422902e-008
	,2.997333058e-008
	,3.380134022e-008
	,3.855095365e-008
	,4.454256144e-008
	,5.217353182e-008
	,6.202703979e-008
	,7.491235186e-008
	,9.183599844e-008
	,1.142779415e-007
	,1.441144900e-007
	,1.839259138e-007
	,2.370826003e-007
	,3.079635902e-007
	,4.022945475e-007
	,5.273050128e-007
	,6.913930260e-007
	,9.008155334e-007
	,1.170216107e-006
	,1.513327592e-006
	,1.941577781e-006
	,2.463931227e-006
	,3.101353234e-006
	,3.869828016e-006
	,4.787761120e-006
	,5.872439583e-006
	,7.140947194e-006
	,8.609918918e-006
	,1.029534155e-005
	,1.221240154e-005
	,1.437541014e-005
	,1.679782010e-005
	,1.949223391e-005
	,2.247050914e-005
	,2.574389089e-005
	,2.932316987e-005
	,3.321885823e-005
	,3.744135144e-005
	,4.200107855e-005
	,4.690864279e-005
	,5.205757479e-005
	,5.753645605e-005
	,6.335620222e-005
	,6.952276446e-005
	,7.604213877e-005
	,8.292044570e-005
	,8.992396862e-005
	,9.709798434e-005
	,1.045547327e-004
	,1.122586505e-004
	,1.196417206e-004
	,1.273398447e-004
	,1.353284061e-004
	,1.432285858e-004
	,1.514947743e-004
	,1.601298543e-004
	,1.691395464e-004
	,1.785317593e-004
	,1.883161030e-004
	,1.985035234e-004
	,2.090797323e-004
	,2.199281067e-004
	,2.308337171e-004
	,2.417839617e-004
	,2.530802918e-004
	,2.647292358e-004
	,2.766502114e-004
	,2.885882796e-004
	,3.002190309e-004
	,3.120175372e-004
	,3.240754668e-004
	,3.363954845e-004
	,3.490022736e-004
	,3.619260437e-004
	,3.752621789e-004
	,3.890478820e-004
	,4.033488732e-004
	,4.182152347e-004
	,4.321396406e-004
	,4.453452231e-004
	,4.583575659e-004
	,4.691579267e-004
	,4.805865917e-004
	,4.924682065e-004
	,5.047130463e-004
	,5.172687394e-004
	,5.301020663e-004
	,5.431214278e-004
	,5.563790783e-004
	,5.698646444e-004
	,5.835684491e-004
	,5.973684244e-004
	,6.112636827e-004
	,6.250232880e-004
	,6.389636214e-004
	,6.530797573e-004
	,6.673673151e-004
	,6.817805243e-004
	,6.962931984e-004
	,7.109703481e-004
	,7.257947204e-004
	,7.407579676e-004
	,7.558601607e-004
	,7.711029320e-004
	,7.859431479e-004
	,8.002251962e-004
	,8.146459393e-004
	,8.292085370e-004
	,8.439254560e-004
	,8.587865371e-004
	,-5.337817613e-005
	,-4.649134175e-005
	,-4.004248395e-005
	,-3.408142123e-005
	,-2.870125056e-005
	,-2.397805577e-005
	,-1.993289351e-005
	,-1.653064296e-005
	,-1.369247740e-005
	,-1.130696885e-005
	,-9.268124144e-006
	,-7.519093261e-006
	,-6.027538631e-006
	,-4.778695436e-006
	,-3.752526390e-006
	,-2.923016745e-006
	,-2.265989967e-006
	,-1.753931717e-006
	,-1.355541948e-006
	,-1.045066337e-006
	,-8.036034510e-007
	,-6.146265453e-007
	,-4.673800520e-007
	,-3.541346827e-007
	,-2.679060695e-007
	,-2.024308579e-007
	,-1.527850338e-007
	,-1.152164475e-007
	,-8.676453844e-008
	,-6.514941286e-008
	,-4.870171095e-008
	,-3.621413389e-008
	,-2.675967238e-008
	,-1.959115970e-008
	,-1.412978095e-008
	,-9.964747902e-009
	,-6.795457839e-009
	,-4.382424555e-009
	,-2.535981258e-009
	,-1.110296960e-009
	,-1.634389339e-017
	,8.738005871e-010
	,1.578593119e-009
	,2.166462166e-009
	,2.676005907e-009
	,3.135672258e-009
	,3.566209963e-009
	,3.982723094e-009
	,4.396331092e-009
	,4.815332952e-009
	,5.246349432e-009
	,5.694797343e-009
	,6.165222904e-009
	,6.661908073e-009
	,7.189204849e-009
	,7.751751272e-009
	,8.354376923e-009
	,9.001710206e-009
	,9.697989988e-009
	,1.044712361e-008
	,1.125259580e-008
	,1.211706106e-008
	,1.304216414e-008
	,1.402909221e-008
	,1.507923421e-008
	,1.619405650e-008
	,1.737470479e-008
	,1.862279046e-008
	,1.994131340e-008
	,2.133366889e-008
	,2.280347026e-008
	,2.435415770e-008
	,2.598789493e-008
	,2.770467858e-008
	,2.950186275e-008
	,3.137358146e-008
	,3.331004123e-008
	,3.529805880e-008
	,3.732435492e-008
	,3.938067517e-008
	,4.146679399e-008
	,4.358884586e-008
	,4.575578118e-008
	,4.797788969e-008
	,5.026772101e-008
	,5.264076411e-008
	,5.511383583e-008
	,5.770357374e-008
	,6.042519611e-008
	,6.329558118e-008
	,6.633345610e-008
	,6.956018251e-008
	,7.300198654e-008
	,7.669166281e-008
	,8.067380460e-008
	,8.500865643e-008
	,8.977652789e-008
	,9.508028679e-008
	,1.010101817e-007
	,1.077736446e-007
	,1.156091397e-007
	,1.247958883e-007
	,1.358107586e-007
	,1.492584368e-007
	,1.659548651e-007
	,1.869375620e-007
	,2.135756446e-007
	,2.478790260e-007
	,2.923723251e-007
	,3.502086087e-007
	,4.258933333e-007
	,5.248787147e-007
	,6.543545531e-007
	,8.231960015e-007
	,1.042410738e-006
	,1.325283168e-006
	,1.687400680e-006
	,2.146721458e-006
	,2.723178233e-006
	,3.438259441e-006
	,4.314455075e-006
	,5.374506430e-006
	,6.640748976e-006
	,8.134531084e-006
	,9.875789558e-006
	,1.188281410e-005
	,1.415747989e-005
	,1.670530051e-005
	,1.954954694e-005
	,2.269960832e-005
	,2.616361506e-005
	,2.994870332e-005
	,3.406127771e-005
	,3.844310970e-005
	,4.310865838e-005
	,4.791497713e-005
	,5.284750228e-005
	,5.806128766e-005
	,6.355912046e-005
	,6.934418624e-005
	,7.542020902e-005
	,8.179153944e-005
	,8.846321888e-005
	,9.544101473e-005
	,1.027314732e-004
	,1.103419470e-004
	,1.182805622e-004
	,1.265561828e-004
	,1.351783425e-004
	,1.441573121e-004
	,1.535021369e-004
	,1.632096051e-004
	,1.732653215e-004
	,1.834032645e-004
	,1.938843417e-004
	,2.046978669e-004
	,2.155521738e-004
	,2.261719185e-004
	,2.371039706e-004
	,2.483686219e-004
	,2.599916551e-004
	,2.719473390e-004
	,2.840676858e-004
	,2.965261634e-004
	,3.091024604e-004
	,3.213386474e-004
	,3.334463247e-004
	,3.460294362e-004
	,3.591442760e-004
	,3.726182258e-004
	,3.856121250e-004
	,3.972341020e-004
	,4.090393063e-004
	,4.211993373e-004
	,4.336518758e-004
	,4.463610058e-004
	,4.593043800e-004
	,4.724671368e-004
	,4.858389354e-004
	,4.994124066e-004
	,5.131685113e-004
	,5.270794241e-004
	,5.411772067e-004
	,5.554590329e-004
	,5.697571202e-004
	,5.837111485e-004
	,5.978105876e-004
	,6.120695343e-004
	,6.264858362e-004
	,6.403511813e-004
	,6.539363659e-004
	,6.676528762e-004
	,6.815134636e-004
	,6.955104497e-004
	,7.096343578e-004
	,7.238777191e-004
	,7.382399079e-004
	,7.527217296e-004
	,7.673466060e-004
	,7.821086222e-004
	,7.969892750e-004
	,-1.043882516e-004
	,-9.429523510e-005
	,-8.450106013e-005
	,-7.520709839e-005
	,-6.661781894e-005
	,-5.879029232e-005
	,-5.164688115e-005
	,-4.505692522e-005
	,-3.902129864e-005
	,-3.358994292e-005
	,-2.874320043e-005
	,-2.438995199e-005
	,-2.042117591e-005
	,-1.683114035e-005
	,-1.370767513e-005
	,-1.108078978e-005
	,-8.913313348e-006
	,-7.152214264e-006
	,-5.731404868e-006
	,-4.582663266e-006
	,-3.646908622e-006
	,-2.880749163e-006
	,-2.254889679e-006
	,-1.744891443e-006
	,-1.329665610e-006
	,-1.003697230e-006
	,-7.543877010e-007
	,-5.648811371e-007
	,-4.220702636e-007
	,-3.151502043e-007
	,-2.350583433e-007
	,-1.747025542e-007
	,-1.289271372e-007
	,-9.418975206e-008
	,-6.790447719e-008
	,-4.800721681e-008
	,-3.287425094e-008
	,-2.128855451e-008
	,-1.236645154e-008
	,-5.442615554e-009
	,-8.824736189e-018
	,4.358033451e-009
	,7.929461458e-009
	,1.093485528e-008
	,1.353615694e-008
	,1.584742373e-008
	,1.794738715e-008
	,1.990231867e-008
	,2.177003194e-008
	,2.360552924e-008
	,2.543463495e-008
	,2.726818363e-008
	,2.911306184e-008
	,3.097800597e-008
	,3.287463081e-008
	,3.481800827e-008
	,3.682267536e-008
	,3.889866132e-008
	,4.105221297e-008
	,4.328885961e-008
	,4.561458070e-008
	,4.803562945e-008
	,5.055867300e-008
	,5.319071223e-008
	,5.593907486e-008
	,5.881181540e-008
	,6.181696574e-008
	,6.496123317e-008
	,6.824928877e-008
	,7.168314923e-008
	,7.526185633e-008
	,7.898247356e-008
	,8.284198048e-008
	,8.683956431e-008
	,9.097667076e-008
	,9.525127080e-008
	,9.965579631e-008
	,1.041779762e-007
	,1.088042767e-007
	,1.135247936e-007
	,1.183338666e-007
	,1.232260085e-007
	,1.281931245e-007
	,1.332257366e-007
	,1.383162091e-007
	,1.434602267e-007
	,1.486556769e-007
	,1.539013314e-007
	,1.591966013e-007
	,1.645414388e-007
	,1.699357493e-007
	,1.753788991e-007
	,1.808696708e-007
	,1.864064900e-007
	,1.919867362e-007
	,1.976089215e-007
	,2.032739706e-007
	,2.089833574e-007
	,2.147409676e-007
	,2.205549446e-007
	,2.264408149e-007
	,2.324262409e-007
	,2.385573117e-007
	,2.449066895e-007
	,2.515128473e-007
	,2.585032048e-007
	,2.660623662e-007
	,2.744088261e-007
	,2.838212724e-007
	,2.946830534e-007
	,3.074958369e-007
	,3.229158618e-007
	,3.418315092e-007
	,3.653882535e-007
	,3.950926648e-007
	,4.330214539e-007
	,4.819159241e-007
	,5.451713924e-007
	,6.273068255e-007
	,7.340437374e-007
	,8.727014750e-007
	,1.052237353e-006
	,1.283847085e-006
	,1.581002836e-006
	,1.959722983e-006
	,2.438574309e-006
	,3.038546259e-006
	,3.782743768e-006
	,4.695661807e-006
	,5.802511944e-006
	,7.128206112e-006
	,8.696423002e-006
	,1.052880158e-005
	,1.264426910e-005
	,1.505867181e-005
	,1.778467898e-005
	,2.083192937e-005
	,2.420736299e-005
	,2.791566641e-005
	,3.195977660e-005
	,3.634138213e-005
	,4.106138201e-005
	,4.612028993e-005
	,5.151859099e-005
	,5.725700608e-005
	,6.333670152e-005
	,6.975943820e-005
	,7.652766409e-005
	,8.364455666e-005
	,9.111402346e-005
	,9.893741751e-005
	,1.070939487e-004
	,1.155300735e-004
	,1.243087688e-004
	,1.333443464e-004
	,1.425928243e-004
	,1.521636613e-004
	,1.620601176e-004
	,1.722373775e-004
	,1.823674396e-004
	,1.925512697e-004
	,2.029111686e-004
	,2.135673205e-004
	,2.245273040e-004
	,2.357999441e-004
	,2.473972115e-004
	,2.593371741e-004
	,2.715603454e-004
	,2.841119972e-004
	,2.969802674e-004
	,3.098519167e-004
	,3.218599458e-004
	,3.341417240e-004
	,3.466725327e-004
	,3.594302906e-004
	,3.723935530e-004
	,3.855606872e-004
	,3.989250151e-004
	,4.124807671e-004
	,4.262244665e-004
	,4.401529742e-004
	,4.542637236e-004
	,4.685546997e-004
	,4.824260219e-004
	,4.961485850e-004
	,5.100211174e-004
	,5.236742920e-004
	,5.370901181e-004
	,5.506288257e-004
	,5.640520906e-004
	,5.773386624e-004
	,5.907499223e-004
	,6.042827882e-004
	,6.179344251e-004
	,6.317138340e-004
	,6.456293853e-004
	,6.596559387e-004
	,6.737877345e-004
	,6.880184698e-004
	,7.023453686e-004
	,7.167699188e-004
	,-1.616481220e-004
	,-1.503990540e-004
	,-1.395144046e-004
	,-1.290327774e-004
	,-1.189768464e-004
	,-1.093344967e-004
	,-1.000886577e-004
	,-9.122589784e-005
	,-8.270638071e-005
	,-7.450555600e-005
	,-6.661017375e-005
	,-5.899898180e-005
	,-5.165960610e-005
	,-4.469898553e-005
	,-3.827923858e-005
	,-3.249320631e-005
	,-2.738096946e-005
	,-2.294028023e-005
	,-1.912541750e-005
	,-1.586779003e-005
	,-1.309297714e-005
	,-1.073373387e-005
	,-8.744398313e-006
	,-7.084529094e-006
	,-5.706093739e-006
	,-4.562471429e-006
	,-3.613285143e-006
	,-2.827618744e-006
	,-2.182518199e-006
	,-1.654169365e-006
	,-1.231148870e-006
	,-9.068856773e-007
	,-6.633614306e-007
	,-4.807376486e-007
	,-3.431358650e-007
	,-2.396777615e-007
	,-1.621232358e-007
	,-1.038258221e-007
	,-5.970577017e-008
	,-2.600012574e-008
	,2.417600932e-017
	,2.022976056e-008
	,3.613250952e-008
	,4.879562150e-008
	,5.905805912e-008
	,6.758096905e-008
	,7.488045052e-008
	,8.138165541e-008
	,8.738464111e-008
	,9.309189813e-008
	,9.862678932e-008
	,1.040220184e-007
	,1.092615226e-007
	,1.143483706e-007
	,1.192789121e-007
	,1.240601315e-007
	,1.287622493e-007
	,1.334604494e-007
	,1.381941277e-007
	,1.429876495e-007
	,1.478545757e-007
	,1.527971485e-007
	,1.578078140e-007
	,1.628707438e-007
	,1.679597891e-007
	,1.730371376e-007
	,1.780632766e-007
	,1.830128777e-007
	,1.878719583e-007
	,1.926285463e-007
	,1.972766025e-007
	,2.018233198e-007
	,2.062842029e-007
	,2.106734771e-007
	,2.150020646e-007
	,2.192791310e-007
	,2.235132211e-007
	,2.277140883e-007
	,2.318930600e-007
	,2.360618153e-007
	,2.402306756e-007
	,2.444051729e-007
	,2.485865888e-007
	,2.527733966e-007
	,2.569617633e-007
	,2.611455125e-007
	,2.653159716e-007
	,2.694627172e-007
	,2.735765792e-007
	,2.776531190e-007
	,2.816918783e-007
	,2.856924979e-007
	,2.896525806e-007
	,2.935686130e-007
	,2.974386872e-007
	,3.012642084e-007
	,3.050487128e-007
	,3.087960623e-007
	,3.125101745e-007
	,3.161955581e-007
	,3.198569458e-007
	,3.234988106e-007
	,3.271283544e-007
	,3.307529741e-007
	,3.343816888e-007
	,3.380259223e-007
	,3.417005878e-007
	,3.454255470e-007
	,3.492275063e-007
	,3.531425978e-007
	,3.572016231e-007
	,3.614310897e-007
	,3.659276847e-007
	,3.707873389e-007
	,3.761368245e-007
	,3.821462808e-007
	,3.890410879e-007
	,3.971205320e-007
	,4.067816667e-007
	,4.185506181e-007
	,4.331235522e-007
	,4.514200434e-007
	,4.746500457e-007
	,5.043870269e-007
	,5.427265819e-007
	,5.922449300e-007
	,6.565127607e-007
	,7.400403114e-007
	,8.485148890e-007
	,9.892121133e-007
	,1.171193018e-006
	,1.405587354e-006
	,1.705958492e-006
	,2.088484461e-006
	,2.572045976e-006
	,3.177962676e-006
	,3.930413575e-006
	,4.855247658e-006
	,5.979328819e-006
	,7.330513534e-006
	,8.935797962e-006
	,1.082068092e-005
	,1.300833051e-005
	,1.551899160e-005
	,1.836770375e-005
	,2.156491987e-005
	,2.512269665e-005
	,2.904752357e-005
	,3.334323645e-005
	,3.801148277e-005
	,4.305218803e-005
	,4.846399439e-005
	,5.424467232e-005
	,6.039144463e-005
	,6.690127812e-005
	,7.377040068e-005
	,8.099151918e-005
	,8.856561850e-005
	,9.649043939e-005
	,1.047643531e-004
	,1.133864862e-004
	,1.223568060e-004
	,1.316761687e-004
	,1.413454702e-004
	,1.513502934e-004
	,1.617114403e-004
	,1.720841029e-004
	,1.826840666e-004
	,1.934965185e-004
	,2.046199269e-004
	,2.160550651e-004
	,2.277239742e-004
	,2.395783569e-004
	,2.515529796e-004
	,2.635221133e-004
	,2.756558422e-004
	,2.879624159e-004
	,3.004506920e-004
	,3.131186575e-004
	,3.259596025e-004
	,3.389645633e-004
	,3.521295958e-004
	,3.654491457e-004
	,3.789175474e-004
	,3.925305553e-004
	,4.062836824e-004
	,4.201720349e-004
	,4.341924382e-004
	,4.483378114e-004
	,4.626080211e-004
	,4.769340217e-004
	,4.904658245e-004
	,5.041173785e-004
	,5.178807921e-004
	,5.317596192e-004
	,5.457524515e-004
	,5.598579221e-004
	,5.740746289e-004
	,5.884140486e-004
	,6.028646237e-004
	,6.174219972e-004
	,-2.023918036e-004
	,-1.900045779e-004
	,-1.780165209e-004
	,-1.664416887e-004
	,-1.552763103e-004
	,-1.445057890e-004
	,-1.341297000e-004
	,-1.241837643e-004
	,-1.147058447e-004
	,-1.057120297e-004
	,-9.719848395e-005
	,-8.912885338e-005
	,-8.141675595e-005
	,-7.393817429e-005
	,-6.661470909e-005
	,-5.947513316e-005
	,-5.261835669e-005
	,-4.615589658e-005
	,-4.014083234e-005
	,-3.458002037e-005
	,-2.949377677e-005
	,-2.491734245e-005
	,-2.085691607e-005
	,-1.729027656e-005
	,-1.417738231e-005
	,-1.148333435e-005
	,-9.194439286e-006
	,-7.281403091e-006
	,-5.701098706e-006
	,-4.409075099e-006
	,-3.365470808e-006
	,-2.534355070e-006
	,-1.880798776e-006
	,-1.371790046e-006
	,-9.787751470e-007
	,-6.786229855e-007
	,-4.527463961e-007
	,-2.846899590e-007
	,-1.601891661e-007
	,-6.809906744e-008
	,9.397249016e-019
	,5.044740149e-008
	,8.800054970e-008
	,1.161675441e-007
	,1.375490652e-007
	,1.540854791e-007
	,1.671692999e-007
	,1.777763537e-007
	,1.865895089e-007
	,1.941025830e-007
	,2.007283869e-007
	,2.067576007e-007
	,2.123713473e-007
	,2.176835569e-007
	,2.227595779e-007
	,2.276216821e-007
	,2.322863435e-007
	,2.367880205e-007
	,2.411662793e-007
	,2.454600005e-007
	,2.496850167e-007
	,2.538497266e-007
	,2.579590660e-007
	,2.620121841e-007
	,2.660194760e-007
	,2.699891204e-007
	,2.739216137e-007
	,2.778146410e-007
	,2.816645009e-007
	,2.854638347e-007
	,2.891988971e-007
	,2.928494185e-007
	,2.964059865e-007
	,2.998858777e-007
	,3.033132859e-007
	,3.067038872e-007
	,3.100660229e-007
	,3.134034293e-007
	,3.167164878e-007
	,3.200037923e-007
	,3.232628966e-007
	,3.264897886e-007
	,3.296815762e-007
	,3.328379829e-007
	,3.359589542e-007
	,3.390453522e-007
	,3.420999614e-007
	,3.451259661e-007
	,3.481266009e-007
	,3.511048983e-007
	,3.540633592e-007
	,3.570039663e-007
	,3.599282347e-007
	,3.628372572e-007
	,3.657316473e-007
	,3.686114355e-007
	,3.714759791e-007
	,3.743238556e-007
	,3.771528413e-007
	,3.799603021e-007
	,3.827441313e-007
	,3.855036603e-007
	,3.882400505e-007
	,3.909561943e-007
	,3.936560297e-007
	,3.963437353e-007
	,3.990234032e-007
	,4.016979134e-007
	,4.043710488e-007
	,4.070454528e-007
	,4.097238366e-007
	,4.124098262e-007
	,4.151089709e-007
	,4.178302330e-007
	,4.205867073e-007
	,4.233957877e-007
	,4.262796403e-007
	,4.292387577e-007
	,4.323177645e-007
	,4.355560438e-007
	,4.390045458e-007
	,4.427303711e-007
	,4.468222600e-007
	,4.513978657e-007
	,4.566133575e-007
	,4.626761139e-007
	,4.698614197e-007
	,4.785344509e-007
	,4.891787696e-007
	,5.024344024e-007
	,5.191466115e-007
	,5.404292167e-007
	,5.677464657e-007
	,6.028954885e-007
	,6.484144139e-007
	,7.075358457e-007
	,7.844014669e-007
	,8.843053409e-007
	,1.013954733e-006
	,1.181772494e-006
	,1.398185422e-006
	,1.675915162e-006
	,2.030230162e-006
	,2.479129373e-006
	,3.043321115e-006
	,3.746115675e-006
	,4.613000998e-006
	,5.671080835e-006
	,6.948241325e-006
	,8.472246577e-006
	,1.026976913e-005
	,1.236552280e-005
	,1.478155388e-005
	,1.753678951e-005
	,2.064682934e-005
	,2.412398600e-005
	,2.797751726e-005
	,3.221399404e-005
	,3.683317251e-005
	,4.183920839e-005
	,4.723271481e-005
	,5.301286753e-005
	,5.917802943e-005
	,6.572602380e-005
	,7.265435360e-005
	,7.996037250e-005
	,8.764141766e-005
	,9.569489793e-005
	,1.041184021e-004
	,1.128925018e-004
	,1.220205829e-004
	,1.315042598e-004
	,1.413400877e-004
	,1.513527591e-004
	,1.614001199e-004
	,1.717637205e-004
	,1.824356917e-004
	,1.934088236e-004
	,2.046727861e-004
	,2.162227272e-004
	,2.280441411e-004
	,2.401271398e-004
	,2.524580081e-004
	,2.650313405e-004
	,2.778443900e-004
	,2.908913125e-004
	,3.041677560e-004
	,3.176668389e-004
	,3.313816982e-004
	,3.453073713e-004
	,3.594381662e-004
	,3.737678916e-004
	,3.882916451e-004
	,4.030045456e-004
	,4.179019289e-004
	,4.328682528e-004
	,4.468854968e-004
	,4.608587970e-004
	,4.749780321e-004
	,4.892417543e-004
	,5.036483362e-004
	,-2.323893138e-004
	,-2.194258481e-004
	,-2.067434546e-004
	,-1.943405709e-004
	,-1.822640708e-004
	,-1.705798677e-004
	,-1.593366662e-004
	,-1.485605506e-004
	,-1.382354183e-004
	,-1.282993247e-004
	,-1.186818872e-004
	,-1.093595133e-004
	,-1.002962086e-004
	,-9.147831228e-005
	,-8.295725253e-005
	,-7.480913943e-005
	,-6.709049847e-005
	,-5.982924287e-005
	,-5.302966277e-005
	,-4.667814567e-005
	,-4.075555836e-005
	,-3.526376311e-005
	,-3.021989981e-005
	,-2.563280529e-005
	,-2.150434381e-005
	,-1.783067113e-005
	,-1.460050794e-005
	,-1.179438251e-005
	,-9.387455766e-006
	,-7.352090604e-006
	,-5.658559759e-006
	,-4.275381166e-006
	,-3.168622342e-006
	,-2.300393543e-006
	,-1.631147160e-006
	,-1.123227982e-006
	,-7.429704518e-007
	,-4.618041758e-007
	,-2.562940840e-007
	,-1.073552817e-007
	,-1.817146633e-017
	,7.712061418e-008
	,1.325164002e-007
	,1.724783488e-007
	,2.015402587e-007
	,2.229234136e-007
	,2.388972570e-007
	,2.510768726e-007
	,2.606119669e-007
	,2.682969618e-007
	,2.746805586e-007
	,2.801427493e-007
	,2.849465163e-007
	,2.892742100e-007
	,2.932538064e-007
	,2.969765529e-007
	,3.005056437e-007
	,3.038825489e-007
	,3.071355005e-007
	,3.102861194e-007
	,3.133509321e-007
	,3.163470797e-007
	,3.192889326e-007
	,3.221856907e-007
	,3.250474512e-007
	,3.278847645e-007
	,3.307040251e-007
	,3.335086834e-007
	,3.363007701e-007
	,3.390813806e-007
	,3.418504816e-007
	,3.446080794e-007
	,3.473557783e-007
	,3.500941989e-007
	,3.528231024e-007
	,3.555419934e-007
	,3.582497558e-007
	,3.609448026e-007
	,3.636263625e-007
	,3.662955456e-007
	,3.689550793e-007
	,3.716080764e-007
	,3.742570622e-007
	,3.769036998e-007
	,3.795488395e-007
	,3.821929430e-007
	,3.848364369e-007
	,3.874797751e-007
	,3.901233612e-007
	,3.927677040e-007
	,3.954135902e-007
	,3.980619940e-007
	,4.007138250e-007
	,4.033698375e-007
	,4.060305996e-007
	,4.086964531e-007
	,4.113676205e-007
	,4.140442655e-007
	,4.167264917e-007
	,4.194143462e-007
	,4.221077994e-007
	,4.248066920e-007
	,4.275106930e-007
	,4.302194476e-007
	,4.329329848e-007
	,4.356518394e-007
	,4.383767261e-007
	,4.411082639e-007
	,4.438469212e-007
	,4.465930518e-007
	,4.493469321e-007
	,4.521087775e-007
	,4.548787391e-007
	,4.576565111e-007
	,4.604421189e-007
	,4.632355616e-007
	,4.660371255e-007
	,4.688481491e-007
	,4.716715595e-007
	,4.745117943e-007
	,4.773744606e-007
	,4.802663363e-007
	,4.831958000e-007
	,4.861669248e-007
	,4.891900238e-007
	,4.922832852e-007
	,4.954664710e-007
	,4.987656968e-007
	,5.022154924e-007
	,5.058616472e-007
	,5.097648694e-007
	,5.140057497e-007
	,5.186912902e-007
	,5.239635488e-007
	,5.300111109e-007
	,5.370841989e-007
	,5.455145764e-007
	,5.557417082e-007
	,5.683470248e-007
	,5.840986314e-007
	,6.040093615e-007
	,6.293102400e-007
	,6.617723999e-007
	,7.036704185e-007
	,7.579319431e-007
	,8.283368183e-007
	,9.197312457e-007
	,1.038276869e-006
	,1.191730656e-006
	,1.389744415e-006
	,1.644163556e-006
	,1.969296283e-006
	,2.382110240e-006
	,2.902317518e-006
	,3.552289208e-006
	,4.356756095e-006
	,5.342308358e-006
	,6.536659031e-006
	,7.967762711e-006
	,9.662860526e-006
	,1.164763477e-005
	,1.394537880e-005
	,1.657646477e-005
	,1.955804181e-005
	,2.290398586e-005
	,2.662504977e-005
	,3.072916841e-005
	,3.522186613e-005
	,4.010668483e-005
	,4.538561392e-005
	,5.105949637e-005
	,5.712838795e-005
	,6.359184813e-005
	,7.044918976e-005
	,7.769967564e-005
	,8.534267104e-005
	,9.336004746e-005
	,1.017422531e-004
	,1.105022328e-004
	,1.196376228e-004
	,1.291459676e-004
	,1.387908186e-004
	,1.485414999e-004
	,1.586295501e-004
	,1.690476630e-004
	,1.797887517e-004
	,1.908462157e-004
	,2.022131879e-004
	,2.138832078e-004
	,2.258497537e-004
	,2.381065662e-004
	,2.506473568e-004
	,2.634660043e-004
	,2.765566229e-004
	,2.899134357e-004
	,3.035309300e-004
	,3.174034117e-004
	,3.315264067e-004
	,3.458947565e-004
	,3.605035474e-004
	,3.753484638e-004
	,-2.575819172e-004
	,-2.439103792e-004
	,-2.304940882e-004
	,-2.173767341e-004
	,-2.046372690e-004
	,-1.923292344e-004
	,-1.804430948e-004
	,-1.689189395e-004
	,-1.576776237e-004
	,-1.466723460e-004
	,-1.359065630e-004
	,-1.254071955e-004
	,-1.152249475e-004
	,-1.054079062e-004
	,-9.597730025e-005
	,-8.694094903e-005
	,-7.831681371e-005
	,-7.011994648e-005
	,-6.234682901e-005
	,-5.500200444e-005
	,-4.812172507e-005
	,-4.173459421e-005
	,-3.585357689e-005
	,-3.048435919e-005
	,-2.563129803e-005
	,-2.129582127e-005
	,-1.746980229e-005
	,-1.413602559e-005
	,-1.127071930e-005
	,-8.844697795e-006
	,-6.823717643e-006
	,-5.169183271e-006
	,-3.839664587e-006
	,-2.791586262e-006
	,-1.980386064e-006
	,-1.363022495e-006
	,-9.002972108e-007
	,-5.585535332e-007
	,-3.093688272e-007
	,-1.293134787e-007
	,-2.454339116e-018
	,9.253436936e-008
	,1.586660890e-007
	,2.059851298e-007
	,2.399771477e-007
	,2.645683496e-007
	,2.825438462e-007
	,2.958768210e-007
	,3.059588355e-007
	,3.137673797e-007
	,3.199976279e-007
	,3.251400533e-007
	,3.295301263e-007
	,3.333968452e-007
	,3.368975558e-007
	,3.401410426e-007
	,3.432026856e-007
	,3.461351080e-007
	,3.489750083e-007
	,3.517475721e-007
	,3.544723930e-007
	,3.571648138e-007
	,3.598349873e-007
	,3.624900389e-007
	,3.651350285e-007
	,3.677733191e-007
	,3.704070797e-007
	,3.730376103e-007
	,3.756653811e-007
	,3.782901928e-007
	,3.809118651e-007
	,3.835296326e-007
	,3.861423548e-007
	,3.887498588e-007
	,3.913541229e-007
	,3.939584137e-007
	,3.965655300e-007
	,3.991773830e-007
	,4.017949824e-007
	,4.044192348e-007
	,4.070510922e-007
	,4.096910857e-007
	,4.123395574e-007
	,4.149967599e-007
	,4.176628904e-007
	,4.203381053e-007
	,4.230225283e-007
	,4.257162642e-007
	,4.284194368e-007
	,4.311321740e-007
	,4.338545754e-007
	,4.365867284e-007
	,4.393287108e-007
	,4.420805907e-007
	,4.448424280e-007
	,4.476142734e-007
	,4.503961531e-007
	,4.531880921e-007
	,4.559901748e-007
	,4.588024875e-007
	,4.616250955e-007
	,4.644580535e-007
	,4.673014145e-007
	,4.701552343e-007
	,4.730195758e-007
	,4.758945114e-007
	,4.787801231e-007
	,4.816764997e-007
	,4.845837364e-007
	,4.875019349e-007
	,4.904312030e-007
	,4.933716575e-007
	,4.963234282e-007
	,4.992866601e-007
	,5.022615125e-007
	,5.052481622e-007
	,5.082468104e-007
	,5.112576866e-007
	,5.142810513e-007
	,5.173170761e-007
	,5.203660221e-007
	,5.234283072e-007
	,5.265042492e-007
	,5.295940733e-007
	,5.326978038e-007
	,5.358153189e-007
	,5.389471523e-007
	,5.420959205e-007
	,5.452664305e-007
	,5.484635390e-007
	,5.516897744e-007
	,5.549540916e-007
	,5.582645907e-007
	,5.616316858e-007
	,5.650689887e-007
	,5.685944340e-007
	,5.722317406e-007
	,5.760123376e-007
	,5.799779152e-007
	,5.841838067e-007
	,5.887034559e-007
	,5.936343720e-007
	,5.991060139e-007
	,6.052901705e-007
	,6.124147194e-007
	,6.207817185e-007
	,6.307912818e-007
	,6.429728346e-007
	,6.580260896e-007
	,6.767886237e-007
	,7.004901176e-007
	,7.307221871e-007
	,7.695360333e-007
	,8.195986560e-007
	,8.843592173e-007
	,9.682497033e-007
	,1.076920914e-006
	,1.217511115e-006
	,1.398938968e-006
	,1.632204489e-006
	,1.930671994e-006
	,2.310298716e-006
	,2.789763922e-006
	,3.390449686e-006
	,4.136229622e-006
	,5.053038719e-006
	,6.168227434e-006
	,7.509742347e-006
	,9.105201529e-006
	,1.098097549e-005
	,1.316136135e-005
	,1.566794071e-005
	,1.851919129e-005
	,2.173032180e-005
	,2.531337173e-005
	,2.927742730e-005
	,3.362900261e-005
	,3.837243943e-005
	,4.351032691e-005
	,4.904389921e-005
	,5.497340897e-005
	,6.129841196e-005
	,6.801801936e-005
	,7.513110028e-005
	,8.263645519e-005
	,9.053296433e-005
	,9.881964132e-005
	,1.074957260e-004
	,1.165606349e-004
	,1.258397025e-004
	,1.351852037e-004
	,1.448882315e-004
	,1.549428237e-004
	,1.653435914e-004
	,1.760868485e-004
	,1.871675062e-004
	,1.985821306e-004
	,2.103282840e-004
	,2.224020134e-004
	,2.348019615e-004
	,2.475254502e-004
	,-2.798222235e-004
	,-2.657019856e-004
	,-2.517007266e-004
	,-2.379518942e-004
	,-2.245229268e-004
	,-2.113828071e-004
	,-1.984906219e-004
	,-1.858511725e-004
	,-1.734713496e-004
	,-1.613317244e-004
	,-1.494248414e-004
	,-1.378184551e-004
	,-1.265991098e-004
	,-1.158146251e-004
	,-1.054799884e-004
	,-9.558859809e-005
	,-8.613262691e-005
	,-7.713797034e-005
	,-6.863564647e-005
	,-6.063732589e-005
	,-5.315880732e-005
	,-4.621416918e-005
	,-3.980606933e-005
	,-3.393350329e-005
	,-2.859694801e-005
	,-2.379822649e-005
	,-1.953616340e-005
	,-1.580211738e-005
	,-1.257879485e-005
	,-9.842655497e-006
	,-7.563879695e-006
	,-5.702116922e-006
	,-4.210331361e-006
	,-3.042265039e-006
	,-2.146654411e-006
	,-1.471463331e-006
	,-9.696442265e-007
	,-6.010820772e-007
	,-3.329431857e-007
	,-1.392377848e-007
	,1.576917383e-017
	,9.980483111e-008
	,1.713851792e-007
	,2.228903076e-007
	,2.601623259e-007
	,2.873428589e-007
	,3.073790702e-007
	,3.224178930e-007
	,3.339508315e-007
	,3.430058887e-007
	,3.502968199e-007
	,3.563225215e-007
	,3.614356939e-007
	,3.658871173e-007
	,3.698558744e-007
	,3.734712065e-007
	,3.768273999e-007
	,3.799939649e-007
	,3.830226318e-007
	,3.859517192e-007
	,3.888093756e-007
	,3.916161461e-007
	,3.943869917e-007
	,3.971334630e-007
	,3.998644303e-007
	,4.025862356e-007
	,4.053036235e-007
	,4.080202085e-007
	,4.107386782e-007
	,4.134610506e-007
	,4.161888516e-007
	,4.189231888e-007
	,4.216647546e-007
	,4.244142444e-007
	,4.271723495e-007
	,4.299394348e-007
	,4.327161745e-007
	,4.355031657e-007
	,4.383007982e-007
	,4.411093631e-007
	,4.439290925e-007
	,4.467601784e-007
	,4.496027855e-007
	,4.524570553e-007
	,4.553230856e-007
	,4.582008061e-007
	,4.610898387e-007
	,4.639903718e-007
	,4.669027174e-007
	,4.698268232e-007
	,4.727623616e-007
	,4.757086574e-007
	,4.786644762e-007
	,4.816279771e-007
	,4.845976923e-007
	,4.875742633e-007
	,4.905600270e-007
	,4.935571191e-007
	,4.965668358e-007
	,4.995898672e-007
	,5.026265674e-007
	,5.056771062e-007
	,5.087415514e-007
	,5.118199264e-007
	,5.149123056e-007
	,5.180187520e-007
	,5.211392903e-007
	,5.242739226e-007
	,5.274226391e-007
	,5.305854317e-007
	,5.337623033e-007
	,5.369532688e-007
	,5.401583456e-007
	,5.433775458e-007
	,5.466108879e-007
	,5.498584069e-007
	,5.531201546e-007
	,5.563962007e-007
	,5.596866353e-007
	,5.629915604e-007
	,5.663110894e-007
	,5.696453583e-007
	,5.729945253e-007
	,5.763587684e-007
	,5.797382833e-007
	,5.831332575e-007
	,5.865438755e-007
	,5.899705186e-007
	,5.934135558e-007
	,5.968734163e-007
	,6.003506216e-007
	,6.038458242e-007
	,6.073598483e-007
	,6.108937471e-007
	,6.144488758e-007
	,6.180269933e-007
	,6.216283799e-007
	,6.252562780e-007
	,6.289141242e-007
	,6.326060962e-007
	,6.363376484e-007
	,6.401159354e-007
	,6.439503711e-007
	,6.478533708e-007
	,6.518413565e-007
	,6.559360655e-007
	,6.601663004e-007
	,6.645702466e-007
	,6.691985290e-007
	,6.741183242e-007
	,6.794187476e-007
	,6.852180278e-007
	,6.916729912e-007
	,6.989915965e-007
	,7.074494785e-007
	,7.174117572e-007
	,7.293617315e-007
	,7.438659826e-007
	,7.617751690e-007
	,7.841999285e-007
	,8.125688686e-007
	,8.487490198e-007
	,8.951705310e-007
	,9.549809118e-007
	,1.032232490e-006
	,1.132105007e-006
	,1.261162300e-006
	,1.427636973e-006
	,1.641730046e-006
	,1.915903359e-006
	,2.265132307e-006
	,2.707076859e-006
	,3.262123003e-006
	,3.953248225e-006
	,4.805677184e-006
	,5.846318440e-006
	,7.103007451e-006
	,8.603617932e-006
	,1.037513398e-005
	,1.244278486e-005
	,1.482934358e-005
	,1.755468004e-005
	,2.063550549e-005
	,2.408526418e-005
	,2.791438483e-005
	,3.213055545e-005
	,3.673918808e-005
	,4.174376299e-005
	,4.714628674e-005
	,5.294765706e-005
	,5.914795682e-005
	,6.574673633e-005
	,7.274321751e-005
	,8.013645658e-005
	,8.792546315e-005
	,9.610926806e-005
	,1.046869769e-004
	,1.135460892e-004
	,1.224240190e-004
	,1.316649486e-004
	,1.412623434e-004
	,-2.979711989e-004
	,-2.834051148e-004
	,-2.689318758e-004
	,-2.545915755e-004
	,-2.404122348e-004
	,-2.264347696e-004
	,-2.126667164e-004
	,-1.991051772e-004
	,-1.857822165e-004
	,-1.727453363e-004
	,-1.600562767e-004
	,-1.477738307e-004
	,-1.359229578e-004
	,-1.244992648e-004
	,-1.134820265e-004
	,-1.028831535e-004
	,-9.275514986e-005
	,-8.312534595e-005
	,-7.400438353e-005
	,-6.541773536e-005
	,-5.738456096e-005
	,-4.991008344e-005
	,-4.299659397e-005
	,-3.664843457e-005
	,-3.087178603e-005
	,-2.567136382e-005
	,-2.104640673e-005
	,-1.698807698e-005
	,-1.348027440e-005
	,-1.049974664e-005
	,-8.023029518e-006
	,-6.016852163e-006
	,-4.426843639e-006
	,-3.190844610e-006
	,-2.246945872e-006
	,-1.537524221e-006
	,-1.011636307e-006
	,-6.261730533e-007
	,-3.463270157e-007
	,-1.447081896e-007
	,-2.819853703e-018
	,1.036467601e-007
	,1.779025531e-007
	,2.313812073e-007
	,2.702525342e-007
	,2.988828935e-007
	,3.203440083e-007
	,3.367870497e-007
	,3.497129237e-007
	,3.601654410e-007
	,3.688682911e-007
	,3.763216179e-007
	,3.828698391e-007
	,3.887491620e-007
	,3.941209249e-007
	,3.990952222e-007
	,4.037476883e-007
	,4.081311105e-007
	,4.122835499e-007
	,4.162341772e-007
	,4.200072702e-007
	,4.236246221e-007
	,4.271065621e-007
	,4.304717658e-007
	,4.337363910e-007
	,4.369152709e-007
	,4.400263318e-007
	,4.430885081e-007
	,4.461167443e-007
	,4.491220208e-007
	,4.521127407e-007
	,4.550955735e-007
	,4.580756723e-007
	,4.610569266e-007
	,4.640422281e-007
	,4.670337461e-007
	,4.700334604e-007
	,4.730430830e-007
	,4.760638875e-007
	,4.790967287e-007
	,4.821420270e-007
	,4.852000632e-007
	,4.882714849e-007
	,4.913568244e-007
	,4.944563775e-007
	,4.975702359e-007
	,5.006985371e-007
	,5.038417228e-007
	,5.070001078e-007
	,5.101738627e-007
	,5.133631046e-007
	,5.165679186e-007
	,5.197883244e-007
	,5.230240458e-007
	,5.262747321e-007
	,5.295409104e-007
	,5.328228299e-007
	,5.361205262e-007
	,5.394339906e-007
	,5.427631781e-007
	,5.461079880e-007
	,5.494684261e-007
	,5.528445893e-007
	,5.562364996e-007
	,5.596441415e-007
	,5.630674893e-007
	,5.665065100e-007
	,5.699611495e-007
	,5.734313014e-007
	,5.769168680e-007
	,5.804179107e-007
	,5.839344917e-007
	,5.874666176e-007
	,5.910142805e-007
	,5.945774671e-007
	,5.981561707e-007
	,6.017504131e-007
	,6.053602240e-007
	,6.089856412e-007
	,6.126267026e-007
	,6.162834379e-007
	,6.199558892e-007
	,6.236441203e-007
	,6.273482102e-007
	,6.310682400e-007
	,6.348042964e-007
	,6.385564850e-007
	,6.423249340e-007
	,6.461097930e-007
	,6.499112323e-007
	,6.537294240e-007
	,6.575645306e-007
	,6.614166841e-007
	,6.652861793e-007
	,6.691733078e-007
	,6.730783937e-007
	,6.770018079e-007
	,6.809439771e-007
	,6.849053772e-007
	,6.888865589e-007
	,6.928881969e-007
	,6.969111272e-007
	,7.009559205e-007
	,7.050234135e-007
	,7.091153586e-007
	,7.132335466e-007
	,7.173802677e-007
	,7.215584744e-007
	,7.257719912e-007
	,7.300258122e-007
	,7.343264979e-007
	,7.386826881e-007
	,7.431057827e-007
	,7.476108443e-007
	,7.522177932e-007
	,7.569529975e-007
	,7.618513533e-007
	,7.669591479e-007
	,7.723377425e-007
	,7.780685344e-007
	,7.842595035e-007
	,7.910538651e-007
	,7.986415283e-007
	,8.072742640e-007
	,8.172857247e-007
	,8.290565581e-007
	,8.431731002e-007
	,8.604093521e-007
	,8.817557966e-007
	,9.085117757e-007
	,9.423763956e-007
	,9.855633033e-007
	,1.040943575e-006
	,1.112220158e-006
	,1.204136979e-006
	,1.322722868e-006
	,1.475566400e-006
	,1.672111100e-006
	,1.923952934e-006
	,2.245111362e-006
	,2.652235371e-006
	,3.164699019e-006
	,3.804537467e-006
	,4.596186695e-006
	,5.566005682e-006
	,6.741593763e-006
	,8.150951688e-006
	,9.821568340e-006
	,1.177953066e-005
	,1.404875298e-005
	,1.665040800e-005
	,1.960259134e-005
	,2.292022197e-005
	,2.661514632e-005
	,3.069671387e-005
	,3.517155055e-005
	,4.004418956e-005
	,4.531753003e-005
	,5.099326129e-005
	,5.707209880e-005
	,6.355413446e-005
	,-3.119935749e-004
	,-2.967222708e-004
	,-2.814896841e-004
	,-2.664066307e-004
	,-2.515529858e-004
	,-2.369952537e-004
	,-2.227714450e-004
	,-2.088851126e-004
	,-1.953149418e-004
	,-1.820532486e-004
	,-1.691284296e-004
	,-1.565529367e-004
	,-1.443034951e-004
	,-1.323489424e-004
	,-1.207302649e-004
	,-1.095376713e-004
	,-9.881749524e-005
	,-8.858778018e-005
	,-7.888395063e-005
	,-6.973732089e-005
	,-6.116180033e-005
	,-5.316785031e-005
	,-4.576707030e-005
	,-3.897038317e-005
	,-3.278550106e-005
	,-2.721458282e-005
	,-2.225122529e-005
	,-1.788300186e-005
	,-1.411363007e-005
	,-1.094407382e-005
	,-8.338049908e-006
	,-6.238607278e-006
	,-4.580289317e-006
	,-3.294938156e-006
	,-2.316022722e-006
	,-1.582037010e-006
	,-1.038943237e-006
	,-6.421184774e-007
	,-3.547995032e-007
	,-1.480123360e-007
	,2.146075810e-017
	,1.058519900e-007
	,1.817791067e-007
	,2.365952693e-007
	,2.765825977e-007
	,3.061864150e-007
	,3.285353215e-007
	,3.458220539e-007
	,3.595783685e-007
	,3.708713406e-007
	,3.804424783e-007
	,3.888057895e-007
	,3.963163487e-007
	,4.032176384e-007
	,4.096719136e-007
	,4.157653713e-007
	,4.215540112e-007
	,4.271391670e-007
	,4.325688814e-007
	,4.378630607e-007
	,4.430306556e-007
	,4.480743550e-007
	,4.529930434e-007
	,4.577835190e-007
	,4.624418630e-007
	,4.669646175e-007
	,4.713498307e-007
	,4.755979498e-007
	,4.797124732e-007
	,4.837002516e-007
	,4.875713593e-007
	,4.913385297e-007
	,4.950162153e-007
	,4.986194826e-007
	,5.021630011e-007
	,5.056602882e-007
	,5.091232558e-007
	,5.125620359e-007
	,5.159850074e-007
	,5.193989441e-007
	,5.228092127e-007
	,5.262200043e-007
	,5.296346236e-007
	,5.330558254e-007
	,5.364859457e-007
	,5.399267245e-007
	,5.433792647e-007
	,5.468444648e-007
	,5.503232132e-007
	,5.538163382e-007
	,5.573246829e-007
	,5.608488001e-007
	,5.643890688e-007
	,5.679457790e-007
	,5.715191627e-007
	,5.751094081e-007
	,5.787166645e-007
	,5.823410303e-007
	,5.859825025e-007
	,5.896410259e-007
	,5.933167313e-007
	,5.970092418e-007
	,6.007184979e-007
	,6.044452285e-007
	,6.081896299e-007
	,6.119517237e-007
	,6.157315015e-007
	,6.195289479e-007
	,6.233440451e-007
	,6.271767744e-007
	,6.310271160e-007
	,6.348950431e-007
	,6.387805008e-007
	,6.426833283e-007
	,6.466032273e-007
	,6.505400987e-007
	,6.544941452e-007
	,6.584655457e-007
	,6.624543410e-007
	,6.664605108e-007
	,6.704840254e-007
	,6.745248594e-007
	,6.785829931e-007
	,6.826584143e-007
	,6.867511292e-007
	,6.908611597e-007
	,6.949885121e-007
	,6.991331815e-007
	,7.032951721e-007
	,7.074745103e-007
	,7.116712528e-007
	,7.158854603e-007
	,7.201172030e-007
	,7.243665668e-007
	,7.286336573e-007
	,7.329185769e-007
	,7.372213926e-007
	,7.415421580e-007
	,7.458809170e-007
	,7.502378134e-007
	,7.546130095e-007
	,7.590066308e-007
	,7.634187866e-007
	,7.678495938e-007
	,7.722991804e-007
	,7.767676887e-007
	,7.812552915e-007
	,7.857621979e-007
	,7.902885900e-007
	,7.948343140e-007
	,7.993999102e-007
	,8.039857824e-007
	,8.085924854e-007
	,8.132207827e-007
	,8.178717256e-007
	,8.225467668e-007
	,8.272479074e-007
	,8.319778888e-007
	,8.367404790e-007
	,8.415408375e-007
	,8.463860083e-007
	,8.512855657e-007
	,8.562524766e-007
	,8.613042328e-007
	,8.664643473e-007
	,8.717643288e-007
	,8.772462051e-007
	,8.829661002e-007
	,8.889986848e-007
	,8.954431970e-007
	,9.024314008e-007
	,9.101381048e-007
	,9.187951099e-007
	,9.286579050e-007
	,9.401310256e-007
	,9.537564711e-007
	,9.702211826e-007
	,9.904280063e-007
	,1.015561258e-006
	,1.047170075e-006
	,1.087273713e-006
	,1.138493355e-006
	,1.204214359e-006
	,1.288782022e-006
	,1.397732356e-006
	,1.538055601e-006
	,1.718484856e-006
	,1.949794824e-006
	,2.245085891e-006
	,2.620018246e-006
	,3.092954362e-006
	,3.684956788e-006
	,4.419613973e-006
	,5.322645940e-006
	,6.421299357e-006
	,7.743565289e-006
	,9.317296637e-006
	,1.116930635e-005
	,1.332455169e-005
	,1.580549199e-005
	,1.863167152e-005
	,-3.212546915e-004
	,-3.055975588e-004
	,-2.901489213e-004
	,-2.749772875e-004
	,-2.601075985e-004
	,-2.455399044e-004
	,-2.312587588e-004
	,-2.172364171e-004
	,-2.034480906e-004
	,-1.899157486e-004
	,-1.766785871e-004
	,-1.637360558e-004
	,-1.510629062e-004
	,-1.386927695e-004
	,-1.267011367e-004
	,-1.151209750e-004
	,-1.039598722e-004
	,-9.325647252e-005
	,-8.306946921e-005
	,-7.343886545e-005
	,-6.439304723e-005
	,-5.595364563e-005
	,-4.813592193e-005
	,-4.094982740e-005
	,-3.439894891e-005
	,-2.847549640e-005
	,-2.317870014e-005
	,-1.854951570e-005
	,-1.459950846e-005
	,-1.129705033e-005
	,-8.589969846e-006
	,-6.414586728e-006
	,-4.700555868e-006
	,-3.375308363e-006
	,-2.368236538e-006
	,-1.614473860e-006
	,-1.058610552e-006
	,-6.531280406e-007
	,-3.602534321e-007
	,-1.502041212e-007
	,-1.033901091e-017
	,1.074527084e-007
	,1.845954105e-007
	,2.403685682e-007
	,2.811396347e-007
	,3.114132034e-007
	,3.343597654e-007
	,3.522021195e-007
	,3.664939303e-007
	,3.783184433e-007
	,3.884288026e-007
	,3.973438656e-007
	,4.053885370e-007
	,4.127823476e-007
	,4.197797735e-007
	,4.265177692e-007
	,4.330776745e-007
	,4.395125666e-007
	,4.458568426e-007
	,4.521319652e-007
	,4.583502817e-007
	,4.645176063e-007
	,4.706350144e-007
	,4.767002863e-007
	,4.827088760e-007
	,4.886543962e-007
	,4.945290784e-007
	,5.003241849e-007
	,5.060303539e-007
	,5.116379184e-007
	,5.171372418e-007
	,5.225191006e-007
	,5.277751401e-007
	,5.328984087e-007
	,5.378839591e-007
	,5.427294697e-007
	,5.474358018e-007
	,5.520073664e-007
	,5.564521679e-007
	,5.607814402e-007
	,5.650088834e-007
	,5.691496312e-007
	,5.732191522e-007
	,5.772322887e-007
	,5.812025695e-007
	,5.851418326e-007
	,5.890601005e-007
	,5.929656375e-007
	,5.968651217e-007
	,6.007638622e-007
	,6.046659912e-007
	,6.085745333e-007
	,6.124915759e-007
	,6.164194364e-007
	,6.203602952e-007
	,6.243154986e-007
	,6.282860480e-007
	,6.322728546e-007
	,6.362766370e-007
	,6.402978676e-007
	,6.443367461e-007
	,6.483935590e-007
	,6.524687462e-007
	,6.565627733e-007
	,6.606759447e-007
	,6.648084431e-007
	,6.689603909e-007
	,6.731318352e-007
	,6.773224983e-007
	,6.815313796e-007
	,6.857588927e-007
	,6.900057169e-007
	,6.942718139e-007
	,6.985571806e-007
	,7.028619735e-007
	,7.071862245e-007
	,7.115298852e-007
	,7.158928762e-007
	,7.202750932e-007
	,7.246763804e-007
	,7.290964460e-007
	,7.335349112e-007
	,7.379916941e-007
	,7.424668137e-007
	,7.469601781e-007
	,7.514716273e-007
	,7.560009491e-007
	,7.605478491e-007
	,7.651120851e-007
	,7.696935497e-007
	,7.742920384e-007
	,7.789072772e-007
	,7.835389619e-007
	,7.881867470e-007
	,7.928502293e-007
	,7.975289617e-007
	,8.022224747e-007
	,8.069302580e-007
	,8.116517532e-007
	,8.163863586e-007
	,8.211334352e-007
	,8.258922921e-007
	,8.306621298e-007
	,8.354420795e-007
	,8.402312574e-007
	,8.450288552e-007
	,8.498341540e-007
	,8.546464527e-007
	,8.594651116e-007
	,8.642896087e-007
	,8.691195884e-007
	,8.739548819e-007
	,8.787954839e-007
	,8.836416008e-007
	,8.884936964e-007
	,8.933523267e-007
	,8.982184795e-007
	,9.030933723e-007
	,9.079783618e-007
	,9.128749821e-007
	,9.177849659e-007
	,9.227102526e-007
	,9.276530348e-007
	,9.326158181e-007
	,9.376015219e-007
	,9.426135965e-007
	,9.476561722e-007
	,9.527343084e-007
	,9.578543481e-007
	,9.630243587e-007
	,9.682547022e-007
	,9.735587936e-007
	,9.789541150e-007
	,9.844635655e-007
	,9.901172584e-007
	,9.959548686e-007
	,1.002028716e-006
	,1.008408061e-006
	,1.015184506e-006
	,1.022479400e-006
	,1.030453585e-006
	,1.039276670e-006
	,1.049226107e-006
	,1.060681720e-006
	,1.074118491e-006
	,1.090161890e-006
	,1.109633774e-006
	,1.133612578e-006
	,1.163509973e-006
	,1.201167000e-006
	,1.248975890e-006
	,1.310030417e-006
	,1.388308726e-006
	,1.488890743e-006
	,1.618209539e-006
	,1.784331224e-006
	,1.997251279e-006
	,2.269186516e-006
	,2.614831444e-006
	,3.051539192e-006
	,3.599383953e-006
	,-3.283441002e-004
	,-3.124523503e-004
	,-2.969092221e-004
	,-2.817253637e-004
	,-2.668884905e-004
	,-2.523712384e-004
	,-2.381304966e-004
	,-2.241072348e-004
	,-2.102625716e-004
	,-1.966073661e-004
	,-1.831383258e-004
	,-1.698229905e-004
	,-1.566931503e-004
	,-1.438530470e-004
	,-1.313792121e-004
	,-1.193128405e-004
	,-1.077042101e-004
	,-9.662516450e-005
	,-8.611671299e-005
	,-7.619468299e-005
	,-6.686856307e-005
	,-5.814759035e-005
	,-5.004081695e-005
	,-4.255252145e-005
	,-3.567531293e-005
	,-2.943190660e-005
	,-2.389391437e-005
	,-1.908942311e-005
	,-1.500160349e-005
	,-1.158979616e-005
	,-8.797890571e-006
	,-6.558671018e-006
	,-4.798007789e-006
	,-3.439388289e-006
	,-2.408484429e-006
	,-1.638901244e-006
	,-1.072452071e-006
	,-6.608874428e-007
	,-3.643796408e-007
	,-1.519152074e-007
	,-1.410011729e-018
	,1.087073758e-007
	,1.867981144e-007
	,2.433117667e-007
	,2.846833259e-007
	,3.154641776e-007
	,3.388576037e-007
	,3.571095303e-007
	,3.717896913e-007
	,3.839901643e-007
	,3.944426070e-007
	,4.036134319e-007
	,4.119680173e-007
	,4.197913986e-007
	,4.272609623e-007
	,4.344970146e-007
	,4.415817394e-007
	,4.485710924e-007
	,4.555028475e-007
	,4.624021135e-007
	,4.692851234e-007
	,4.761618339e-007
	,4.830377071e-007
	,4.899149252e-007
	,4.967932179e-007
	,5.036704259e-007
	,5.105428857e-007
	,5.174056966e-007
	,5.242529125e-007
	,5.310776863e-007
	,5.378723848e-007
	,5.446286779e-007
	,5.513375964e-007
	,5.579895167e-007
	,5.645741434e-007
	,5.710810343e-007
	,5.775000417e-007
	,5.838209507e-007
	,5.900335462e-007
	,5.961279575e-007
	,6.020950526e-007
	,6.079268984e-007
	,6.136172888e-007
	,6.191623236e-007
	,6.245609803e-007
	,6.298155888e-007
	,6.349320890e-007
	,6.399199555e-007
	,6.447917210e-007
	,6.495621336e-007
	,6.542470949e-007
	,6.588625833e-007
	,6.634237468e-007
	,6.679442703e-007
	,6.724360292e-007
	,6.769089658e-007
	,6.813710371e-007
	,6.858279933e-007
	,6.902840811e-007
	,6.947446988e-007
	,6.992144873e-007
	,7.036963428e-007
	,7.081922491e-007
	,7.127036695e-007
	,7.172317061e-007
	,7.217771832e-007
	,7.263406941e-007
	,7.309226350e-007
	,7.355232658e-007
	,7.401428352e-007
	,7.447816291e-007
	,7.494397254e-007
	,7.541169776e-007
	,7.588136402e-007
	,7.635297349e-007
	,7.682650248e-007
	,7.730186463e-007
	,7.777891823e-007
	,7.825775642e-007
	,7.873840646e-007
	,7.922082542e-007
	,7.970495336e-007
	,8.019072173e-007
	,8.067805393e-007
	,8.116686394e-007
	,8.165705240e-007
	,8.214850694e-007
	,8.264111580e-007
	,8.313477809e-007
	,8.362939177e-007
	,8.412484372e-007
	,8.462101652e-007
	,8.511779464e-007
	,8.561506939e-007
	,8.611274343e-007
	,8.661073523e-007
	,8.710898299e-007
	,8.760744773e-007
	,8.810611520e-007
	,8.860499609e-007
	,8.910412351e-007
	,8.960354982e-007
	,9.010335659e-007
	,9.060364569e-007
	,9.110452258e-007
	,9.160609738e-007
	,9.210848386e-007
	,9.261179769e-007
	,9.311615507e-007
	,9.362166311e-007
	,9.412841742e-007
	,9.463651436e-007
	,9.514605894e-007
	,9.565715094e-007
	,9.616988236e-007
	,9.668434016e-007
	,9.720060908e-007
	,9.771877096e-007
	,9.823889777e-007
	,9.876105521e-007
	,9.928530744e-007
	,9.981171397e-007
	,1.003403344e-006
	,1.008712416e-006
	,1.014045059e-006
	,1.019401989e-006
	,1.024783972e-006
	,1.030191841e-006
	,1.035626464e-006
	,1.041088771e-006
	,1.046579861e-006
	,1.052101071e-006
	,1.057654043e-006
	,1.063240826e-006
	,1.068863994e-006
	,1.074526794e-006
	,1.080233382e-006
	,1.085989128e-006
	,1.091801022e-006
	,1.097678251e-006
	,1.103632857e-006
	,1.109680697e-006
	,1.115842684e-006
	,1.122146415e-006
	,1.128628319e-006
	,1.135336568e-006
	,1.142334938e-006
	,1.149707952e-006
	,1.157567670e-006
	,1.166025945e-006
	,1.175272665e-006
	,1.185575858e-006
	,1.197264432e-006
	,1.210771905e-006
	,1.226668947e-006
	,1.245704994e-006
	,1.268864401e-006
	,1.297434867e-006
	,1.333096834e-006
	,1.378035410e-006
	,1.435079523e-006
	,-3.347573136e-004
	,-3.187808478e-004
	,-3.031873028e-004
	,-2.879637090e-004
	,-2.730817486e-004
	,-2.584987494e-004
	,-2.441519314e-004
	,-2.299666154e-004
	,-2.159076276e-004
	,-2.019613897e-004
	,-1.880889274e-004
	,-1.743207328e-004
	,-1.607939906e-004
	,-1.476187071e-004
	,-1.348432230e-004
	,-1.224972999e-004
	,-1.106446669e-004
	,-9.933799970e-005
	,-8.859827643e-005
	,-7.843611971e-005
	,-6.886129516e-005
	,-5.988292952e-005
	,-5.150291399e-005
	,-4.371126884e-005
	,-3.654984425e-005
	,-3.010601339e-005
	,-2.442212098e-005
	,-1.949916847e-005
	,-1.531243382e-005
	,-1.181931850e-005
	,-8.962634566e-006
	,-6.673585230e-006
	,-4.875704371e-006
	,-3.489362693e-006
	,-2.438554641e-006
	,-1.656231346e-006
	,-1.082933069e-006
	,-6.670538562e-007
	,-3.677255962e-007
	,-1.533114559e-007
	,-7.675976067e-018
	,1.097327605e-007
	,1.885970216e-007
	,2.457127038e-007
	,2.875699659e-007
	,3.187584597e-007
	,3.425081302e-007
	,3.610830265e-007
	,3.760606785e-007
	,3.884852720e-007
	,3.991085752e-007
	,4.085716462e-007
	,4.172589295e-007
	,4.254275131e-007
	,4.332542031e-007
	,4.408608982e-007
	,4.483315810e-007
	,4.557239904e-007
	,4.630776807e-007
	,4.704195891e-007
	,4.777678794e-007
	,4.851345926e-007
	,4.925274695e-007
	,4.999511985e-007
	,5.074082660e-007
	,5.148995281e-007
	,5.224245920e-007
	,5.299820639e-007
	,5.375697053e-007
	,5.451845289e-007
	,5.528228525e-007
	,5.604803298e-007
	,5.681519661e-007
	,5.758321322e-007
	,5.835145791e-007
	,5.911924607e-007
	,5.988583647e-007
	,6.065043518e-007
	,6.141219990e-007
	,6.217024429e-007
	,6.292364159e-007
	,6.367142737e-007
	,6.441260148e-007
	,6.514612930e-007
	,6.587094123e-007
	,6.658592307e-007
	,6.728989532e-007
	,6.798170955e-007
	,6.866042323e-007
	,6.932521390e-007
	,6.997536650e-007
	,7.061034776e-007
	,7.122987428e-007
	,7.183396940e-007
	,7.242300433e-007
	,7.299771377e-007
	,7.355917631e-007
	,7.410875612e-007
	,7.464801176e-007
	,7.517858732e-007
	,7.570210359e-007
	,7.622006047e-007
	,7.673373953e-007
	,7.724410076e-007
	,7.775202076e-007
	,7.825857402e-007
	,7.876457121e-007
	,7.927053544e-007
	,7.977682657e-007
	,8.028369544e-007
	,8.079131096e-007
	,8.129977754e-007
	,8.180914800e-007
	,8.231943367e-007
	,8.283061265e-007
	,8.334263690e-007
	,8.385543877e-007
	,8.436893711e-007
	,8.488304337e-007
	,8.539766739e-007
	,8.591272319e-007
	,8.642813558e-007
	,8.694384313e-007
	,8.745975689e-007
	,8.797566935e-007
	,8.849160238e-007
	,8.900784900e-007
	,8.952452774e-007
	,9.004171295e-007
	,9.055949724e-007
	,9.107798687e-007
	,9.159728501e-007
	,9.211748518e-007
	,9.263867342e-007
	,9.316095368e-007
	,9.368443216e-007
	,9.420920051e-007
	,9.473533905e-007
	,9.526291805e-007
	,9.579199653e-007
	,9.632263369e-007
	,9.685489580e-007
	,9.738883964e-007
	,9.792451308e-007
	,9.846195893e-007
	,9.900121649e-007
	,9.954232254e-007
	,1.000853118e-006
	,1.006302175e-006
	,1.011770719e-006
	,1.017259066e-006
	,1.022767526e-006
	,1.028296412e-006
	,1.033846034e-006
	,1.039416702e-006
	,1.045008719e-006
	,1.050622393e-006
	,1.056258035e-006
	,1.061916047e-006
	,1.067596823e-006
	,1.073300766e-006
	,1.079028273e-006
	,1.084779745e-006
	,1.090555600e-006
	,1.096356249e-006
	,1.102182060e-006
	,1.108033374e-006
	,1.113910526e-006
	,1.119813833e-006
	,1.125743797e-006
	,1.131700932e-006
	,1.137685737e-006
	,1.143698736e-006
	,1.149740481e-006
	,1.155811476e-006
	,1.161912240e-006
	,1.168043386e-006
	,1.174205631e-006
	,1.180399821e-006
	,1.186626963e-006
	,1.192888282e-006
	,1.199185291e-006
	,1.205519888e-006
	,1.211894494e-006
	,1.218312142e-006
	,1.224776684e-006
	,1.231293072e-006
	,1.237867801e-006
	,1.244509403e-006
	,1.251229083e-006
	,1.258041598e-006
	,1.264966388e-006
	,1.272029079e-006
	,1.279263511e-006
	,1.286714302e-006
	,1.294440640e-006
	,1.302521097e-006
	,1.311028742e-006
	,1.320093058e-006
	,1.329904894e-006
	,1.340692524e-006
	,-3.408365510e-004
	,-3.248249959e-004
	,-3.091999710e-004
	,-2.939329501e-004
	,-2.789797678e-004
	,-2.642752121e-004
	,-2.497243757e-004
	,-2.352329221e-004
	,-2.207642432e-004
	,-2.063044290e-004
	,-1.919036702e-004
	,-1.777259842e-004
	,-1.639045556e-004
	,-1.504933071e-004
	,-1.375059661e-004
	,-1.249827190e-004
	,-1.129812835e-004
	,-1.015256318e-004
	,-9.062254200e-005
	,-8.027780475e-005
	,-7.049804152e-005
	,-6.128200392e-005
	,-5.261742030e-005
	,-4.456133613e-005
	,-3.721509628e-005
	,-3.063371017e-005
	,-2.483784838e-005
	,-1.982068783e-005
	,-1.555527753e-005
	,-1.199804906e-005
	,-9.090665656e-006
	,-6.762610289e-006
	,-4.934730422e-006
	,-3.524607583e-006
	,-2.459110333e-006
	,-1.669367108e-006
	,-1.091175742e-006
	,-6.720279550e-007
	,-3.704709286e-007
	,-1.544678459e-007
	,-2.260985774e-017
	,1.105901189e-007
	,1.901043753e-007
	,2.477266419e-007
	,2.899919636e-007
	,3.215215233e-007
	,3.455669528e-007
	,3.644028043e-007
	,3.795574151e-007
	,3.921273462e-007
	,4.030013600e-007
	,4.127310083e-007
	,4.216900407e-007
	,4.301365149e-007
	,4.382489274e-007
	,4.461507343e-007
	,4.539272694e-007
	,4.616374540e-007
	,4.693219046e-007
	,4.770085491e-007
	,4.847165158e-007
	,4.924588244e-007
	,5.002442475e-007
	,5.080785945e-007
	,5.159655957e-007
	,5.239075070e-007
	,5.319055190e-007
	,5.399600304e-007
	,5.480708256e-007
	,5.562371839e-007
	,5.644579424e-007
	,5.727315252e-007
	,5.810559491e-007
	,5.894288134e-007
	,5.978472797e-007
	,6.063080448e-007
	,6.148073128e-007
	,6.233407658e-007
	,6.319035411e-007
	,6.404902147e-007
	,6.490947944e-007
	,6.577107268e-007
	,6.663309154e-007
	,6.749477515e-007
	,6.835531523e-007
	,6.921386005e-007
	,7.006951767e-007
	,7.092135768e-007
	,7.176841115e-007
	,7.260966882e-007
	,7.344407867e-007
	,7.427054451e-007
	,7.508792782e-007
	,7.589505467e-007
	,7.669072878e-007
	,7.747375020e-007
	,7.824293526e-007
	,7.899712114e-007
	,7.973512550e-007
	,8.045587818e-007
	,8.115888584e-007
	,8.184403640e-007
	,8.251144895e-007
	,8.316156415e-007
	,8.379518105e-007
	,8.441343344e-007
	,8.501771727e-007
	,8.560956810e-007
	,8.619047200e-007
	,8.676178197e-007
	,8.732518635e-007
	,8.788249139e-007
	,8.843512450e-007
	,8.898421503e-007
	,8.953068946e-007
	,9.007531653e-007
	,9.061873632e-007
	,9.116148295e-007
	,9.170400332e-007
	,9.224667251e-007
	,9.278980645e-007
	,9.333367225e-007
	,9.387849657e-007
	,9.442447250e-007
	,9.497176527e-007
	,9.552051692e-007
	,9.607085018e-007
	,9.662287165e-007
	,9.717667398e-007
	,9.773233546e-007
	,9.828990734e-007
	,9.884932523e-007
	,9.941026029e-007
	,9.997291692e-007
	,1.005376174e-006
	,1.011043798e-006
	,1.016732234e-006
	,1.022442323e-006
	,1.028174261e-006
	,1.033927998e-006
	,1.039703655e-006
	,1.045501375e-006
	,1.051321227e-006
	,1.057163326e-006
	,1.063027757e-006
	,1.068914567e-006
	,1.074823788e-006
	,1.080755453e-006
	,1.086709594e-006
	,1.092686253e-006
	,1.098685477e-006
	,1.104707318e-006
	,1.110751818e-006
	,1.116819013e-006
	,1.122909051e-006
	,1.129022154e-006
	,1.135158505e-006
	,1.141318276e-006
	,1.147501650e-006
	,1.153708821e-006
	,1.159939995e-006
	,1.166195365e-006
	,1.172475083e-006
	,1.178779322e-006
	,1.185108472e-006
	,1.191462991e-006
	,1.197843275e-006
	,1.204249692e-006
	,1.210682611e-006
	,1.217142414e-006
	,1.223629425e-006
	,1.230143885e-006
	,1.236686235e-006
	,1.243256832e-006
	,1.249855967e-006
	,1.256484070e-006
	,1.263141688e-006
	,1.269829347e-006
	,1.276547551e-006
	,1.283296805e-006
	,1.290077587e-006
	,1.296890338e-006
	,1.303735519e-006
	,1.310613642e-006
	,1.317525273e-006
	,1.324471031e-006
	,1.331451621e-006
	,1.338467883e-006
	,1.345520848e-006
	,1.352611759e-006
	,1.359742022e-006
	,1.366913323e-006
	,1.374127841e-006
	,1.381388393e-006
	,1.388698614e-006
	,1.396063218e-006
	,1.403488343e-006
	,1.410982011e-006
	,1.418554744e-006
	,1.426220388e-006
	,1.433997145e-006
	,-3.467431607e-004
	,-3.307155949e-004
	,-3.150617382e-004
	,-2.997345221e-004
	,-2.846631404e-004
	,-2.697427714e-004
	,-2.548413105e-004
	,-2.398814770e-004
	,-2.248766490e-004
	,-2.098905450e-004
	,-1.950914574e-004
	,-1.806359834e-004
	,-1.665921065e-004
	,-1.529722987e-004
	,-1.397917248e-004
	,-1.271083924e-004
	,-1.149598337e-004
	,-1.033537153e-004
	,-9.229070293e-005
	,-8.177085502e-005
	,-7.178511496e-005
	,-6.231253198e-005
	,-5.341330282e-005
	,-4.520055844e-005
	,-3.773627181e-005
	,-3.105734599e-005
	,-2.517684538e-005
	,-2.008563843e-005
	,-1.575677723e-005
	,-1.214686622e-005
	,-9.197116423e-006
	,-6.835320620e-006
	,-4.978511060e-006
	,-3.549778053e-006
	,-2.475604839e-006
	,-1.680187027e-006
	,-1.098010736e-006
	,-6.762103087e-007
	,-3.727938378e-007
	,-1.554499456e-007
	,3.002424270e-017
	,1.113216248e-007
	,1.913922838e-007
	,2.494490120e-007
	,2.920643736e-007
	,3.238857542e-007
	,3.481804599e-007
	,3.671924477e-007
	,3.824646609e-007
	,3.952489514e-007
	,4.063471860e-007
	,4.163018760e-007
	,4.254882063e-007
	,4.341661343e-007
	,4.425158139e-007
	,4.506620815e-007
	,4.586914208e-007
	,4.666637229e-007
	,4.746204369e-007
	,4.825902199e-007
	,4.905928525e-007
	,4.986419540e-007
	,5.067468644e-007
	,5.149139503e-007
	,5.231475103e-007
	,5.314504028e-007
	,5.398244791e-007
	,5.482708821e-007
	,5.567902483e-007
	,5.653828417e-007
	,5.740486385e-007
	,5.827873776e-007
	,5.915985834e-007
	,6.004815705e-007
	,6.094354346e-007
	,6.184590336e-007
	,6.275509593e-007
	,6.367095050e-007
	,6.459326271e-007
	,6.552179037e-007
	,6.645624908e-007
	,6.739630764e-007
	,6.834158344e-007
	,6.929163791e-007
	,7.024597212e-007
	,7.120402282e-007
	,7.216515894e-007
	,7.312867876e-007
	,7.409380776e-007
	,7.505969700e-007
	,7.602542165e-007
	,7.698997922e-007
	,7.795228680e-007
	,7.891117690e-007
	,7.986539229e-007
	,8.081358173e-007
	,8.175430039e-007
	,8.268602128e-007
	,8.360716484e-007
	,8.451615163e-007
	,8.541147630e-007
	,8.629178981e-007
	,8.715596827e-007
	,8.800314715e-007
	,8.883271366e-007
	,8.964426852e-007
	,9.043757902e-007
	,9.121254327e-007
	,9.196917066e-007
	,9.270755491e-007
	,9.342777006e-007
	,9.412999898e-007
	,9.481531271e-007
	,9.548511657e-007
	,9.614069997e-007
	,9.678367719e-007
	,9.741610496e-007
	,9.803998562e-007
	,9.865712224e-007
	,9.926911981e-007
	,9.987737773e-007
	,1.004830871e-006
	,1.010872399e-006
	,1.016906482e-006
	,1.022939680e-006
	,1.028977240e-006
	,1.035023338e-006
	,1.041081281e-006
	,1.047153694e-006
	,1.053242659e-006
	,1.059349841e-006
	,1.065476579e-006
	,1.071623960e-006
	,1.077792881e-006
	,1.083984093e-006
	,1.090198235e-006
	,1.096435849e-006
	,1.102697325e-006
	,1.108982476e-006
	,1.115288062e-006
	,1.121609136e-006
	,1.127951717e-006
	,1.134319090e-006
	,1.140711524e-006
	,1.147128725e-006
	,1.153570389e-006
	,1.160036479e-006
	,1.166526287e-006
	,1.173039850e-006
	,1.179577998e-006
	,1.186140936e-006
	,1.192728684e-006
	,1.199341219e-006
	,1.205978501e-006
	,1.212640485e-006
	,1.219327126e-006
	,1.226038459e-006
	,1.232774581e-006
	,1.239535571e-006
	,1.246321506e-006
	,1.253132473e-006
	,1.259968579e-006
	,1.266829954e-006
	,1.273716749e-006
	,1.280629136e-006
	,1.287567304e-006
	,1.294531447e-006
	,1.301521763e-006
	,1.308538434e-006
	,1.315581608e-006
	,1.322651679e-006
	,1.329749228e-006
	,1.336874741e-006
	,1.344028632e-006
	,1.351211298e-006
	,1.358423135e-006
	,1.365664546e-006
	,1.372935925e-006
	,1.380237639e-006
	,1.387569977e-006
	,1.394933143e-006
	,1.402327399e-006
	,1.409753138e-006
	,1.417210893e-006
	,1.424701493e-006
	,1.432225497e-006
	,1.439783379e-006
	,1.447375610e-006
	,1.455002666e-006
	,1.462665019e-006
	,1.470363131e-006
	,1.478097480e-006
	,1.485868579e-006
	,1.493677001e-006
	,1.501523404e-006
	,1.509408543e-006
	,1.517333232e-006
	,1.525298366e-006
	,1.533305021e-006
	,1.541354514e-006
	,1.549448508e-006
	,-3.525831539e-004
	,-3.365434502e-004
	,-3.208414967e-004
	,-3.053962788e-004
	,-2.900927259e-004
	,-2.747933247e-004
	,-2.593939284e-004
	,-2.439020382e-004
	,-2.283882143e-004
	,-2.130069194e-004
	,-1.979390870e-004
	,-1.832755059e-004
	,-1.690383829e-004
	,-1.552252950e-004
	,-1.418757110e-004
	,-1.290442895e-004
	,-1.167478159e-004
	,-1.049850239e-004
	,-9.375062157e-005
	,-8.302906468e-005
	,-7.278909512e-005
	,-6.308331425e-005
	,-5.403606614e-005
	,-4.571464306e-005
	,-3.816150858e-005
	,-3.140675280e-005
	,-2.545877487e-005
	,-2.030746913e-005
	,-1.592629295e-005
	,-1.227219347e-005
	,-9.285638234e-006
	,-6.890607801e-006
	,-5.009589796e-006
	,-3.570284256e-006
	,-2.489560171e-006
	,-1.689346074e-006
	,-1.103871858e-006
	,-6.798290776e-007
	,-3.748116548e-007
	,-1.563049621e-007
	,7.049040126e-018
	,1.119598408e-007
	,1.925163647e-007
	,2.509523582e-007
	,2.938727133e-007
	,3.259464768e-007
	,3.504379784e-007
	,3.695462752e-007
	,3.850011015e-007
	,3.979811090e-007
	,4.092727134e-007
	,4.194198988e-007
	,4.287999653e-007
	,4.376746888e-007
	,4.462257087e-007
	,4.545790750e-007
	,4.628222775e-007
	,4.710160557e-007
	,4.792025880e-007
	,4.874111694e-007
	,4.956621463e-007
	,5.039696461e-007
	,5.123434704e-007
	,5.207904085e-007
	,5.293151519e-007
	,5.379209295e-007
	,5.466099514e-007
	,5.553837181e-007
	,5.642432367e-007
	,5.731891707e-007
	,5.822219428e-007
	,5.913418040e-007
	,6.005488767e-007
	,6.098431786e-007
	,6.192246315e-007
	,6.286930581e-007
	,6.382481677e-007
	,6.478895344e-007
	,6.576165672e-007
	,6.674284726e-007
	,6.773242114e-007
	,6.873024491e-007
	,6.973614984e-007
	,7.074992535e-007
	,7.177131151e-007
	,7.279999043e-007
	,7.383557588e-007
	,7.487760093e-007
	,7.592550297e-007
	,7.697860592e-007
	,7.803609973e-007
	,7.909701792e-007
	,8.016021557e-007
	,8.122435324e-007
	,8.228789696e-007
	,8.334914996e-007
	,8.440633418e-007
	,8.545773022e-007
	,8.650185681e-007
	,8.753763316e-007
	,8.856445257e-007
	,8.958213066e-007
	,9.059075693e-007
	,9.159051871e-007
	,9.258155636e-007
	,9.356387346e-007
	,9.453729690e-007
	,9.550147199e-007
	,9.645587842e-007
	,9.739985764e-007
	,9.833264585e-007
	,9.925340934e-007
	,1.001612800e-006
	,1.010553900e-006
	,1.019349055e-006
	,1.027990594e-006
	,1.036471785e-006
	,1.044787018e-006
	,1.052932118e-006
	,1.060906186e-006
	,1.068713819e-006
	,1.076362737e-006
	,1.083858736e-006
	,1.091207541e-006
	,1.098430196e-006
	,1.105550660e-006
	,1.112588825e-006
	,1.119562352e-006
	,1.126487021e-006
	,1.133376627e-006
	,1.140242922e-006
	,1.147095709e-006
	,1.153943016e-006
	,1.160791337e-006
	,1.167645872e-006
	,1.174510768e-006
	,1.181389319e-006
	,1.188284149e-006
	,1.195197353e-006
	,1.202130617e-006
	,1.209085314e-006
	,1.216062576e-006
	,1.223063359e-006
	,1.230088483e-006
	,1.237138621e-006
	,1.244214113e-006
	,1.251313673e-006
	,1.258429170e-006
	,1.265558271e-006
	,1.272711338e-006
	,1.279890683e-006
	,1.287096076e-006
	,1.294328157e-006
	,1.301587510e-006
	,1.308874107e-006
	,1.316187730e-006
	,1.323528134e-006
	,1.330895030e-006
	,1.338287790e-006
	,1.345704917e-006
	,1.353146856e-006
	,1.360614954e-006
	,1.368109535e-006
	,1.375630694e-006
	,1.383178517e-006
	,1.390753089e-006
	,1.398354502e-006
	,1.405982866e-006
	,1.413638303e-006
	,1.421320973e-006
	,1.429031100e-006
	,1.436768922e-006
	,1.444534666e-006
	,1.452328522e-006
	,1.460150585e-006
	,1.468000854e-006
	,1.475879684e-006
	,1.483787853e-006
	,1.491726018e-006
	,1.499694670e-006
	,1.507694244e-006
	,1.515725180e-006
	,1.523787922e-006
	,1.531882904e-006
	,1.540010529e-006
	,1.548171141e-006
	,1.556364991e-006
	,1.564592334e-006
	,1.572853636e-006
	,1.581149495e-006
	,1.589480492e-006
	,1.597847148e-006
	,1.606249948e-006
	,1.614689338e-006
	,1.623165635e-006
	,1.631679220e-006
	,1.640230843e-006
	,1.648821090e-006
	,1.657450405e-006
	,1.666119178e-006
	,1.674827854e-006
	,-3.584259806e-004
	,-3.423487557e-004
	,-3.265216027e-004
	,-3.108149586e-004
	,-2.951035512e-004
	,-2.793019106e-004
	,-2.633853558e-004
	,-2.474054579e-004
	,-2.314895546e-004
	,-2.158358717e-004
	,-2.005681774e-004
	,-1.857266451e-004
	,-1.713075820e-004
	,-1.573194398e-004
	,-1.438208914e-004
	,-1.308477777e-004
	,-1.184024184e-004
	,-1.064758979e-004
	,-9.504760619e-005
	,-8.407591814e-005
	,-7.359467146e-005
	,-6.373718982e-005
	,-5.458171214e-005
	,-4.616941224e-005
	,-3.853954880e-005
	,-3.171737814e-005
	,-2.570872481e-005
	,-2.050331496e-005
	,-1.607498719e-005
	,-1.238028876e-005
	,-9.356006429e-006
	,-6.930205867e-006
	,-5.035032608e-006
	,-3.587967281e-006
	,-2.501653038e-006
	,-1.697281405e-006
	,-1.109012812e-006
	,-6.830201720e-007
	,-3.765957510e-007
	,-1.570621969e-007
	,-3.561173374e-017
	,1.125260318e-007
	,1.935138864e-007
	,2.522864157e-007
	,2.954765832e-007
	,3.277681483e-007
	,3.523746843e-007
	,3.716264736e-007
	,3.872582068e-007
	,4.004104914e-007
	,4.118705129e-007
	,4.221846093e-007
	,4.317321345e-007
	,4.407765234e-007
	,4.495007508e-007
	,4.580319556e-007
	,4.664585341e-007
	,4.748419987e-007
	,4.832252024e-007
	,4.916380402e-007
	,5.001014019e-007
	,5.086299108e-007
	,5.172338240e-007
	,5.259203486e-007
	,5.346945579e-007
	,5.435600271e-007
	,5.525192774e-007
	,5.615740874e-007
	,5.707257121e-007
	,5.799750378e-007
	,5.893226928e-007
	,5.987691260e-007
	,6.083146629e-007
	,6.179595430e-007
	,6.277039447e-007
	,6.375479970e-007
	,6.474917817e-007
	,6.575353247e-007
	,6.676785785e-007
	,6.779213940e-007
	,6.882634820e-007
	,6.987043629e-007
	,7.092433030e-007
	,7.198792336e-007
	,7.306106508e-007
	,7.414354880e-007
	,7.523509546e-007
	,7.633533329e-007
	,7.744377224e-007
	,7.855977284e-007
	,7.968251027e-007
	,8.081093820e-007
	,8.194376308e-007
	,8.307944930e-007
	,8.421628733e-007
	,8.535255254e-007
	,8.648674816e-007
	,8.761785747e-007
	,8.874548255e-007
	,8.986978937e-007
	,9.099129723e-007
	,9.211062986e-007
	,9.322832665e-007
	,9.434474478e-007
	,9.546003436e-007
	,9.657415455e-007
	,9.768690530e-007
	,9.879795968e-007
	,9.990689040e-007
	,1.010131879e-006
	,1.021162703e-006
	,1.032154868e-006
	,1.043101165e-006
	,1.053993660e-006
	,1.064823679e-006
	,1.075581827e-006
	,1.086258054e-006
	,1.096841757e-006
	,1.107321887e-006
	,1.117687042e-006
	,1.127925503e-006
	,1.138025410e-006
	,1.147975560e-006
	,1.157766781e-006
	,1.167392354e-006
	,1.176847507e-006
	,1.186129344e-006
	,1.195237271e-006
	,1.204173453e-006
	,1.212943070e-006
	,1.221554304e-006
	,1.230017981e-006
	,1.238346696e-006
	,1.246552338e-006
	,1.254639894e-006
	,1.262617476e-006
	,1.270516134e-006
	,1.278361255e-006
	,1.286169547e-006
	,1.293953804e-006
	,1.301724315e-006
	,1.309489395e-006
	,1.317255732e-006
	,1.325028682e-006
	,1.332812521e-006
	,1.340610665e-006
	,1.348425853e-006
	,1.356260303e-006
	,1.364115831e-006
	,1.371993954e-006
	,1.379895960e-006
	,1.387822948e-006
	,1.395775745e-006
	,1.403754302e-006
	,1.411753865e-006
	,1.419758990e-006
	,1.427776431e-006
	,1.435818239e-006
	,1.443888216e-006
	,1.451988019e-006
	,1.460117698e-006
	,1.468276851e-006
	,1.476465050e-006
	,1.484681939e-006
	,1.492927235e-006
	,1.501200727e-006
	,1.509502256e-006
	,1.517831703e-006
	,1.526188961e-006
	,1.534573842e-006
	,1.542985617e-006
	,1.551422370e-006
	,1.559885095e-006
	,1.568375803e-006
	,1.576895088e-006
	,1.585443205e-006
	,1.594020366e-006
	,1.602626794e-006
	,1.611262712e-006
	,1.619928302e-006
	,1.628623611e-006
	,1.637348484e-006
	,1.646103116e-006
	,1.654888513e-006
	,1.663705621e-006
	,1.672555046e-006
	,1.681437255e-006
	,1.690352680e-006
	,1.699301746e-006
	,1.708284874e-006
	,1.717302470e-006
	,1.726354893e-006
	,1.735442415e-006
	,1.744565262e-006
	,1.753723832e-006
	,1.762918758e-006
	,1.772150658e-006
	,1.781420047e-006
	,1.790727397e-006
	,1.800073155e-006
	,1.809457751e-006
	,-4.932948977e-007
	,-3.846703021e-007
	,-3.002722970e-007
	,-2.345668925e-007
	,-1.830831802e-007
	,-1.424962289e-007
	,-1.105493043e-007
	,-8.547033135e-008
	,-6.578399238e-008
	,-5.038214285e-008
	,-3.843683016e-008
	,-2.927245070e-008
	,-2.229287624e-008
	,-1.699117658e-008
	,-1.296242168e-008
	,-9.893998327e-009
	,-7.548412790e-009
	,-5.750587122e-009
	,-4.374773223e-009
	,-3.325303666e-009
	,-2.525809639e-009
	,-1.917003805e-009
	,-1.453524574e-009
	,-1.100277132e-009
	,-8.306997728e-010
	,-6.252732051e-010
	,-4.692471128e-010
	,-3.510805244e-010
	,-2.618719712e-010
	,-1.948147009e-010
	,-1.445860286e-010
	,-1.070036174e-010
	,-7.884843829e-011
	,-5.769323362e-011
	,-4.173226468e-011
	,-2.963651845e-011
	,-2.042146145e-011
	,-1.334480419e-011
	,-7.845886621e-012
	,-3.503569001e-012
	,4.697775894e-019
	,2.906235352e-012
	,5.398949327e-012
	,7.618391491e-012
	,9.670984758e-012
	,1.163579239e-011
	,1.357163492e-011
	,1.552778638e-011
	,1.755120255e-011
	,1.968808003e-011
	,2.198176155e-011
	,2.447275938e-011
	,2.719647189e-011
	,3.018377691e-011
	,3.346730185e-011
	,3.709542209e-011
	,4.115288344e-011
	,4.581090478e-011
	,5.126755465e-011
	,5.772178527e-011
	,6.550368736e-011
	,7.505800957e-011
	,8.690111609e-011
	,1.018120226e-010
	,1.208033259e-010
	,1.452116063e-010
	,1.768854598e-010
	,2.182566535e-010
	,2.726184695e-010
	,3.443765710e-010
	,4.394098771e-010
	,5.655505770e-010
	,7.331893814e-010
	,9.560618754e-010
	,1.250364343e-009
	,1.640040561e-009
	,2.155158981e-009
	,2.834686306e-009
	,3.721926865e-009
	,4.884317851e-009
	,6.404220719e-009
	,8.387562739e-009
	,1.097071223e-008
	,1.432914662e-008
	,1.868859853e-008
	,2.433938711e-008
	,3.165487083e-008
	,4.064462808e-008
	,5.188920222e-008
	,6.607539788e-008
	,8.319037995e-008
	,1.043666204e-007
	,1.307928456e-007
	,1.637323258e-007
	,2.047414970e-007
	,2.557372903e-007
	,3.190777089e-007
	,3.976607436e-007
	,4.950448648e-007
	,6.155963407e-007
	,7.646696610e-007
	,9.488284904e-007
	,1.173343364e-006
	,1.445719240e-006
	,1.773691210e-006
	,2.172341460e-006
	,2.655734003e-006
	,3.240669135e-006
	,3.946925082e-006
	,4.779385137e-006
	,5.695357307e-006
	,6.745736882e-006
	,7.850350000e-006
	,9.112832072e-006
	,1.056529680e-005
	,1.222875800e-005
	,1.412547680e-005
	,1.627893738e-005
	,1.871383089e-005
	,2.145607036e-005
	,2.453283929e-005
	,2.797264945e-005
	,3.180535337e-005
	,3.606200331e-005
	,4.057035073e-005
	,4.541714797e-005
	,5.068654754e-005
	,5.639596856e-005
	,6.255913214e-005
	,6.918709817e-005
	,7.582929258e-005
	,8.266294641e-005
	,8.928773622e-005
	,9.547073959e-005
	,1.020874432e-004
	,1.091166219e-004
	,1.165410396e-004
	,1.243478323e-004
	,1.325280713e-004
	,1.410770608e-004
	,1.499944946e-004
	,1.592846687e-004
	,1.689566438e-004
	,1.790249513e-004
	,1.893057333e-004
	,1.994854614e-004
	,2.099968362e-004
	,2.208357428e-004
	,2.320434454e-004
	,2.435154664e-004
	,2.553039837e-004
	,2.674681041e-004
	,2.795301013e-004
	,2.910366695e-004
	,3.028580147e-004
	,3.151194955e-004
	,3.278318956e-004
	,3.410117804e-004
	,3.546792127e-004
	,3.688585031e-004
	,3.831966686e-004
	,3.967214916e-004
	,4.101096387e-004
	,4.241027524e-004
	,4.386944250e-004
	,4.526738246e-004
	,4.665964721e-004
	,4.807466646e-004
	,4.952908977e-004
	,5.102942444e-004
	,5.257786869e-004
	,5.417712386e-004
	,5.582862884e-004
	,5.737916565e-004
	,5.885955993e-004
	,6.042205376e-004
	,6.207021420e-004
	,6.381186085e-004
	,6.540735467e-004
	,6.689394854e-004
	,6.843338403e-004
	,7.004653597e-004
	,7.172118343e-004
	,7.344391838e-004
	,7.521222765e-004
	,7.673454988e-004
	,7.812052507e-004
	,7.956511732e-004
	,8.105590130e-004
	,8.258544914e-004
	,8.415026360e-004
	,8.574699101e-004
	,8.735917352e-004
	,8.897810675e-004
	,9.028989190e-004
	,9.165560351e-004
	,9.306555863e-004
	,9.451431156e-004
	,9.599808717e-004
	,9.751399090e-004
	,9.905972693e-004
	,-1.504988106e-006
	,-1.187299884e-006
	,-9.343232802e-007
	,-7.324560768e-007
	,-5.718528985e-007
	,-4.444991149e-007
	,-3.437872494e-007
	,-2.648460783e-007
	,-2.037211783e-007
	,-1.567656182e-007
	,-1.207756480e-007
	,-9.316347372e-008
	,-7.191108373e-008
	,-5.547407151e-008
	,-4.272028324e-008
	,-3.283672397e-008
	,-2.518957745e-008
	,-1.926298296e-008
	,-1.465843356e-008
	,-1.108929465e-008
	,-8.350265750e-009
	,-6.271908154e-009
	,-4.706863930e-009
	,-3.532698585e-009
	,-2.652730807e-009
	,-1.993056771e-009
	,-1.498005814e-009
	,-1.125874554e-009
	,-8.455198297e-010
	,-6.338071769e-010
	,-4.737484671e-010
	,-3.527972697e-010
	,-2.614083470e-010
	,-1.922428021e-010
	,-1.397186531e-010
	,-9.965437011e-011
	,-6.891870414e-011
	,-4.514575799e-011
	,-2.655895529e-011
	,-1.184067752e-011
	,-2.542954167e-017
	,9.726441623e-012
	,1.791771504e-011
	,2.499592970e-011
	,3.127126844e-011
	,3.700223566e-011
	,4.242620477e-011
	,4.775160870e-011
	,5.314930531e-011
	,5.875586185e-011
	,6.468037150e-011
	,7.100937326e-011
	,7.781713068e-011
	,8.518339919e-011
	,9.319975973e-011
	,1.019656564e-010
	,1.115857510e-010
	,1.221767429e-010
	,1.338779357e-010
	,1.468492299e-010
	,1.612749803e-010
	,1.773737641e-010
	,1.953900537e-010
	,2.156721863e-010
	,2.386530250e-010
	,2.648770088e-010
	,2.950373906e-010
	,3.299269562e-010
	,3.706276930e-010
	,4.188890969e-010
	,4.771159501e-010
	,5.479982637e-010
	,6.358833437e-010
	,7.465453634e-010
	,8.870001483e-010
	,1.067743857e-009
	,1.301729191e-009
	,1.604611308e-009
	,2.001762953e-009
	,2.524743051e-009
	,3.206190365e-009
	,4.104826901e-009
	,5.291337856e-009
	,6.830133407e-009
	,8.829327911e-009
	,1.143498637e-008
	,1.482756023e-008
	,1.923365305e-008
	,2.493946221e-008
	,3.230691364e-008
	,4.179305660e-008
	,5.397418793e-008
	,6.957587657e-008
	,8.951027186e-008
	,1.149226478e-007
	,1.472499960e-007
	,1.882930313e-007
	,2.403066487e-007
	,3.061122296e-007
	,3.892366607e-007
	,4.920777809e-007
	,6.192268391e-007
	,7.775444492e-007
	,9.742456400e-007
	,1.218099634e-006
	,1.519678231e-006
	,1.891725748e-006
	,2.346896116e-006
	,2.859417304e-006
	,3.462815890e-006
	,4.135585398e-006
	,4.905323543e-006
	,5.808204940e-006
	,6.862712353e-006
	,8.088853429e-006
	,9.508157206e-006
	,1.114363458e-005
	,1.301973326e-005
	,1.516230362e-005
	,1.759858282e-005
	,2.035718662e-005
	,2.346805563e-005
	,2.693601530e-005
	,3.062807541e-005
	,3.469905139e-005
	,3.916795811e-005
	,4.405385193e-005
	,4.937293048e-005
	,5.513891194e-005
	,6.088657739e-005
	,6.667590375e-005
	,7.226953637e-005
	,7.794162870e-005
	,8.400554395e-005
	,9.045087278e-005
	,9.726805921e-005
	,1.044495234e-004
	,1.119896039e-004
	,1.198844683e-004
	,1.281303060e-004
	,1.367061671e-004
	,1.456391739e-004
	,1.549454248e-004
	,1.646018947e-004
	,1.741465963e-004
	,1.840277316e-004
	,1.942543596e-004
	,2.047944542e-004
	,2.156362610e-004
	,2.267315826e-004
	,2.381815104e-004
	,2.494537879e-004
	,2.604351381e-004
	,2.717821591e-004
	,2.834982497e-004
	,2.955953135e-004
	,3.080625472e-004
	,3.208680498e-004
	,3.341338290e-004
	,3.467638460e-004
	,3.594618061e-004
	,3.726729847e-004
	,3.863551882e-004
	,4.003248894e-004
	,4.146570245e-004
	,4.280633112e-004
	,4.418426943e-004
	,4.560227403e-004
	,4.706072126e-004
	,4.855416904e-004
	,5.007358508e-004
	,5.164023944e-004
	,5.318330576e-004
	,5.460092084e-004
	,5.604193008e-004
	,5.751651482e-004
	,5.907399696e-004
	,6.072004132e-004
	,6.231054049e-004
	,6.379407364e-004
	,6.534692095e-004
	,6.695926009e-004
	,6.863635227e-004
	,7.036246432e-004
	,7.207293411e-004
	,7.346140522e-004
	,7.491112233e-004
	,7.636683118e-004
	,7.785903672e-004
	,7.938624871e-004
	,8.094496400e-004
	,8.234651289e-004
	,8.363173335e-004
	,8.496686517e-004
	,8.633505368e-004
	,8.771070989e-004
	,8.912817619e-004
	,9.057918428e-004
	,9.206082891e-004
	,9.357108123e-004
	,9.510830689e-004
	,-4.480112711e-006
	,-3.576608696e-006
	,-2.843201771e-006
	,-2.255055555e-006
	,-1.784621506e-006
	,-1.407563334e-006
	,-1.104544014e-006
	,-8.624918145e-007
	,-6.716760725e-007
	,-5.222083319e-007
	,-4.049704669e-007
	,-3.128569016e-007
	,-2.408463441e-007
	,-1.848891132e-007
	,-1.415515458e-007
	,-1.081120569e-007
	,-8.237082951e-008
	,-6.261323775e-008
	,-4.754117572e-008
	,-3.610380367e-008
	,-2.744023820e-008
	,-2.087530950e-008
	,-1.589328051e-008
	,-1.210323250e-008
	,-9.210320996e-009
	,-6.997352534e-009
	,-5.307469143e-009
	,-4.020348329e-009
	,-3.040039837e-009
	,-2.291428804e-009
	,-1.717423556e-009
	,-1.276545031e-009
	,-9.394168238e-010
	,-6.835773924e-010
	,-4.904559106e-010
	,-3.449640370e-010
	,-2.352374465e-010
	,-1.520779392e-010
	,-8.845767505e-011
	,-3.908304263e-011
	,-1.013014542e-017
	,3.173524248e-011
	,5.831277264e-011
	,8.135982019e-011
	,1.020828004e-010
	,1.213910429e-010
	,1.400111670e-010
	,1.585488143e-010
	,1.775096572e-010
	,1.973132334e-010
	,2.183114172e-010
	,2.408180727e-010
	,2.651393554e-010
	,2.915697053e-010
	,3.203681211e-010
	,3.517312265e-010
	,3.857710591e-010
	,4.225538000e-010
	,4.622278048e-010
	,5.050905271e-010
	,5.515238467e-010
	,6.019105403e-010
	,6.565623257e-010
	,7.156405652e-010
	,7.790749587e-010
	,8.465786338e-010
	,9.178969093e-010
	,9.932731560e-010
	,1.073574521e-009
	,1.160214041e-009
	,1.254769332e-009
	,1.358910336e-009
	,1.474425117e-009
	,1.603353933e-009
	,1.748098784e-009
	,1.911573691e-009
	,2.098668775e-009
	,2.315546820e-009
	,2.570358841e-009
	,2.873291684e-009
	,3.236155722e-009
	,3.680417355e-009
	,4.232715635e-009
	,4.924662655e-009
	,5.804561512e-009
	,6.937839516e-009
	,8.404792361e-009
	,1.032300705e-008
	,1.284407302e-008
	,1.616733658e-008
	,2.056085167e-008
	,2.637232879e-008
	,3.403963283e-008
	,4.411326601e-008
	,5.734944806e-008
	,7.464230333e-008
	,9.705835019e-008
	,1.261597457e-007
	,1.638193045e-007
	,2.123981370e-007
	,2.748656334e-007
	,3.549465914e-007
	,4.572980941e-007
	,5.877143118e-007
	,7.504496484e-007
	,9.440822344e-007
	,1.183369646e-006
	,1.464761106e-006
	,1.798268871e-006
	,2.201543923e-006
	,2.687253703e-006
	,3.269707413e-006
	,3.964962994e-006
	,4.790890125e-006
	,5.767196127e-006
	,6.915421028e-006
	,8.258908115e-006
	,9.822757013e-006
	,1.163375949e-005
	,1.372029165e-005
	,1.610837804e-005
	,1.871491036e-005
	,2.163861869e-005
	,2.490671447e-005
	,2.854119037e-005
	,3.256262341e-005
	,3.698931762e-005
	,4.166413091e-005
	,4.631890992e-005
	,5.106257069e-005
	,5.577626122e-005
	,6.084562359e-005
	,6.627005403e-005
	,7.204702534e-005
	,7.816471054e-005
	,8.460882483e-005
	,9.139407187e-005
	,9.851899324e-005
	,1.059838981e-004
	,1.137914674e-004
	,1.219472521e-004
	,1.304603815e-004
	,1.393449375e-004
	,1.481766637e-004
	,1.573290200e-004
	,1.668126289e-004
	,1.766381386e-004
	,1.868191611e-004
	,1.972826973e-004
	,2.080791989e-004
	,2.184851561e-004
	,2.288655224e-004
	,2.395782352e-004
	,2.506276696e-004
	,2.620137963e-004
	,2.737568666e-004
	,2.858769555e-004
	,2.971036948e-004
	,3.087434145e-004
	,3.208439335e-004
	,3.333433123e-004
	,3.462631084e-004
	,3.596237760e-004
	,3.734703914e-004
	,3.874604736e-004
	,4.010190127e-004
	,4.148279847e-004
	,4.287707864e-004
	,4.430903238e-004
	,4.572234895e-004
	,4.717849801e-004
	,4.863333085e-004
	,4.993913044e-004
	,5.129812904e-004
	,5.271942065e-004
	,5.420548517e-004
	,5.576069733e-004
	,5.738504930e-004
	,5.903419504e-004
	,6.052227986e-004
	,6.207150519e-004
	,6.366734123e-004
	,6.531679635e-004
	,6.702273489e-004
	,6.852204425e-004
	,6.993205447e-004
	,7.137741476e-004
	,7.286302634e-004
	,7.430325007e-004
	,7.547360596e-004
	,7.670507249e-004
	,7.798794670e-004
	,7.931457830e-004
	,8.067892808e-004
	,8.207694086e-004
	,8.350561953e-004
	,8.495741223e-004
	,8.643174756e-004
	,8.793382977e-004
	,8.946032602e-004
	,9.101023037e-004
	,-1.245670769e-005
	,-1.018398465e-005
	,-8.299269821e-006
	,-6.750889477e-006
	,-5.476245967e-006
	,-4.419173633e-006
	,-3.543081778e-006
	,-2.817425358e-006
	,-2.216957696e-006
	,-1.729513618e-006
	,-1.343049761e-006
	,-1.041853575e-006
	,-8.086147038e-007
	,-6.278538349e-007
	,-4.870898599e-007
	,-3.770925404e-007
	,-2.913659820e-007
	,-2.247108887e-007
	,-1.729056145e-007
	,-1.326507685e-007
	,-1.013918626e-007
	,-7.722109213e-008
	,-5.866806591e-008
	,-4.447857722e-008
	,-3.362083744e-008
	,-2.532228983e-008
	,-1.901188589e-008
	,-1.424092146e-008
	,-1.064602592e-008
	,-7.943460707e-009
	,-5.913335732e-009
	,-4.388089194e-009
	,-3.241647401e-009
	,-2.378031164e-009
	,-1.725192592e-009
	,-1.229200354e-009
	,-8.496751729e-010
	,-5.565344018e-010
	,-3.275612494e-010
	,-1.462542970e-010
	,8.667747592e-018
	,1.209408706e-010
	,2.239770040e-010
	,3.146359303e-010
	,3.969629508e-010
	,4.738749503e-010
	,5.475337173e-010
	,6.197504634e-010
	,6.922241363e-010
	,7.663383261e-010
	,8.428177449e-010
	,9.216890351e-010
	,1.002731848e-009
	,1.086232097e-009
	,1.173263466e-009
	,1.265261392e-009
	,1.363592361e-009
	,1.469458121e-009
	,1.583974960e-009
	,1.708198027e-009
	,1.843112250e-009
	,1.989618608e-009
	,2.148531435e-009
	,2.320682350e-009
	,2.507150440e-009
	,2.709363759e-009
	,2.928953607e-009
	,3.167609503e-009
	,3.427055371e-009
	,3.709133259e-009
	,4.015944806e-009
	,4.349908788e-009
	,4.713779568e-009
	,5.110676632e-009
	,5.544086108e-009
	,6.017862988e-009
	,6.536214493e-009
	,7.103655180e-009
	,7.724934051e-009
	,8.405064988e-009
	,9.149385145e-009
	,9.964669713e-009
	,1.086104166e-008
	,1.185381945e-008
	,1.296308531e-008
	,1.421443682e-008
	,1.564082915e-008
	,1.727974328e-008
	,1.918591306e-008
	,2.143913400e-008
	,2.414221078e-008
	,2.743314062e-008
	,3.144675829e-008
	,3.643377511e-008
	,4.273331246e-008
	,5.068553958e-008
	,6.086241759e-008
	,7.405032763e-008
	,9.119043016e-008
	,1.132482463e-007
	,1.417935025e-007
	,1.788051669e-007
	,2.266314237e-007
	,2.883142579e-007
	,3.674984523e-007
	,4.686238430e-007
	,5.970869877e-007
	,7.593734855e-007
	,9.632350977e-007
	,1.217864573e-006
	,1.534070157e-006
	,1.924441718e-006
	,2.403499516e-006
	,2.987815443e-006
	,3.696100956e-006
	,4.549249022e-006
	,5.570299361e-006
	,6.784284509e-006
	,8.180873852e-006
	,9.792900451e-006
	,1.165556714e-005
	,1.379324006e-005
	,1.623038259e-005
	,1.898972744e-005
	,2.209205910e-005
	,2.534518783e-005
	,2.877744060e-005
	,3.229880494e-005
	,3.599682319e-005
	,4.000596844e-005
	,4.431799238e-005
	,4.895234183e-005
	,5.391144037e-005
	,5.919673432e-005
	,6.480889986e-005
	,7.074820678e-005
	,7.701512253e-005
	,8.361101491e-005
	,9.053876454e-005
	,9.780332458e-005
	,1.054124502e-004
	,1.133488180e-004
	,1.213518590e-004
	,1.296707128e-004
	,1.383118638e-004
	,1.472842330e-004
	,1.565991065e-004
	,1.662417412e-004
	,1.761649393e-004
	,1.856552892e-004
	,1.954660041e-004
	,2.055980331e-004
	,2.160592203e-004
	,2.267430203e-004
	,2.372204667e-004
	,2.474573735e-004
	,2.580843144e-004
	,2.690996640e-004
	,2.804968867e-004
	,2.922926835e-004
	,3.045027399e-004
	,3.171028986e-004
	,3.301143889e-004
	,3.430963460e-004
	,3.557187550e-004
	,3.683978628e-004
	,3.814772154e-004
	,3.949538691e-004
	,4.086502306e-004
	,4.227451278e-004
	,4.364415333e-004
	,4.491982969e-004
	,4.624460768e-004
	,4.761840888e-004
	,4.904349999e-004
	,5.051050722e-004
	,5.202713186e-004
	,5.360845265e-004
	,5.526204290e-004
	,5.679087244e-004
	,5.832097270e-004
	,5.990322952e-004
	,6.153792487e-004
	,6.316607846e-004
	,6.457702545e-004
	,6.603294206e-004
	,6.717322246e-004
	,6.835916616e-004
	,6.960033103e-004
	,7.088668812e-004
	,7.221147880e-004
	,7.355593279e-004
	,7.492496043e-004
	,7.632399730e-004
	,7.775000136e-004
	,7.920122583e-004
	,8.067631313e-004
	,8.217419348e-004
	,8.369199438e-004
	,8.522593670e-004
	,8.678107922e-004
	,-3.159253599e-005
	,-2.685313970e-005
	,-2.260607079e-005
	,-1.888657911e-005
	,-1.565808491e-005
	,-1.288250344e-005
	,-1.054098291e-005
	,-8.593611881e-006
	,-6.975370256e-006
	,-5.630552801e-006
	,-4.520776494e-006
	,-3.610445629e-006
	,-2.869158279e-006
	,-2.266727537e-006
	,-1.780670917e-006
	,-1.391576130e-006
	,-1.080723378e-006
	,-8.331623358e-007
	,-6.382131372e-007
	,-4.873950424e-007
	,-3.720167210e-007
	,-2.839186892e-007
	,-2.165502302e-007
	,-1.650629333e-007
	,-1.256761409e-007
	,-9.553687828e-008
	,-7.254434229e-008
	,-5.503800774e-008
	,-4.169448258e-008
	,-3.150301332e-008
	,-2.371473935e-008
	,-1.776791847e-008
	,-1.323670705e-008
	,-9.783637306e-009
	,-7.141432321e-009
	,-5.106109539e-009
	,-3.524568231e-009
	,-2.292757548e-009
	,-1.334895952e-009
	,-5.879017965e-010
	,-1.952909193e-017
	,4.705565167e-010
	,8.571058031e-010
	,1.185611890e-009
	,1.476014348e-009
	,1.743571019e-009
	,1.999892494e-009
	,2.253796790e-009
	,2.511959624e-009
	,2.779410153e-009
	,3.059997788e-009
	,3.356818545e-009
	,3.672620628e-009
	,4.010409951e-009
	,4.373924820e-009
	,4.767258085e-009
	,5.194209238e-009
	,5.658067504e-009
	,6.161849666e-009
	,6.708759571e-009
	,7.302444025e-009
	,7.946843439e-009
	,8.645558614e-009
	,9.401180361e-009
	,1.021529816e-008
	,1.108881653e-008
	,1.202349695e-008
	,1.302328396e-008
	,1.409333663e-008
	,1.523824707e-008
	,1.646129320e-008
	,1.776430436e-008
	,1.914679889e-008
	,2.060431843e-008
	,2.212793466e-008
	,2.370776104e-008
	,2.533994610e-008
	,2.703091161e-008
	,2.879569480e-008
	,3.065452224e-008
	,3.262895362e-008
	,3.473931249e-008
	,3.700382725e-008
	,3.943910975e-008
	,4.206110085e-008
	,4.488713271e-008
	,4.793720296e-008
	,5.123632321e-008
	,5.481459622e-008
	,5.870796386e-008
	,6.295862588e-008
	,6.761680610e-008
	,7.274415310e-008
	,7.841675976e-008
	,8.472673956e-008
	,9.182093915e-008
	,9.988542300e-008
	,1.091660202e-007
	,1.199888711e-007
	,1.327944269e-007
	,1.480050976e-007
	,1.664956094e-007
	,1.893354637e-007
	,2.179615307e-007
	,2.540160523e-007
	,3.000426777e-007
	,3.593354763e-007
	,4.358512038e-007
	,5.348034690e-007
	,6.629073453e-007
	,8.280612974e-007
	,1.039339578e-006
	,1.306171737e-006
	,1.642248292e-006
	,2.062745606e-006
	,2.584732066e-006
	,3.227058532e-006
	,4.010304122e-006
	,4.956189113e-006
	,6.088063169e-006
	,7.429020844e-006
	,8.945510125e-006
	,1.064103628e-005
	,1.254343143e-005
	,1.459600743e-005
	,1.688173806e-005
	,1.942510559e-005
	,2.223853948e-005
	,2.533240076e-005
	,2.871535245e-005
	,3.239448234e-005
	,3.637553334e-005
	,4.066302717e-005
	,4.526048251e-005
	,5.017073649e-005
	,5.539633759e-005
	,6.094005097e-005
	,6.680544980e-005
	,7.299749016e-005
	,7.952327805e-005
	,8.628381978e-005
	,9.327821902e-005
	,1.005853419e-004
	,1.082110958e-004
	,1.161630584e-004
	,1.244510283e-004
	,1.330842129e-004
	,1.416287111e-004
	,1.503164982e-004
	,1.593114911e-004
	,1.686207265e-004
	,1.780054379e-004
	,1.870935806e-004
	,1.965235751e-004
	,2.062951912e-004
	,2.163464305e-004
	,2.264312736e-004
	,2.363341933e-004
	,2.466570395e-004
	,2.574005832e-004
	,2.685703816e-004
	,2.801382930e-004
	,2.921298242e-004
	,3.044239061e-004
	,3.164637052e-004
	,3.288711263e-004
	,3.416470484e-004
	,3.547996731e-004
	,3.682691979e-004
	,3.813353868e-004
	,3.941698388e-004
	,4.073992178e-004
	,4.210202738e-004
	,4.349465923e-004
	,4.490446947e-004
	,4.635893341e-004
	,4.786260234e-004
	,4.942055035e-004
	,5.102218515e-004
	,5.263688042e-004
	,5.415925915e-004
	,5.572839299e-004
	,5.733361970e-004
	,5.855181624e-004
	,5.968655339e-004
	,6.089655337e-004
	,6.216031447e-004
	,6.346733788e-004
	,6.479442554e-004
	,6.612772094e-004
	,6.748933886e-004
	,6.887699209e-004
	,7.028905035e-004
	,7.171884374e-004
	,7.316034671e-004
	,7.462404716e-004
	,7.610853456e-004
	,7.761313245e-004
	,7.913729595e-004
	,8.068058432e-004
	,8.224365075e-004
	,-6.839859478e-005
	,-6.044915238e-005
	,-5.307782867e-005
	,-4.628604074e-005
	,-4.000814844e-005
	,-3.427688245e-005
	,-2.920276959e-005
	,-2.478351305e-005
	,-2.091251984e-005
	,-1.747309078e-005
	,-1.443632684e-005
	,-1.181053579e-005
	,-9.581109752e-006
	,-7.712568533e-006
	,-6.164383604e-006
	,-4.907358276e-006
	,-3.900526975e-006
	,-3.094491980e-006
	,-2.446614935e-006
	,-1.928418432e-006
	,-1.514475093e-006
	,-1.181153157e-006
	,-9.148572032e-007
	,-7.053471221e-007
	,-5.412668662e-007
	,-4.125593635e-007
	,-3.124435501e-007
	,-2.353321860e-007
	,-1.763264782e-007
	,-1.315478123e-007
	,-9.786721870e-008
	,-7.263248947e-008
	,-5.370342270e-008
	,-3.944311723e-008
	,-2.863774440e-008
	,-2.040808799e-008
	,-1.411104816e-008
	,-9.255543506e-009
	,-5.462289490e-009
	,-2.447026193e-009
	,1.388938454e-017
	,2.027564891e-009
	,3.737646461e-009
	,5.220061434e-009
	,6.556851798e-009
	,7.812880763e-009
	,9.036379917e-009
	,1.026106364e-008
	,1.150695223e-008
	,1.278118630e-008
	,1.408210971e-008
	,1.540859714e-008
	,1.676739669e-008
	,1.816950053e-008
	,1.962306620e-008
	,2.113223596e-008
	,2.270080629e-008
	,2.433857125e-008
	,2.606407569e-008
	,2.790056094e-008
	,2.987061747e-008
	,3.199389837e-008
	,3.428693793e-008
	,3.676334675e-008
	,3.943419755e-008
	,4.230942411e-008
	,4.539962199e-008
	,4.871591386e-008
	,5.226831614e-008
	,5.606708817e-008
	,6.012658736e-008
	,6.446152988e-008
	,6.908558792e-008
	,7.401557563e-008
	,7.927414913e-008
	,8.488804743e-008
	,9.088498697e-008
	,9.729257754e-008
	,1.041397789e-007
	,1.114588845e-007
	,1.192855532e-007
	,1.276571007e-007
	,1.366108371e-007
	,1.461831006e-007
	,1.564084331e-007
	,1.673183693e-007
	,1.789402575e-007
	,1.912970068e-007
	,2.044091353e-007
	,2.183017592e-007
	,2.330153559e-007
	,2.486124340e-007
	,2.651714550e-007
	,2.827777308e-007
	,3.015188724e-007
	,3.214839481e-007
	,3.427649044e-007
	,3.654597707e-007
	,3.896756459e-007
	,4.155341413e-007
	,4.431560869e-007
	,4.727129148e-007
	,5.043874007e-007
	,5.384027117e-007
	,5.750743768e-007
	,6.148380070e-007
	,6.584032438e-007
	,7.067784042e-007
	,7.615447913e-007
	,8.247052973e-007
	,8.988059246e-007
	,9.866976037e-007
	,1.092808058e-006
	,1.222427412e-006
	,1.383000403e-006
	,1.583767186e-006
	,1.835275022e-006
	,2.150071253e-006
	,2.543704557e-006
	,3.032756442e-006
	,3.634470344e-006
	,4.368822271e-006
	,5.255477454e-006
	,6.313284081e-006
	,7.561708903e-006
	,9.018933414e-006
	,1.070167844e-005
	,1.262492562e-005
	,1.480079145e-005
	,1.724174724e-005
	,1.995800341e-005
	,2.295797158e-005
	,2.624871437e-005
	,2.983621297e-005
	,3.372568986e-005
	,3.792198318e-005
	,4.242998238e-005
	,4.725508961e-005
	,5.233176996e-005
	,5.770815131e-005
	,6.339486229e-005
	,6.939658222e-005
	,7.570652144e-005
	,8.228722011e-005
	,8.917221613e-005
	,9.611622488e-005
	,1.033373476e-004
	,1.108352417e-004
	,1.181521147e-004
	,1.256171641e-004
	,1.331327928e-004
	,1.409607910e-004
	,1.491025025e-004
	,1.575621447e-004
	,1.663462589e-004
	,1.754632271e-004
	,1.849229445e-004
	,1.947365842e-004
	,2.049164230e-004
	,2.154757656e-004
	,2.261902928e-004
	,2.372377036e-004
	,2.486762274e-004
	,2.601718354e-004
	,2.718057252e-004
	,2.837772837e-004
	,2.960919865e-004
	,3.087543582e-004
	,3.209454120e-004
	,3.333261659e-004
	,3.460909270e-004
	,3.592467811e-004
	,3.727164552e-004
	,3.863660059e-004
	,4.003723622e-004
	,4.147596513e-004
	,4.295627876e-004
	,4.445499159e-004
	,4.596756477e-004
	,4.742118988e-004
	,4.886283605e-004
	,5.026336160e-004
	,5.159658347e-004
	,5.279616452e-004
	,5.405623010e-004
	,5.535685662e-004
	,5.668723876e-004
	,5.804784744e-004
	,5.943557738e-004
	,6.083536852e-004
	,6.222644607e-004
	,6.363092318e-004
	,6.505407472e-004
	,6.649695483e-004
	,6.795907478e-004
	,6.944008524e-004
	,7.093060155e-004
	,7.243610607e-004
	,7.395938555e-004
	,7.550016252e-004
	,7.705821320e-004
	,-1.243262878e-004
	,-1.130886886e-004
	,-1.026285561e-004
	,-9.290353540e-005
	,-8.382473318e-005
	,-7.529419922e-005
	,-6.718425206e-005
	,-5.948814781e-005
	,-5.225284225e-005
	,-4.549932503e-005
	,-3.926905546e-005
	,-3.363428503e-005
	,-2.860776682e-005
	,-2.418278748e-005
	,-2.033542716e-005
	,-1.700359436e-005
	,-1.408759692e-005
	,-1.150413043e-005
	,-9.250750369e-006
	,-7.356326208e-006
	,-5.820191675e-006
	,-4.600408182e-006
	,-3.639729736e-006
	,-2.883218151e-006
	,-2.283718520e-006
	,-1.805511767e-006
	,-1.419696618e-006
	,-1.103344466e-006
	,-8.446590453e-007
	,-6.387129939e-007
	,-4.789347905e-007
	,-3.568138850e-007
	,-2.641093266e-007
	,-1.938258979e-007
	,-1.404980608e-007
	,-9.991737710e-008
	,-6.887065796e-008
	,-4.494818442e-008
	,-2.634265497e-008
	,-1.169527704e-008
	,1.670906849e-017
	,9.489154088e-009
	,1.734404247e-008
	,2.402544485e-008
	,2.990299275e-008
	,3.527397710e-008
	,4.037494035e-008
	,4.536701100e-008
	,5.030709787e-008
	,5.528063941e-008
	,6.046784936e-008
	,6.595669739e-008
	,7.178819915e-008
	,7.800514848e-008
	,8.466143458e-008
	,9.180789352e-008
	,9.948420105e-008
	,1.077284464e-007
	,1.165695773e-007
	,1.260219822e-007
	,1.360959448e-007
	,1.467979109e-007
	,1.581196474e-007
	,1.700332777e-007
	,1.825092592e-007
	,1.955534842e-007
	,2.092284372e-007
	,2.236358581e-007
	,2.388847141e-007
	,2.550742397e-007
	,2.722887836e-007
	,2.905902508e-007
	,3.100051580e-007
	,3.305017227e-007
	,3.519698413e-007
	,3.742477738e-007
	,3.971944313e-007
	,4.207060688e-007
	,4.446962226e-007
	,4.690723926e-007
	,4.937603791e-007
	,5.187793989e-007
	,5.442644019e-007
	,5.703954652e-007
	,5.973222711e-007
	,6.251400615e-007
	,6.539080795e-007
	,6.836855815e-007
	,7.145522366e-007
	,7.465959839e-007
	,7.798926294e-007
	,8.145018578e-007
	,8.504772697e-007
	,8.878751604e-007
	,9.267529326e-007
	,9.671629301e-007
	,1.009150350e-006
	,1.052761346e-006
	,1.098045392e-006
	,1.145049086e-006
	,1.193817069e-006
	,1.244394121e-006
	,1.296828103e-006
	,1.351174675e-006
	,1.407500901e-006
	,1.465891555e-006
	,1.526398989e-006
	,1.589165503e-006
	,1.654371371e-006
	,1.722245082e-006
	,1.793097667e-006
	,1.867357693e-006
	,1.945622567e-006
	,2.028688726e-006
	,2.117717643e-006
	,2.214253052e-006
	,2.320343065e-006
	,2.438674405e-006
	,2.572666155e-006
	,2.726936757e-006
	,2.907121701e-006
	,3.120334159e-006
	,3.376499842e-006
	,3.687409509e-006
	,4.067154217e-006
	,4.531299103e-006
	,5.098722512e-006
	,5.791588570e-006
	,6.632968207e-006
	,7.645734882e-006
	,8.854100160e-006
	,1.028056682e-005
	,1.194492854e-005
	,1.386723349e-005
	,1.606473150e-005
	,1.855118497e-005
	,2.133731749e-005
	,2.443261697e-005
	,2.784427097e-005
	,3.154653035e-005
	,3.550709511e-005
	,3.971169219e-005
	,4.418275320e-005
	,4.894007980e-005
	,5.398430839e-005
	,5.931593591e-005
	,6.493426965e-005
	,7.083912375e-005
	,7.703103911e-005
	,8.351140512e-005
	,9.028242342e-005
	,9.734746783e-005
	,1.047107825e-004
	,1.123776600e-004
	,1.203543747e-004
	,1.286481830e-004
	,1.372672192e-004
	,1.462206118e-004
	,1.555088124e-004
	,1.651505570e-004
	,1.751574807e-004
	,1.855274835e-004
	,1.962741051e-004
	,2.070097737e-004
	,2.178241891e-004
	,2.289670744e-004
	,2.403063129e-004
	,2.515343870e-004
	,2.630752576e-004
	,2.749296951e-004
	,2.871030145e-004
	,2.996032762e-004
	,3.124403044e-004
	,3.255063593e-004
	,3.379857143e-004
	,3.508379402e-004
	,3.640739867e-004
	,3.776316762e-004
	,3.914536879e-004
	,4.057545091e-004
	,4.205798425e-004
	,4.353528023e-004
	,4.481744134e-004
	,4.612238036e-004
	,4.746512996e-004
	,4.883005358e-004
	,5.021446942e-004
	,5.162268244e-004
	,5.305091166e-004
	,5.449482943e-004
	,5.595166964e-004
	,5.736698462e-004
	,5.880018513e-004
	,6.024805765e-004
	,6.170979795e-004
	,6.318787908e-004
	,6.468287083e-004
	,6.619470568e-004
	,6.770976811e-004
	,6.912640070e-004
	,7.055850802e-004
	,-1.927147318e-004
	,-1.803301658e-004
	,-1.684155358e-004
	,-1.569346183e-004
	,-1.457890095e-004
	,-1.348563114e-004
	,-1.240779730e-004
	,-1.134768998e-004
	,-1.031818108e-004
	,-9.338481207e-005
	,-8.416028654e-005
	,-7.544706940e-005
	,-6.719836207e-005
	,-5.945746614e-005
	,-5.221120329e-005
	,-4.543010977e-005
	,-3.921389617e-005
	,-3.361119107e-005
	,-2.858537730e-005
	,-2.408905113e-005
	,-2.013311387e-005
	,-1.673441982e-005
	,-1.385654159e-005
	,-1.142278026e-005
	,-9.348075243e-006
	,-7.566337372e-006
	,-6.054277844e-006
	,-4.800208245e-006
	,-3.779303284e-006
	,-2.960457082e-006
	,-2.302153234e-006
	,-1.764770112e-006
	,-1.329017986e-006
	,-9.882102026e-007
	,-7.262204735e-007
	,-5.237937150e-007
	,-3.657916206e-007
	,-2.413641679e-007
	,-1.426636286e-007
	,-6.371446966e-008
	,-3.498666502e-018
	,5.179991460e-008
	,9.451301696e-008
	,1.306164047e-007
	,1.620389169e-007
	,1.902951991e-007
	,2.165403657e-007
	,2.415335242e-007
	,2.657996762e-007
	,2.897984507e-007
	,3.139292305e-007
	,3.384520310e-007
	,3.634530899e-007
	,3.887763325e-007
	,4.142381374e-007
	,4.400356534e-007
	,4.662190123e-007
	,4.930114443e-007
	,5.208145167e-007
	,5.498427536e-007
	,5.803418379e-007
	,6.125313853e-007
	,6.465526357e-007
	,6.824578496e-007
	,7.202401634e-007
	,7.598971726e-007
	,8.014336449e-007
	,8.448148765e-007
	,8.899269043e-007
	,9.365811293e-007
	,9.845995247e-007
	,1.033890040e-006
	,1.084404421e-006
	,1.136061570e-006
	,1.188748906e-006
	,1.242387270e-006
	,1.296965638e-006
	,1.352532071e-006
	,1.409189495e-006
	,1.467083534e-006
	,1.526356528e-006
	,1.587131897e-006
	,1.649541974e-006
	,1.713667872e-006
	,1.779518708e-006
	,1.847031565e-006
	,1.916047511e-006
	,1.986283734e-006
	,2.057357242e-006
	,2.128900090e-006
	,2.200660284e-006
	,2.272465491e-006
	,2.344128558e-006
	,2.415395213e-006
	,2.485942549e-006
	,2.555427572e-006
	,2.623587715e-006
	,2.690324451e-006
	,2.755674225e-006
	,2.819708648e-006
	,2.882471933e-006
	,2.943987336e-006
	,3.004296845e-006
	,3.063479471e-006
	,3.121623209e-006
	,3.178777586e-006
	,3.234947336e-006
	,3.290111623e-006
	,3.344251285e-006
	,3.397376853e-006
	,3.449550656e-006
	,3.500892384e-006
	,3.551547387e-006
	,3.601700625e-006
	,3.651655429e-006
	,3.701740833e-006
	,3.752321760e-006
	,3.803792115e-006
	,3.856587295e-006
	,3.911216272e-006
	,3.968307373e-006
	,4.028664796e-006
	,4.093337098e-006
	,4.163701019e-006
	,4.241565950e-006
	,4.329303507e-006
	,4.429865896e-006
	,4.547351831e-006
	,4.686788901e-006
	,4.854809380e-006
	,5.059692805e-006
	,5.311714051e-006
	,5.623429371e-006
	,6.009920756e-006
	,6.488723394e-006
	,7.080009119e-006
	,7.806930735e-006
	,8.694389189e-006
	,9.768527590e-006
	,1.105523212e-005
	,1.258121517e-005
	,1.437108345e-005
	,1.644626402e-005
	,1.882647843e-005
	,2.152753678e-005
	,2.456138069e-005
	,2.793760643e-005
	,3.166239116e-005
	,3.573940209e-005
	,4.017089092e-005
	,4.495751898e-005
	,5.009901536e-005
	,5.559469113e-005
	,6.144398591e-005
	,6.764646661e-005
	,7.420217474e-005
	,8.111179837e-005
	,8.837679087e-005
	,9.599944852e-005
	,1.039829096e-004
	,1.123303415e-004
	,1.210454763e-004
	,1.300468099e-004
	,1.394001360e-004
	,1.489957978e-004
	,1.588693931e-004
	,1.690607917e-004
	,1.793015055e-004
	,1.896229287e-004
	,2.000590209e-004
	,2.107793541e-004
	,2.217847690e-004
	,2.330777720e-004
	,2.446625630e-004
	,2.565451075e-004
	,2.687332138e-004
	,2.812365831e-004
	,2.940667932e-004
	,3.072372111e-004
	,3.207627993e-004
	,3.346635805e-004
	,3.486500442e-004
	,3.625287096e-004
	,3.761078870e-004
	,3.898964131e-004
	,4.039476006e-004
	,4.181739183e-004
	,4.325235157e-004
	,4.470864651e-004
	,4.617513221e-004
	,4.766032452e-004
	,4.916136757e-004
	,5.066834427e-004
	,5.199007286e-004
	,5.331504020e-004
	,5.465504914e-004
	,5.600887579e-004
	,5.737661472e-004
	,5.875736286e-004
	,6.015137457e-004
	,6.155833906e-004
	,-2.500713666e-004
	,-2.365775634e-004
	,-2.232503647e-004
	,-2.101807529e-004
	,-1.974567856e-004
	,-1.851335947e-004
	,-1.732372523e-004
	,-1.617850702e-004
	,-1.507963607e-004
	,-1.402907374e-004
	,-1.302818789e-004
	,-1.207731514e-004
	,-1.117565243e-004
	,-1.032150028e-004
	,-9.512528706e-005
	,-8.744703474e-005
	,-8.008050805e-005
	,-7.280842802e-005
	,-6.539154113e-005
	,-5.788946191e-005
	,-5.060003038e-005
	,-4.378229156e-005
	,-3.756223160e-005
	,-3.195989645e-005
	,-2.693863233e-005
	,-2.250450079e-005
	,-1.866211759e-005
	,-1.537201381e-005
	,-1.257833565e-005
	,-1.022186787e-005
	,-8.244452220e-006
	,-6.590724179e-006
	,-5.207385172e-006
	,-4.049156158e-006
	,-3.084742283e-006
	,-2.288033797e-006
	,-1.631751185e-006
	,-1.090401675e-006
	,-6.474583607e-007
	,-2.893202230e-007
	,1.514104967e-018
	,2.350400866e-007
	,4.275608874e-007
	,5.880190013e-007
	,7.250806784e-007
	,8.443683600e-007
	,9.482724415e-007
	,1.038756666e-006
	,1.120972555e-006
	,1.199273409e-006
	,1.275827093e-006
	,1.351410716e-006
	,1.425550552e-006
	,1.497329921e-006
	,1.567557690e-006
	,1.636770165e-006
	,1.704639428e-006
	,1.770895927e-006
	,1.835535754e-006
	,1.898391546e-006
	,1.959757590e-006
	,2.020858900e-006
	,2.082483451e-006
	,2.144925989e-006
	,2.207942293e-006
	,2.271571439e-006
	,2.335357354e-006
	,2.398377805e-006
	,2.459916607e-006
	,2.519721189e-006
	,2.578005230e-006
	,2.635224981e-006
	,2.691785918e-006
	,2.747953928e-006
	,2.803862793e-006
	,2.859503672e-006
	,2.914726684e-006
	,2.969405297e-006
	,3.023586403e-006
	,3.077378454e-006
	,3.130814370e-006
	,3.183817395e-006
	,3.236283831e-006
	,3.288216653e-006
	,3.339689043e-006
	,3.390724240e-006
	,3.441289110e-006
	,3.491378949e-006
	,3.541056386e-006
	,3.590375276e-006
	,3.639359305e-006
	,3.688026915e-006
	,3.736391740e-006
	,3.784449567e-006
	,3.832174416e-006
	,3.879516854e-006
	,3.926401176e-006
	,3.972738921e-006
	,4.018465664e-006
	,4.063564841e-006
	,4.108051573e-006
	,4.151944137e-006
	,4.195247680e-006
	,4.237948279e-006
	,4.280012695e-006
	,4.321398798e-006
	,4.362082464e-006
	,4.402080021e-006
	,4.441435484e-006
	,4.480190820e-006
	,4.518377199e-006
	,4.556014683e-006
	,4.593127745e-006
	,4.629757037e-006
	,4.665954139e-006
	,4.701770784e-006
	,4.737257335e-006
	,4.772468517e-006
	,4.807467611e-006
	,4.842281720e-006
	,4.877007426e-006
	,4.911728645e-006
	,4.946546386e-006
	,4.981585422e-006
	,5.017003096e-006
	,5.053001253e-006
	,5.089842248e-006
	,5.127869274e-006
	,5.167533137e-006
	,5.209427214e-006
	,5.254333002e-006
	,5.303279505e-006
	,5.357619477e-006
	,5.419126583e-006
	,5.489980482e-006
	,5.573265391e-006
	,5.672861666e-006
	,5.793745632e-006
	,5.942250157e-006
	,6.126339043e-006
	,6.355912014e-006
	,6.643104913e-006
	,7.002559072e-006
	,7.451535938e-006
	,8.010178255e-006
	,8.701264228e-006
	,9.549898906e-006
	,1.058297166e-005
	,1.182827339e-005
	,1.331380437e-005
	,1.506677520e-005
	,1.711234784e-005
	,1.947257217e-005
	,2.216756775e-005
	,2.521245973e-005
	,2.862024334e-005
	,3.240054608e-005
	,3.655973005e-005
	,4.110175010e-005
	,4.602832556e-005
	,5.133963540e-005
	,5.703465236e-005
	,6.311149962e-005
	,6.956776603e-005
	,7.640084826e-005
	,8.360807407e-005
	,9.118690403e-005
	,9.913507084e-005
	,1.074506557e-004
	,1.161322920e-004
	,1.251791397e-004
	,1.345910218e-004
	,1.443684428e-004
	,1.545128722e-004
	,1.649968803e-004
	,1.753970493e-004
	,1.861448869e-004
	,1.972404995e-004
	,2.086665394e-004
	,2.203448840e-004
	,2.323409798e-004
	,2.445675844e-004
	,2.569585021e-004
	,2.694954279e-004
	,2.822199104e-004
	,2.951883473e-004
	,3.083657366e-004
	,3.217606822e-004
	,3.353694185e-004
	,3.491807470e-004
	,3.630904312e-004
	,3.771164262e-004
	,3.913110256e-004
	,4.056220117e-004
	,4.200958823e-004
	,4.347055062e-004
	,4.494452085e-004
	,4.643305007e-004
	,4.784029301e-004
	,4.923944121e-004
	,5.065165399e-004
	,-2.914754550e-004
	,-2.771338027e-004
	,-2.631253788e-004
	,-2.494725165e-004
	,-2.361740064e-004
	,-2.232278763e-004
	,-2.106353474e-004
	,-1.983930549e-004
	,-1.864860222e-004
	,-1.748774995e-004
	,-1.635238434e-004
	,-1.524963087e-004
	,-1.419035087e-004
	,-1.317873975e-004
	,-1.221626967e-004
	,-1.130208423e-004
	,-1.043222244e-004
	,-9.599865350e-005
	,-8.796738753e-005
	,-8.016667052e-005
	,-7.259826941e-005
	,-6.532384898e-005
	,-5.840356097e-005
	,-5.185602700e-005
	,-4.569797339e-005
	,-3.997500129e-005
	,-3.470989039e-005
	,-2.989428081e-005
	,-2.550418551e-005
	,-2.151173080e-005
	,-1.789405060e-005
	,-1.464681679e-005
	,-1.178029179e-005
	,-9.289449789e-006
	,-7.151248991e-006
	,-5.333876404e-006
	,-3.805864856e-006
	,-2.541465428e-006
	,-1.509301957e-006
	,-6.735198301e-007
	,1.289727351e-017
	,5.412291017e-007
	,9.747075504e-007
	,1.319721845e-006
	,1.594753656e-006
	,1.816194678e-006
	,1.997661136e-006
	,2.149915910e-006
	,2.280490260e-006
	,2.394674199e-006
	,2.496300330e-006
	,2.588188775e-006
	,2.672285360e-006
	,2.750095329e-006
	,2.822940555e-006
	,2.891726938e-006
	,2.957053651e-006
	,3.019650135e-006
	,3.080073868e-006
	,3.138678724e-006
	,3.195760220e-006
	,3.251332735e-006
	,3.305537741e-006
	,3.358687179e-006
	,3.410791058e-006
	,3.461645929e-006
	,3.511256250e-006
	,3.559780479e-006
	,3.607220354e-006
	,3.653665886e-006
	,3.699248143e-006
	,3.743936168e-006
	,3.787712525e-006
	,3.830747836e-006
	,3.873117632e-006
	,3.914876531e-006
	,3.956108832e-006
	,3.996865151e-006
	,4.037184314e-006
	,4.077115362e-006
	,4.116682364e-006
	,4.155891817e-006
	,4.194747923e-006
	,4.233245291e-006
	,4.271358998e-006
	,4.309029247e-006
	,4.346154962e-006
	,4.382662906e-006
	,4.418606943e-006
	,4.454107958e-006
	,4.489253848e-006
	,4.524088687e-006
	,4.558629874e-006
	,4.592882435e-006
	,4.626850855e-006
	,4.660531021e-006
	,4.693909343e-006
	,4.726966907e-006
	,4.759684827e-006
	,4.792057762e-006
	,4.824087488e-006
	,4.855777040e-006
	,4.887136490e-006
	,4.918177303e-006
	,4.948907619e-006
	,4.979332328e-006
	,5.009453318e-006
	,5.039275873e-006
	,5.068817723e-006
	,5.098112696e-006
	,5.127205104e-006
	,5.156138993e-006
	,5.184950125e-006
	,5.213663348e-006
	,5.242293003e-006
	,5.270843929e-006
	,5.299315128e-006
	,5.327701806e-006
	,5.355998257e-006
	,5.384199533e-006
	,5.412301062e-006
	,5.440302054e-006
	,5.468212096e-006
	,5.496053669e-006
	,5.523859040e-006
	,5.551655292e-006
	,5.579477592e-006
	,5.607371591e-006
	,5.635384510e-006
	,5.663574232e-006
	,5.692011951e-006
	,5.720785534e-006
	,5.750005412e-006
	,5.779813015e-006
	,5.810391407e-006
	,5.841979499e-006
	,5.874891063e-006
	,5.909539358e-006
	,5.946469385e-006
	,5.986399871e-006
	,6.030277876e-006
	,6.079348513e-006
	,6.135123778e-006
	,6.199789163e-006
	,6.276113889e-006
	,6.367661661e-006
	,6.478995472e-006
	,6.615944686e-006
	,6.785890245e-006
	,6.998035364e-006
	,7.263721998e-006
	,7.596716520e-006
	,8.013444071e-006
	,8.533104845e-006
	,9.177644679e-006
	,9.971523943e-006
	,1.094126093e-005
	,1.211474675e-005
	,1.352038506e-005
	,1.518618588e-005
	,1.713876591e-005
	,1.940252618e-005
	,2.199902604e-005
	,2.494662469e-005
	,2.826032291e-005
	,3.195186967e-005
	,3.603004324e-005
	,4.050103280e-005
	,4.536869638e-005
	,5.063333552e-005
	,5.629691246e-005
	,6.235918127e-005
	,6.881916439e-005
	,7.567545005e-005
	,8.292638787e-005
	,9.057023903e-005
	,9.860528755e-005
	,1.070298832e-004
	,1.158425723e-004
	,1.250420695e-004
	,1.346272875e-004
	,1.445866638e-004
	,1.546203576e-004
	,1.648089756e-004
	,1.753407108e-004
	,1.862081617e-004
	,1.973715682e-004
	,2.088406164e-004
	,2.206128903e-004
	,2.326783658e-004
	,2.450260748e-004
	,2.576450271e-004
	,2.705261433e-004
	,2.836581387e-004
	,2.970417717e-004
	,3.106746520e-004
	,3.245479165e-004
	,3.386478750e-004
	,3.529823664e-004
	,3.675378071e-004
	,3.823032958e-004
	,-3.230269060e-004
	,-3.081736541e-004
	,-2.936372259e-004
	,-2.794435955e-004
	,-2.655924669e-004
	,-2.520609438e-004
	,-2.388066354e-004
	,-2.257979815e-004
	,-2.130531394e-004
	,-2.006363597e-004
	,-1.886060465e-004
	,-1.770002662e-004
	,-1.658355048e-004
	,-1.550915025e-004
	,-1.447251718e-004
	,-1.346864081e-004
	,-1.249222911e-004
	,-1.153821858e-004
	,-1.060538343e-004
	,-9.698147988e-005
	,-8.822872195e-005
	,-7.987182600e-005
	,-7.195349082e-005
	,-6.448539112e-005
	,-5.746469180e-005
	,-5.087957469e-005
	,-4.471018457e-005
	,-3.893246599e-005
	,-3.353904947e-005
	,-2.855389122e-005
	,-2.400354410e-005
	,-1.989699740e-005
	,-1.622785699e-005
	,-1.297994387e-005
	,-1.013239745e-005
	,-7.661976672e-006
	,-5.543285692e-006
	,-3.748530236e-006
	,-2.247659037e-006
	,-1.008968664e-006
	,1.759674677e-017
	,8.114663976e-007
	,1.456501881e-006
	,1.964407533e-006
	,2.362117993e-006
	,2.673153279e-006
	,2.916934105e-006
	,3.108517844e-006
	,3.258957845e-006
	,3.378404971e-006
	,3.476143342e-006
	,3.558459091e-006
	,3.629525057e-006
	,3.692369006e-006
	,3.749254903e-006
	,3.801717296e-006
	,3.850749073e-006
	,3.896945284e-006
	,3.940693880e-006
	,3.982582787e-006
	,4.023073859e-006
	,4.062407053e-006
	,4.100719785e-006
	,4.138093056e-006
	,4.174573822e-006
	,4.210199213e-006
	,4.245027908e-006
	,4.279162013e-006
	,4.312724165e-006
	,4.345808378e-006
	,4.378453451e-006
	,4.410647779e-006
	,4.442438979e-006
	,4.473945626e-006
	,4.505229817e-006
	,4.536311785e-006
	,4.567197287e-006
	,4.597893604e-006
	,4.628409013e-006
	,4.658719382e-006
	,4.688831251e-006
	,4.718793453e-006
	,4.748613863e-006
	,4.778285400e-006
	,4.807796289e-006
	,4.837134713e-006
	,4.866289793e-006
	,4.895262575e-006
	,4.924069440e-006
	,4.952740401e-006
	,4.981307254e-006
	,5.009794162e-006
	,5.038217147e-006
	,5.066585786e-006
	,5.094905382e-006
	,5.123180352e-006
	,5.151416470e-006
	,5.179620351e-006
	,5.207796465e-006
	,5.235947982e-006
	,5.264083403e-006
	,5.292211110e-006
	,5.320335700e-006
	,5.348459875e-006
	,5.376586100e-006
	,5.404717521e-006
	,5.432857782e-006
	,5.461010217e-006
	,5.489177521e-006
	,5.517361838e-006
	,5.545564814e-006
	,5.573787821e-006
	,5.602032092e-006
	,5.630298765e-006
	,5.658588943e-006
	,5.686903686e-006
	,5.715243949e-006
	,5.743610504e-006
	,5.772003859e-006
	,5.800424356e-006
	,5.828872624e-006
	,5.857349833e-006
	,5.885857914e-006
	,5.914398492e-006
	,5.942970810e-006
	,5.971571370e-006
	,6.000193925e-006
	,6.028830664e-006
	,6.057476183e-006
	,6.086133528e-006
	,6.114816961e-006
	,6.143546555e-006
	,6.172339844e-006
	,6.201222451e-006
	,6.230215873e-006
	,6.259343031e-006
	,6.288630429e-006
	,6.318110624e-006
	,6.347825114e-006
	,6.377827853e-006
	,6.408189487e-006
	,6.439002951e-006
	,6.470390955e-006
	,6.502515735e-006
	,6.535591703e-006
	,6.569902467e-006
	,6.605822995e-006
	,6.643848791e-006
	,6.684634219e-006
	,6.729041655e-006
	,6.778101372e-006
	,6.833343443e-006
	,6.896712162e-006
	,6.970719250e-006
	,7.058618767e-006
	,7.164601021e-006
	,7.294022369e-006
	,7.453669506e-006
	,7.652051694e-006
	,7.899706936e-006
	,8.209498742e-006
	,8.596869522e-006
	,9.080006974e-006
	,9.679874062e-006
	,1.042005535e-005
	,1.132638611e-005
	,1.242635692e-005
	,1.374832411e-005
	,1.532058842e-005
	,1.717044549e-005
	,1.932331035e-005
	,2.180201638e-005
	,2.462638496e-005
	,2.781273928e-005
	,3.137433757e-005
	,3.532164700e-005
	,3.966215302e-005
	,4.440128131e-005
	,4.954232885e-005
	,5.508731348e-005
	,6.103707781e-005
	,6.739181151e-005
	,7.415117101e-005
	,8.131473990e-005
	,8.888190331e-005
	,9.685219965e-005
	,1.052253204e-004
	,1.140012086e-004
	,1.231800081e-004
	,1.327621013e-004
	,1.424470174e-004
	,1.523111867e-004
	,1.624844625e-004
	,1.729933131e-004
	,1.838364975e-004
	,1.950039404e-004
	,2.064856679e-004
	,2.182730649e-004
	,2.303598198e-004
	,2.427415384e-004
	,2.554145499e-004
	,-3.487195756e-004
	,-3.339831835e-004
	,-3.195024318e-004
	,-3.052140050e-004
	,-2.910476987e-004
	,-2.769956219e-004
	,-2.631081221e-004
	,-2.494267785e-004
	,-2.360133376e-004
	,-2.229405866e-004
	,-2.102584922e-004
	,-1.979654406e-004
	,-1.860168510e-004
	,-1.743423653e-004
	,-1.628810279e-004
	,-1.516355364e-004
	,-1.406538565e-004
	,-1.299964202e-004
	,-1.197123445e-004
	,-1.098229337e-004
	,-1.003271833e-004
	,-9.121725914e-005
	,-8.250051503e-005
	,-7.419085892e-005
	,-6.629029839e-005
	,-5.880480657e-005
	,-5.175177753e-005
	,-4.514173343e-005
	,-3.897922682e-005
	,-3.326873163e-005
	,-2.802633732e-005
	,-2.326717583e-005
	,-1.899387827e-005
	,-1.519766919e-005
	,-1.186181694e-005
	,-8.964211901e-006
	,-6.478455389e-006
	,-4.374234546e-006
	,-2.617739205e-006
	,-1.172472750e-006
	,-8.093707019e-018
	,9.389757356e-007
	,1.682678355e-006
	,2.266359571e-006
	,2.720880211e-006
	,3.073108738e-006
	,3.346774892e-006
	,3.561007348e-006
	,3.730470023e-006
	,3.866283562e-006
	,3.976802480e-006
	,4.068238552e-006
	,4.145146546e-006
	,4.210855477e-006
	,4.267964954e-006
	,4.318513424e-006
	,4.364027567e-006
	,4.405693629e-006
	,4.444439101e-006
	,4.480974392e-006
	,4.515790780e-006
	,4.549241696e-006
	,4.581693366e-006
	,4.613422370e-006
	,4.644587481e-006
	,4.675290974e-006
	,4.705611735e-006
	,4.735607320e-006
	,4.765318484e-006
	,4.794771714e-006
	,4.823982510e-006
	,4.852967704e-006
	,4.881804583e-006
	,4.910557783e-006
	,4.939252127e-006
	,4.967893734e-006
	,4.996466445e-006
	,5.024940963e-006
	,5.053340053e-006
	,5.081693382e-006
	,5.110004945e-006
	,5.138268078e-006
	,5.166473352e-006
	,5.194609765e-006
	,5.222667228e-006
	,5.250642001e-006
	,5.278550088e-006
	,5.306390106e-006
	,5.334207241e-006
	,5.362048090e-006
	,5.389926259e-006
	,5.417846973e-006
	,5.445813100e-006
	,5.473826825e-006
	,5.501889702e-006
	,5.530002700e-006
	,5.558166416e-006
	,5.586381183e-006
	,5.614646981e-006
	,5.642963211e-006
	,5.671330940e-006
	,5.699752671e-006
	,5.728229464e-006
	,5.756760737e-006
	,5.785342890e-006
	,5.813970824e-006
	,5.842647521e-006
	,5.871378407e-006
	,5.900166266e-006
	,5.929011848e-006
	,5.957914135e-006
	,5.986872089e-006
	,6.015885388e-006
	,6.044954372e-006
	,6.074079727e-006
	,6.103261290e-006
	,6.132498381e-006
	,6.161791100e-006
	,6.191140515e-006
	,6.220548720e-006
	,6.250018609e-006
	,6.279552777e-006
	,6.309152755e-006
	,6.338819505e-006
	,6.368553839e-006
	,6.398355640e-006
	,6.428223999e-006
	,6.458158209e-006
	,6.488159045e-006
	,6.518228866e-006
	,6.548369062e-006
	,6.578580595e-006
	,6.608864877e-006
	,6.639223845e-006
	,6.669659989e-006
	,6.700176447e-006
	,6.730777114e-006
	,6.761467014e-006
	,6.792248818e-006
	,6.823128749e-006
	,6.854109218e-006
	,6.885188814e-006
	,6.916362775e-006
	,6.947626433e-006
	,6.978987502e-006
	,7.010476307e-006
	,7.042138268e-006
	,7.074024360e-006
	,7.106191618e-006
	,7.138708621e-006
	,7.171662124e-006
	,7.205164784e-006
	,7.239364694e-006
	,7.274457461e-006
	,7.310701891e-006
	,7.348440549e-006
	,7.388126676e-006
	,7.430358755e-006
	,7.475834885e-006
	,7.525628290e-006
	,7.581101314e-006
	,7.644014448e-006
	,7.716661151e-006
	,7.802016565e-006
	,7.903919274e-006
	,8.027287733e-006
	,8.178372685e-006
	,8.365040233e-006
	,8.597074237e-006
	,8.886479644e-006
	,9.247755346e-006
	,9.698097047e-006
	,1.025748193e-005
	,1.094858661e-005
	,1.179649937e-005
	,1.282820811e-005
	,1.407187981e-005
	,1.555598438e-005
	,1.730835035e-005
	,1.935525611e-005
	,2.172065648e-005
	,2.442562213e-005
	,2.748803027e-005
	,3.092249206e-005
	,3.474047883e-005
	,3.895072088e-005
	,4.355944072e-005
	,4.857096854e-005
	,5.398789618e-005
	,5.981186957e-005
	,6.604314776e-005
	,7.268163662e-005
	,7.972664675e-005
	,8.717726272e-005
	,9.503229626e-005
	,1.032906420e-004
	,1.119506821e-004
	,1.210106764e-004
	,1.302549981e-004
	,1.396011654e-004
	,1.493085636e-004
	,-3.696460373e-004
	,-3.549834605e-004
	,-3.404669230e-004
	,-3.260571021e-004
	,-3.117674209e-004
	,-2.976109305e-004
	,-2.835592679e-004
	,-2.696307760e-004
	,-2.558935978e-004
	,-2.423800575e-004
	,-2.290624188e-004
	,-2.159056056e-004
	,-2.029294275e-004
	,-1.901962447e-004
	,-1.777411102e-004
	,-1.655620255e-004
	,-1.536615905e-004
	,-1.420749318e-004
	,-1.308604973e-004
	,-1.200609593e-004
	,-1.096920336e-004
	,-9.974984672e-005
	,-9.022328627e-005
	,-8.112433038e-005
	,-7.248178894e-005
	,-6.430906940e-005
	,-5.661668360e-005
	,-4.941859537e-005
	,-4.272006957e-005
	,-3.652129406e-005
	,-3.082386867e-005
	,-2.563159002e-005
	,-2.094659651e-005
	,-1.676560817e-005
	,-1.307874820e-005
	,-9.869597528e-006
	,-7.115517853e-006
	,-4.788387113e-006
	,-2.854097875e-006
	,-1.272487269e-006
	,-1.462075320e-017
	,1.008081267e-006
	,1.797674170e-006
	,2.411938552e-006
	,2.888428448e-006
	,3.258463074e-006
	,3.547340868e-006
	,3.774928750e-006
	,3.956324563e-006
	,4.102710994e-006
	,4.223324308e-006
	,4.325131799e-006
	,4.412734073e-006
	,4.489335544e-006
	,4.557315702e-006
	,4.618177667e-006
	,4.672997373e-006
	,4.723176832e-006
	,4.769746344e-006
	,4.813378525e-006
	,4.854565017e-006
	,4.893684244e-006
	,4.931045274e-006
	,4.966911971e-006
	,5.001513733e-006
	,5.035048651e-006
	,5.067682891e-006
	,5.099551749e-006
	,5.130771443e-006
	,5.161462978e-006
	,5.191743345e-006
	,5.221698293e-006
	,5.251384125e-006
	,5.280835753e-006
	,5.310094455e-006
	,5.339240864e-006
	,5.368334686e-006
	,5.397412193e-006
	,5.426497702e-006
	,5.455606060e-006
	,5.484745989e-006
	,5.513914954e-006
	,5.543080155e-006
	,5.572191234e-006
	,5.601250549e-006
	,5.630308711e-006
	,5.659412737e-006
	,5.688579919e-006
	,5.717815851e-006
	,5.747122851e-006
	,5.776502486e-006
	,5.805956190e-006
	,5.835484726e-006
	,5.865084374e-006
	,5.894725331e-006
	,5.924366432e-006
	,5.954056163e-006
	,5.983816755e-006
	,6.013641989e-006
	,6.043525650e-006
	,6.073478477e-006
	,6.103505982e-006
	,6.133607947e-006
	,6.163782877e-006
	,6.194028908e-006
	,6.224343799e-006
	,6.254724752e-006
	,6.285167595e-006
	,6.315663726e-006
	,6.346196718e-006
	,6.376740233e-006
	,6.407270534e-006
	,6.437796739e-006
	,6.468346278e-006
	,6.498942307e-006
	,6.529599221e-006
	,6.560324588e-006
	,6.591121932e-006
	,6.621993023e-006
	,6.652938828e-006
	,6.683960271e-006
	,6.715057830e-006
	,6.746230755e-006
	,6.777478127e-006
	,6.808799814e-006
	,6.840196530e-006
	,6.871669430e-006
	,6.903218168e-006
	,6.934841287e-006
	,6.966537988e-006
	,6.998308248e-006
	,7.030152572e-006
	,7.062071845e-006
	,7.094066527e-006
	,7.126136365e-006
	,7.158283542e-006
	,7.190511760e-006
	,7.222824634e-006
	,7.255225283e-006
	,7.287716082e-006
	,7.320298395e-006
	,7.352973072e-006
	,7.385741556e-006
	,7.418606077e-006
	,7.451567575e-006
	,7.484626903e-006
	,7.517786610e-006
	,7.551050030e-006
	,7.584421809e-006
	,7.617908150e-006
	,7.651516869e-006
	,7.685257040e-006
	,7.719140048e-006
	,7.753181659e-006
	,7.787403351e-006
	,7.821833167e-006
	,7.856506571e-006
	,7.891468469e-006
	,7.926777102e-006
	,7.962508843e-006
	,7.998764002e-006
	,8.035675516e-006
	,8.073420577e-006
	,8.112235019e-006
	,8.152431648e-006
	,8.194423144e-006
	,8.238673235e-006
	,8.285931812e-006
	,8.337149183e-006
	,8.393552686e-006
	,8.456748840e-006
	,8.528833615e-006
	,8.612529822e-006
	,8.711356094e-006
	,8.829830678e-006
	,8.973710949e-006
	,9.150266452e-006
	,9.368575055e-006
	,9.639823590e-006
	,9.977598932e-006
	,1.039811907e-005
	,1.092037019e-005
	,1.156608833e-005
	,1.235955436e-005
	,1.332716530e-005
	,1.449679271e-005
	,1.589696022e-005
	,1.755592133e-005
	,1.950073367e-005
	,2.175643089e-005
	,2.434537939e-005
	,2.728686881e-005
	,3.059694657e-005
	,3.428847175e-005
	,3.837133400e-005
	,4.285279296e-005
	,4.773787284e-005
	,5.302976263e-005
	,5.873030639e-005
	,6.484021350e-005
	,7.135943175e-005
	,-3.862091979e-004
	,-3.718767269e-004
	,-3.576045603e-004
	,-3.433572534e-004
	,-3.290752905e-004
	,-3.146794249e-004
	,-3.001882913e-004
	,-2.857319684e-004
	,-2.713985414e-004
	,-2.572029168e-004
	,-2.431747509e-004
	,-2.293699027e-004
	,-2.158116241e-004
	,-2.024865106e-004
	,-1.893934524e-004
	,-1.765628234e-004
	,-1.640382808e-004
	,-1.518607053e-004
	,-1.400643117e-004
	,-1.286634255e-004
	,-1.176504138e-004
	,-1.070251495e-004
	,-9.682879622e-005
	,-8.709724103e-005
	,-7.784160660e-005
	,-6.907765346e-005
	,-6.082535408e-005
	,-5.309335263e-005
	,-4.588618162e-005
	,-3.921026382e-005
	,-3.307316883e-005
	,-2.748049193e-005
	,-2.243368755e-005
	,-1.792911641e-005
	,-1.395739654e-005
	,-1.050342700e-005
	,-7.546318761e-006
	,-5.056449450e-006
	,-2.998570468e-006
	,-1.330575916e-006
	,-1.618877205e-018
	,1.048069987e-006
	,1.865710523e-006
	,2.499646794e-006
	,2.990011481e-006
	,3.369938371e-006
	,3.665565862e-006
	,3.897767820e-006
	,4.083690640e-006
	,4.235325281e-006
	,4.360559212e-006
	,4.465463442e-006
	,4.556515182e-006
	,4.637735162e-006
	,4.711672356e-006
	,4.780097665e-006
	,4.844258331e-006
	,4.905026870e-006
	,4.963003389e-006
	,5.018592621e-006
	,5.072066654e-006
	,5.123612967e-006
	,5.173363760e-006
	,5.221413218e-006
	,5.267831709e-006
	,5.312678831e-006
	,5.356014193e-006
	,5.397905181e-006
	,5.438431512e-006
	,5.477686635e-006
	,5.515776252e-006
	,5.552814486e-006
	,5.588918464e-006
	,5.624202734e-006
	,5.658776680e-006
	,5.692745106e-006
	,5.726204600e-006
	,5.759237234e-006
	,5.791906373e-006
	,5.824252629e-006
	,5.856292703e-006
	,5.888038268e-006
	,5.919540902e-006
	,5.950884079e-006
	,5.982134434e-006
	,6.013329026e-006
	,6.044481095e-006
	,6.075599190e-006
	,6.106694706e-006
	,6.137783950e-006
	,6.168902737e-006
	,6.200073025e-006
	,6.231304523e-006
	,6.262602418e-006
	,6.293969603e-006
	,6.325406291e-006
	,6.356906186e-006
	,6.388452071e-006
	,6.420048460e-006
	,6.451725949e-006
	,6.483498207e-006
	,6.515357969e-006
	,6.547247456e-006
	,6.579149412e-006
	,6.611128702e-006
	,6.643201335e-006
	,6.675367223e-006
	,6.707624199e-006
	,6.739970154e-006
	,6.772403238e-006
	,6.804921180e-006
	,6.837518304e-006
	,6.870182273e-006
	,6.902913559e-006
	,6.935722090e-006
	,6.968608245e-006
	,7.001561254e-006
	,7.034566087e-006
	,7.067629325e-006
	,7.100763326e-006
	,7.133972256e-006
	,7.167256905e-006
	,7.200617648e-006
	,7.234054297e-006
	,7.267564727e-006
	,7.301146496e-006
	,7.334797491e-006
	,7.368515985e-006
	,7.402302560e-006
	,7.436157798e-006
	,7.470082195e-006
	,7.504077240e-006
	,7.538144861e-006
	,7.572285423e-006
	,7.606498843e-006
	,7.640785229e-006
	,7.675145243e-006
	,7.709580155e-006
	,7.744090147e-006
	,7.778672858e-006
	,7.813325956e-006
	,7.848051349e-006
	,7.882852777e-006
	,7.917733956e-006
	,7.952697850e-006
	,7.987744774e-006
	,8.022873909e-006
	,8.058085289e-006
	,8.093379757e-006
	,8.128758678e-006
	,8.164223996e-006
	,8.199778800e-006
	,8.235428329e-006
	,8.271175988e-006
	,8.307023948e-006
	,8.342975038e-006
	,8.379033027e-006
	,8.415202016e-006
	,8.451486142e-006
	,8.487890690e-006
	,8.524423375e-006
	,8.561094813e-006
	,8.597918867e-006
	,8.634913042e-006
	,8.672099113e-006
	,8.709505857e-006
	,8.747172434e-006
	,8.785151656e-006
	,8.823514182e-006
	,8.862354247e-006
	,8.901797257e-006
	,8.942009411e-006
	,8.983209170e-006
	,9.025681556e-006
	,9.069729614e-006
	,9.115879179e-006
	,9.164793379e-006
	,9.217324719e-006
	,9.274592586e-006
	,9.338062788e-006
	,9.409648495e-006
	,9.491837800e-006
	,9.587851091e-006
	,9.701831558e-006
	,9.839069855e-006
	,1.000626696e-005
	,1.021182099e-005
	,1.046613192e-005
	,1.078189767e-005
	,1.117437091e-005
	,1.166153356e-005
	,1.226414317e-005
	,1.300560930e-005
	,1.391162537e-005
	,1.500962014e-005
	,1.632800006e-005
	,1.789523689e-005
	,1.973895962e-005
	,2.188508578e-005
	,2.435708336e-005
	,2.717544838e-005
	,-4.002333404e-004
	,-3.855539816e-004
	,-3.709778431e-004
	,-3.564131922e-004
	,-3.417278092e-004
	,-3.268824612e-004
	,-3.119822278e-004
	,-2.971338749e-004
	,-2.824035975e-004
	,-2.678287080e-004
	,-2.534246855e-004
	,-2.392227013e-004
	,-2.252628444e-004
	,-2.115654952e-004
	,-1.981439914e-004
	,-1.850347645e-004
	,-1.722699310e-004
	,-1.598575388e-004
	,-1.477851522e-004
	,-1.360243129e-004
	,-1.245700672e-004
	,-1.134685090e-004
	,-1.027602526e-004
	,-9.247105433e-005
	,-8.263921541e-005
	,-7.331186744e-005
	,-6.451905567e-005
	,-5.627833600e-005
	,-4.860156358e-005
	,-4.149689798e-005
	,-3.496976413e-005
	,-2.902321171e-005
	,-2.365740483e-005
	,-1.886833191e-005
	,-1.464708946e-005
	,-1.097985382e-005
	,-7.851098263e-006
	,-5.238327813e-006
	,-3.097265831e-006
	,-1.371282321e-006
	,-8.302572499e-018
	,1.076164585e-006
	,1.912825831e-006
	,2.559430815e-006
	,3.057902656e-006
	,3.442303650e-006
	,3.741316714e-006
	,3.976886214e-006
	,4.163560066e-006
	,4.314525410e-006
	,4.440706590e-006
	,4.549101617e-006
	,4.644595270e-006
	,4.730687132e-006
	,4.809896888e-006
	,4.884034951e-006
	,4.954394228e-006
	,5.021890352e-006
	,5.087164792e-006
	,5.150659205e-006
	,5.212667452e-006
	,5.273379317e-006
	,5.332922934e-006
	,5.391377298e-006
	,5.448775719e-006
	,5.505112517e-006
	,5.560329477e-006
	,5.614216706e-006
	,5.666577719e-006
	,5.717680539e-006
	,5.767631869e-006
	,5.816418214e-006
	,5.864012984e-006
	,5.910398671e-006
	,5.955573552e-006
	,5.999554924e-006
	,6.042380758e-006
	,6.084109045e-006
	,6.124814558e-006
	,6.164584268e-006
	,6.203512460e-006
	,6.241695995e-006
	,6.279230122e-006
	,6.316205153e-006
	,6.352704136e-006
	,6.388801476e-006
	,6.424562316e-006
	,6.460042598e-006
	,6.495289969e-006
	,6.530345154e-006
	,6.565242125e-006
	,6.600006439e-006
	,6.634651486e-006
	,6.669171121e-006
	,6.703555561e-006
	,6.737855160e-006
	,6.772129222e-006
	,6.806405091e-006
	,6.840690811e-006
	,6.874974975e-006
	,6.909255191e-006
	,6.943566261e-006
	,6.977934081e-006
	,7.012369878e-006
	,7.046879264e-006
	,7.081466033e-006
	,7.116133186e-006
	,7.150882561e-006
	,7.185710951e-006
	,7.220586246e-006
	,7.255412026e-006
	,7.290218795e-006
	,7.325088017e-006
	,7.360044980e-006
	,7.395093813e-006
	,7.430233779e-006
	,7.465463210e-006
	,7.500780380e-006
	,7.536183644e-006
	,7.571671243e-006
	,7.607240540e-006
	,7.642885363e-006
	,7.678588806e-006
	,7.714327193e-006
	,7.750103948e-006
	,7.785928626e-006
	,7.821799758e-006
	,7.857730270e-006
	,7.893730305e-006
	,7.929802158e-006
	,7.965946505e-006
	,8.002162753e-006
	,8.038448672e-006
	,8.074802026e-006
	,8.111220909e-006
	,8.147704421e-006
	,8.184252576e-006
	,8.220865985e-006
	,8.257546378e-006
	,8.294293943e-006
	,8.331105562e-006
	,8.367978579e-006
	,8.404913338e-006
	,8.441909903e-006
	,8.478967225e-006
	,8.516082632e-006
	,8.553253192e-006
	,8.590482750e-006
	,8.627779690e-006
	,8.665147534e-006
	,8.702586386e-006
	,8.740096211e-006
	,8.777677263e-006
	,8.815330622e-006
	,8.853058065e-006
	,8.890860313e-006
	,8.928736076e-006
	,8.966683867e-006
	,9.004703738e-006
	,9.042796379e-006
	,9.080963472e-006
	,9.119207802e-006
	,9.157531928e-006
	,9.195935610e-006
	,9.234417473e-006
	,9.272977526e-006
	,9.311617389e-006
	,9.350340234e-006
	,9.389151013e-006
	,9.428056826e-006
	,9.467067333e-006
	,9.506194678e-006
	,9.545452114e-006
	,9.584856024e-006
	,9.624430306e-006
	,9.664207912e-006
	,9.704232750e-006
	,9.744564095e-006
	,9.785282380e-006
	,9.826496135e-006
	,9.868350763e-006
	,9.911037566e-006
	,9.954744689e-006
	,9.999839197e-006
	,1.004677991e-005
	,1.009615160e-005
	,1.014872544e-005
	,1.020551643e-005
	,1.026785591e-005
	,1.033748415e-005
	,1.041666739e-005
	,1.050834331e-005
	,1.061629814e-005
	,1.074537877e-005
	,1.090173935e-005
	,1.109312073e-005
	,1.132914846e-005
	,1.162163368e-005
	,1.198484515e-005
	,1.243571305e-005
	,1.299392177e-005
	,-4.125268758e-004
	,-3.972261708e-004
	,-3.819660358e-004
	,-3.666300529e-004
	,-3.511521399e-004
	,-3.356337863e-004
	,-3.202143693e-004
	,-3.049794124e-004
	,-2.899852409e-004
	,-2.752679913e-004
	,-2.608383843e-004
	,-2.466848451e-004
	,-2.327784026e-004
	,-2.190837778e-004
	,-2.055962629e-004
	,-1.923447741e-004
	,-1.793517159e-004
	,-1.666196233e-004
	,-1.541304501e-004
	,-1.418925061e-004
	,-1.299717642e-004
	,-1.184216950e-004
	,-1.072697829e-004
	,-9.655288024e-005
	,-8.632786304e-005
	,-7.663257756e-005
	,-6.748415027e-005
	,-5.889295817e-005
	,-5.086949567e-005
	,-4.342594429e-005
	,-3.657407773e-005
	,-3.032246598e-005
	,-2.467422069e-005
	,-1.962562635e-005
	,-1.517481290e-005
	,-1.133095408e-005
	,-8.079910692e-006
	,-5.379700334e-006
	,-3.174837099e-006
	,-1.403126385e-006
	,8.563314843e-018
	,1.097691117e-006
	,1.948477612e-006
	,2.603816728e-006
	,3.106991608e-006
	,3.494859986e-006
	,3.795171609e-006
	,4.029429281e-006
	,4.216531484e-006
	,4.369833678e-006
	,4.498734864e-006
	,4.609988290e-006
	,4.708481221e-006
	,4.797755685e-006
	,4.880372051e-006
	,4.958171303e-006
	,5.032469702e-006
	,5.104203889e-006
	,5.174037581e-006
	,5.242438614e-006
	,5.309733270e-006
	,5.376141729e-006
	,5.441784914e-006
	,5.506536068e-006
	,5.570056129e-006
	,5.632940578e-006
	,5.695427883e-006
	,5.757523966e-006
	,5.819195145e-006
	,5.880391808e-006
	,5.941052207e-006
	,6.001099691e-006
	,6.060437078e-006
	,6.118968257e-006
	,6.176630140e-006
	,6.233366699e-006
	,6.289116268e-006
	,6.343818084e-006
	,6.397417927e-006
	,6.449871991e-006
	,6.501149965e-006
	,6.551237536e-006
	,6.600138160e-006
	,6.647873854e-006
	,6.694484788e-006
	,6.740027607e-006
	,6.784572583e-006
	,6.828199919e-006
	,6.870995631e-006
	,6.913047580e-006
	,6.954442218e-006
	,6.995262245e-006
	,7.035584771e-006
	,7.075479828e-006
	,7.115009505e-006
	,7.154227477e-006
	,7.193178009e-006
	,7.231891723e-006
	,7.270370857e-006
	,7.308581308e-006
	,7.346560750e-006
	,7.384419443e-006
	,7.422216105e-006
	,7.459973354e-006
	,7.497700962e-006
	,7.535401947e-006
	,7.573074835e-006
	,7.610720472e-006
	,7.648351978e-006
	,7.685986861e-006
	,7.723631364e-006
	,7.761273569e-006
	,7.798925287e-006
	,7.836604114e-006
	,7.874330604e-006
	,7.912125843e-006
	,7.949989346e-006
	,7.987854165e-006
	,8.025639267e-006
	,8.063448290e-006
	,8.101328372e-006
	,8.139283192e-006
	,8.177308725e-006
	,8.215396722e-006
	,8.253535856e-006
	,8.291731706e-006
	,8.329998789e-006
	,8.368338518e-006
	,8.406737121e-006
	,8.445172209e-006
	,8.483644791e-006
	,8.522166103e-006
	,8.560740168e-006
	,8.599367047e-006
	,8.638045465e-006
	,8.676773673e-006
	,8.715549736e-006
	,8.754371491e-006
	,8.793235653e-006
	,8.832135252e-006
	,8.871067245e-006
	,8.910041261e-006
	,8.949061534e-006
	,8.988127685e-006
	,9.027238831e-006
	,9.066394740e-006
	,9.105594724e-006
	,9.144837232e-006
	,9.184120022e-006
	,9.223440450e-006
	,9.262795260e-006
	,9.302178785e-006
	,9.341582335e-006
	,9.381003545e-006
	,9.420449339e-006
	,9.459923451e-006
	,9.499424936e-006
	,9.538950807e-006
	,9.578497844e-006
	,9.618062742e-006
	,9.657641914e-006
	,9.697231285e-006
	,9.736826275e-006
	,9.776423012e-006
	,9.816021003e-006
	,9.855619369e-006
	,9.895212265e-006
	,9.934792854e-006
	,9.974354213e-006
	,1.001388949e-005
	,1.005339236e-005
	,1.009285698e-005
	,1.013227660e-005
	,1.017164233e-005
	,1.021094461e-005
	,1.025017347e-005
	,1.028931918e-005
	,1.032837357e-005
	,1.036733045e-005
	,1.040618627e-005
	,1.044493979e-005
	,1.048358998e-005
	,1.052213842e-005
	,1.056059384e-005
	,1.059897464e-005
	,1.063731122e-005
	,1.067564930e-005
	,1.071405443e-005
	,1.075261777e-005
	,1.079146174e-005
	,1.083069498e-005
	,1.087057613e-005
	,1.091142577e-005
	,1.095364724e-005
	,1.099777481e-005
	,1.104451515e-005
	,1.109479982e-005
	,1.114985191e-005
	,1.121127093e-005
	,1.128114027e-005
	,1.136216127e-005
	,-4.229307499e-004
	,-4.071740069e-004
	,-3.913124159e-004
	,-3.752487231e-004
	,-3.590794622e-004
	,-3.430190854e-004
	,-3.272118975e-004
	,-3.117225285e-004
	,-2.965706328e-004
	,-2.817517566e-004
	,-2.672463387e-004
	,-2.530217039e-004
	,-2.390326178e-004
	,-2.252421580e-004
	,-2.116524768e-004
	,-1.982689669e-004
	,-1.850691343e-004
	,-1.720102682e-004
	,-1.590939728e-004
	,-1.464166334e-004
	,-1.340765305e-004
	,-1.221279766e-004
	,-1.106080781e-004
	,-9.957263809e-005
	,-8.906562704e-005
	,-7.910550510e-005
	,-6.970136985e-005
	,-6.086124972e-005
	,-5.259436692e-005
	,-4.491120427e-005
	,-3.782214513e-005
	,-3.133401582e-005
	,-2.544735663e-005
	,-2.017978443e-005
	,-1.556608002e-005
	,-1.160454575e-005
	,-8.263178544e-006
	,-5.493721635e-006
	,-3.237338848e-006
	,-1.428674680e-006
	,8.145583887e-018
	,1.114725800e-006
	,1.976282151e-006
	,2.637646476e-006
	,3.144509139e-006
	,3.532872345e-006
	,3.832966556e-006
	,4.068677546e-006
	,4.257789522e-006
	,4.413180708e-006
	,4.544181438e-006
	,4.657574531e-006
	,4.758294658e-006
	,4.849923789e-006
	,4.935048040e-006
	,5.015523232e-006
	,5.092674823e-006
	,5.167446340e-006
	,5.240506830e-006
	,5.312324201e-006
	,5.383190137e-006
	,5.452971149e-006
	,5.521512220e-006
	,5.589694317e-006
	,5.657748198e-006
	,5.725722494e-006
	,5.793630901e-006
	,5.861470816e-006
	,5.929228833e-006
	,5.996883317e-006
	,6.064405828e-006
	,6.131761966e-006
	,6.198911872e-006
	,6.265810559e-006
	,6.332408154e-006
	,6.398650134e-006
	,6.464477619e-006
	,6.529827746e-006
	,6.594634139e-006
	,6.658827412e-006
	,6.722335509e-006
	,6.785083246e-006
	,6.846988981e-006
	,6.907952962e-006
	,6.967845594e-006
	,7.026573178e-006
	,7.084125453e-006
	,7.140500171e-006
	,7.195688395e-006
	,7.249687850e-006
	,7.302509708e-006
	,7.354180919e-006
	,7.404744295e-006
	,7.454257075e-006
	,7.502788296e-006
	,7.550415373e-006
	,7.597220379e-006
	,7.643286481e-006
	,7.688694828e-006
	,7.733521952e-006
	,7.777837379e-006
	,7.821700341e-006
	,7.865152057e-006
	,7.908194066e-006
	,7.950769041e-006
	,7.992899138e-006
	,8.034746872e-006
	,8.076421338e-006
	,8.117969937e-006
	,8.159417386e-006
	,8.200780201e-006
	,8.242071233e-006
	,8.283301293e-006
	,8.324479803e-006
	,8.365615091e-006
	,8.406714472e-006
	,8.447784135e-006
	,8.488828750e-006
	,8.529850771e-006
	,8.570850467e-006
	,8.611829425e-006
	,8.652795829e-006
	,8.693749700e-006
	,8.734672961e-006
	,8.775568225e-006
	,8.816316105e-006
	,8.856927411e-006
	,8.897546308e-006
	,8.938210977e-006
	,8.978926950e-006
	,9.019691961e-006
	,9.060501920e-006
	,9.101351922e-006
	,9.142234766e-006
	,9.183136555e-006
	,9.224041540e-006
	,9.264950501e-006
	,9.305864093e-006
	,9.346776897e-006
	,9.387692554e-006
	,9.428614268e-006
	,9.469540078e-006
	,9.510465968e-006
	,9.551387149e-006
	,9.592298414e-006
	,9.633194239e-006
	,9.674068811e-006
	,9.714916018e-006
	,9.755729435e-006
	,9.796502299e-006
	,9.837227474e-006
	,9.877897351e-006
	,9.918503416e-006
	,9.959035686e-006
	,9.999488238e-006
	,1.003985940e-005
	,1.008014189e-005
	,1.012032237e-005
	,1.016038181e-005
	,1.020030498e-005
	,1.024008665e-005
	,1.027972222e-005
	,1.031920229e-005
	,1.035851299e-005
	,1.039763935e-005
	,1.043656646e-005
	,1.047527937e-005
	,1.051376284e-005
	,1.055200146e-005
	,1.058998029e-005
	,1.062768685e-005
	,1.066511017e-005
	,1.070223665e-005
	,1.073905345e-005
	,1.077554974e-005
	,1.081171659e-005
	,1.084754700e-005
	,1.088303612e-005
	,1.091818164e-005
	,1.095298424e-005
	,1.098744847e-005
	,1.102158183e-005
	,1.105538994e-005
	,1.108887872e-005
	,1.112205758e-005
	,1.115493890e-005
	,1.118753812e-005
	,1.121987394e-005
	,1.125196867e-005
	,1.128384768e-005
	,1.131553878e-005
	,1.134707359e-005
	,1.137848895e-005
	,1.140982943e-005
	,1.144115043e-005
	,1.147252109e-005
	,1.150402801e-005
	,1.153577737e-005
	,1.156785122e-005
	,1.160045423e-005
	,1.163383112e-005
	,-4.320381252e-004
	,-4.156522684e-004
	,-3.990669404e-004
	,-3.823790249e-004
	,-3.658087644e-004
	,-3.495192118e-004
	,-3.335778122e-004
	,-3.180004797e-004
	,-3.027785816e-004
	,-2.878893691e-004
	,-2.732979924e-004
	,-2.589545571e-004
	,-2.447969802e-004
	,-2.307858239e-004
	,-2.169108869e-004
	,-2.031500640e-004
	,-1.894751163e-004
	,-1.759118807e-004
	,-1.625850940e-004
	,-1.496083188e-004
	,-1.370314413e-004
	,-1.248718953e-004
	,-1.131661373e-004
	,-1.019603596e-004
	,-9.127685803e-005
	,-8.112631452e-005
	,-7.151883981e-005
	,-6.246654025e-005
	,-5.398312832e-005
	,-4.608203758e-005
	,-3.877176677e-005
	,-3.205498072e-005
	,-2.596646255e-005
	,-2.055915288e-005
	,-1.584475193e-005
	,-1.180375071e-005
	,-8.398766460e-006
	,-5.579340913e-006
	,-3.284928569e-006
	,-1.448365095e-006
	,-1.404637314e-017
	,1.127997772e-006
	,1.997642079e-006
	,2.663519327e-006
	,3.171583409e-006
	,3.561217577e-006
	,3.862989157e-006
	,4.100545124e-006
	,4.291472355e-006
	,4.448604033e-006
	,4.581307369e-006
	,4.696418356e-006
	,4.798918742e-006
	,4.892421748e-006
	,4.979530428e-006
	,5.062109050e-006
	,5.141487216e-006
	,5.218608797e-006
	,5.294129853e-006
	,5.368383729e-006
	,5.440994686e-006
	,5.512779589e-006
	,5.584400249e-006
	,5.655999372e-006
	,5.727643458e-006
	,5.799369891e-006
	,5.871198547e-006
	,5.943137388e-006
	,6.015185843e-006
	,6.087336986e-006
	,6.159578933e-006
	,6.231895722e-006
	,6.304267824e-006
	,6.376672394e-006
	,6.449083348e-006
	,6.521471315e-006
	,6.593803520e-006
	,6.666043631e-006
	,6.738151601e-006
	,6.810083542e-006
	,6.881791653e-006
	,6.953224230e-006
	,7.024325786e-006
	,7.095037295e-006
	,7.165296586e-006
	,7.235038877e-006
	,7.304197458e-006
	,7.372704483e-006
	,7.440491851e-006
	,7.507492131e-006
	,7.573639444e-006
	,7.638870181e-006
	,7.703123140e-006
	,7.766337795e-006
	,7.828446117e-006
	,7.889346350e-006
	,7.948894597e-006
	,8.007067194e-006
	,8.063970701e-006
	,8.119690824e-006
	,8.174293616e-006
	,8.227845527e-006
	,8.280418568e-006
	,8.332089462e-006
	,8.382936651e-006
	,8.433036069e-006
	,8.482454622e-006
	,8.531236580e-006
	,8.579373069e-006
	,8.626799931e-006
	,8.673577481e-006
	,8.719899150e-006
	,8.765894311e-006
	,8.811627859e-006
	,8.857137769e-006
	,8.902450400e-006
	,8.947585982e-006
	,8.992560899e-006
	,9.037388837e-006
	,9.082081457e-006
	,9.126648845e-006
	,9.171099837e-006
	,9.215442262e-006
	,9.259683131e-006
	,9.303828790e-006
	,9.347885051e-006
	,9.391857292e-006
	,9.435750516e-006
	,9.479569256e-006
	,9.523316956e-006
	,9.566993089e-006
	,9.610578205e-006
	,9.653952099e-006
	,9.696907038e-006
	,9.739609183e-006
	,9.782175005e-006
	,9.824667333e-006
	,9.867096640e-006
	,9.909451101e-006
	,9.951711665e-006
	,9.993854579e-006
	,1.003586337e-005
	,1.007773649e-005
	,1.011946995e-005
	,1.016105272e-005
	,1.020247061e-005
	,1.024370808e-005
	,1.028474872e-005
	,1.032557545e-005
	,1.036617034e-005
	,1.040651389e-005
	,1.044658402e-005
	,1.048636265e-005
	,1.052583987e-005
	,1.056500324e-005
	,1.060383776e-005
	,1.064232845e-005
	,1.068046122e-005
	,1.071822346e-005
	,1.075560426e-005
	,1.079259463e-005
	,1.082918764e-005
	,1.086537813e-005
	,1.090116193e-005
	,1.093653478e-005
	,1.097149691e-005
	,1.100605955e-005
	,1.104023668e-005
	,1.107404128e-005
	,1.110748584e-005
	,1.114058039e-005
	,1.117334027e-005
	,1.120578274e-005
	,1.123792253e-005
	,1.126977315e-005
	,1.130134713e-005
	,1.133265926e-005
	,1.136373027e-005
	,1.139458109e-005
	,1.142522874e-005
	,1.145568831e-005
	,1.148597427e-005
	,1.151610085e-005
	,1.154608167e-005
	,1.157592921e-005
	,1.160565678e-005
	,1.163527898e-005
	,1.166480810e-005
	,1.169425189e-005
	,1.172361789e-005
	,1.175291475e-005
	,1.178215161e-005
	,1.181133783e-005
	,1.184048311e-005
	,1.186959768e-005
	,1.189869289e-005
	,1.192778207e-005
	,1.195688164e-005
	,1.198600860e-005
	,1.201517846e-005
	,1.204441059e-005
	,-4.397562744e-004
	,-4.227764788e-004
	,-4.057164815e-004
	,-3.887308783e-004
	,-3.720036173e-004
	,-3.556297947e-004
	,-3.396358259e-004
	,-3.240154070e-004
	,-3.087450362e-004
	,-2.937877302e-004
	,-2.790895071e-004
	,-2.645721482e-004
	,-2.501473324e-004
	,-2.357699594e-004
	,-2.214372430e-004
	,-2.071589289e-004
	,-1.929753023e-004
	,-1.790150966e-004
	,-1.654049682e-004
	,-1.522013144e-004
	,-1.394168345e-004
	,-1.270702421e-004
	,-1.152080727e-004
	,-1.038585826e-004
	,-9.303049300e-005
	,-8.272924717e-005
	,-7.296303747e-005
	,-6.374346901e-005
	,-5.508334512e-005
	,-4.699041203e-005
	,-3.946878919e-005
	,-3.256736331e-005
	,-2.635341726e-005
	,-2.085398260e-005
	,-1.606469934e-005
	,-1.196168083e-005
	,-8.506266019e-006
	,-5.647109122e-006
	,-3.322518234e-006
	,-1.463883765e-006
	,9.189911276e-018
	,1.138197050e-006
	,2.013548194e-006
	,2.681772193e-006
	,3.192116971e-006
	,3.583732103e-006
	,3.887352832e-006
	,4.126692141e-006
	,4.319267617e-006
	,4.477940033e-006
	,4.612128575e-006
	,4.728722903e-006
	,4.832746130e-006
	,4.927836540e-006
	,5.016610320e-006
	,5.100938060e-006
	,5.182150140e-006
	,5.261173520e-006
	,5.338457466e-006
	,5.413719114e-006
	,5.488187923e-006
	,5.562464664e-006
	,5.636724826e-006
	,5.711069112e-006
	,5.785561803e-006
	,5.860243770e-006
	,5.935139807e-006
	,6.010263398e-006
	,6.085619955e-006
	,6.161209049e-006
	,6.237025945e-006
	,6.313062746e-006
	,6.389309040e-006
	,6.465752322e-006
	,6.542378256e-006
	,6.619170779e-006
	,6.696112076e-006
	,6.773182487e-006
	,6.850360336e-006
	,6.927621726e-006
	,7.004940305e-006
	,7.082287019e-006
	,7.159629862e-006
	,7.236933650e-006
	,7.314159816e-006
	,7.391266247e-006
	,7.468207187e-006
	,7.544933206e-006
	,7.621391281e-006
	,7.697524966e-006
	,7.773274709e-006
	,7.848578284e-006
	,7.923371361e-006
	,7.997588180e-006
	,8.071162315e-006
	,8.144027495e-006
	,8.216118450e-006
	,8.287371777e-006
	,8.357726814e-006
	,8.427126568e-006
	,8.495518668e-006
	,8.562856357e-006
	,8.629099367e-006
	,8.694214400e-006
	,8.758174322e-006
	,8.820953398e-006
	,8.882509160e-006
	,8.942733768e-006
	,9.001502201e-006
	,9.058943394e-006
	,9.115264878e-006
	,9.170582894e-006
	,9.224945150e-006
	,9.278330859e-006
	,9.330730365e-006
	,9.382285380e-006
	,9.433171603e-006
	,9.483501795e-006
	,9.533346048e-006
	,9.582752995e-006
	,9.631758822e-006
	,9.680391159e-006
	,9.728671065e-006
	,9.776614251e-006
	,9.824231978e-006
	,9.871531777e-006
	,9.918518061e-006
	,9.965192611e-006
	,1.001155500e-005
	,1.005760291e-005
	,1.010333245e-005
	,1.014873842e-005
	,1.019381451e-005
	,1.023855362e-005
	,1.028294803e-005
	,1.032698960e-005
	,1.037066963e-005
	,1.041397726e-005
	,1.045689132e-005
	,1.049933307e-005
	,1.054101703e-005
	,1.058191148e-005
	,1.062231909e-005
	,1.066230139e-005
	,1.070184449e-005
	,1.074091852e-005
	,1.077946969e-005
	,1.081748205e-005
	,1.085500824e-005
	,1.089206979e-005
	,1.092867327e-005
	,1.096482359e-005
	,1.100052661e-005
	,1.103578960e-005
	,1.107062445e-005
	,1.110504853e-005
	,1.113907952e-005
	,1.117273464e-005
	,1.120603135e-005
	,1.123898748e-005
	,1.127162111e-005
	,1.130395031e-005
	,1.133599295e-005
	,1.136776641e-005
	,1.139928711e-005
	,1.143057047e-005
	,1.146163389e-005
	,1.149249582e-005
	,1.152317154e-005
	,1.155367302e-005
	,1.158400820e-005
	,1.161418427e-005
	,1.164421743e-005
	,1.167412663e-005
	,1.170392608e-005
	,1.173362685e-005
	,1.176323855e-005
	,1.179276991e-005
	,1.182222891e-005
	,1.185162242e-005
	,1.188095524e-005
	,1.191022723e-005
	,1.193942997e-005
	,1.196857225e-005
	,1.199767219e-005
	,1.202674231e-005
	,1.205579136e-005
	,1.208482572e-005
	,1.211385000e-005
	,1.214286806e-005
	,1.217188376e-005
	,1.220090141e-005
	,1.222992615e-005
	,1.225896328e-005
	,1.228801602e-005
	,1.231708618e-005
	,1.234617626e-005
	,1.237528925e-005
	,1.240442753e-005
	,1.243359407e-005
	,1.246279283e-005
	,-4.465536849e-004
	,-4.292076441e-004
	,-4.118848909e-004
	,-3.947584966e-004
	,-3.779668962e-004
	,-3.615621201e-004
	,-3.455469048e-004
	,-3.298993656e-004
	,-3.145800164e-004
	,-2.995285588e-004
	,-2.846542686e-004
	,-2.698358958e-004
	,-2.549837012e-004
	,-2.401124431e-004
	,-2.252765634e-004
	,-2.105208704e-004
	,-1.959593173e-004
	,-1.817320756e-004
	,-1.679093156e-004
	,-1.545076376e-004
	,-1.415304840e-004
	,-1.290156477e-004
	,-1.170030726e-004
	,-1.055060221e-004
	,-9.452819930e-005
	,-8.407446527e-005
	,-7.415303190e-005
	,-6.477324421e-005
	,-5.593832548e-005
	,-4.764888323e-005
	,-3.996067708e-005
	,-3.295016216e-005
	,-2.665645117e-005
	,-2.109075330e-005
	,-1.624405284e-005
	,-1.209178475e-005
	,-8.595430245e-006
	,-5.703552293e-006
	,-3.353877755e-006
	,-1.476800614e-006
	,1.561252472e-017
	,1.146081042e-006
	,2.025220405e-006
	,2.696447181e-006
	,3.209186797e-006
	,3.602638628e-006
	,3.907989853e-006
	,4.148900886e-006
	,4.342897883e-006
	,4.502886786e-006
	,4.638340010e-006
	,4.756195336e-006
	,4.861509107e-006
	,4.957938009e-006
	,5.048107084e-006
	,5.133889313e-006
	,5.216602532e-006
	,5.297002148e-006
	,5.374911796e-006
	,5.451702691e-006
	,5.528154956e-006
	,5.604517556e-006
	,5.680941737e-006
	,5.757528470e-006
	,5.834345652e-006
	,5.911438249e-006
	,5.988835038e-006
	,6.066553261e-006
	,6.144601873e-006
	,6.222983840e-006
	,6.301697763e-006
	,6.380739024e-006
	,6.460100592e-006
	,6.539773579e-006
	,6.619747606e-006
	,6.700011037e-006
	,6.780551130e-006
	,6.861354138e-006
	,6.942405407e-006
	,7.023689444e-006
	,7.105189901e-006
	,7.186889611e-006
	,7.268770310e-006
	,7.350812259e-006
	,7.432993922e-006
	,7.515291629e-006
	,7.597679265e-006
	,7.680127985e-006
	,7.762605961e-006
	,7.845078156e-006
	,7.927506135e-006
	,8.009847907e-006
	,8.092057826e-006
	,8.174086547e-006
	,8.255881066e-006
	,8.337384853e-006
	,8.418538093e-006
	,8.499278045e-006
	,8.579539515e-006
	,8.659255446e-006
	,8.738357582e-006
	,8.816777191e-006
	,8.894445794e-006
	,8.971295876e-006
	,9.047261541e-006
	,9.122279123e-006
	,9.196287769e-006
	,9.269230029e-006
	,9.341052497e-006
	,9.411706520e-006
	,9.481148938e-006
	,9.549342786e-006
	,9.616257762e-006
	,9.681870046e-006
	,9.746160464e-006
	,9.809108859e-006
	,9.870681817e-006
	,9.930819756e-006
	,9.989445539e-006
	,1.004643849e-005
	,1.010179015e-005
	,1.015580121e-005
	,1.020870053e-005
	,1.026060137e-005
	,1.031157070e-005
	,1.036165413e-005
	,1.041088428e-005
	,1.045928453e-005
	,1.050687145e-005
	,1.055365672e-005
	,1.059964889e-005
	,1.064485494e-005
	,1.068928164e-005
	,1.073293681e-005
	,1.077583024e-005
	,1.081797442e-005
	,1.085938493e-005
	,1.090008071e-005
	,1.094008406e-005
	,1.097942055e-005
	,1.101811871e-005
	,1.105620974e-005
	,1.109372703e-005
	,1.113070549e-005
	,1.116718014e-005
	,1.120318144e-005
	,1.123871363e-005
	,1.127364294e-005
	,1.130771655e-005
	,1.134124039e-005
	,1.137444204e-005
	,1.140736016e-005
	,1.143999836e-005
	,1.147237819e-005
	,1.150453501e-005
	,1.153648858e-005
	,1.156824771e-005
	,1.159981009e-005
	,1.163114446e-005
	,1.166226024e-005
	,1.169321498e-005
	,1.172403275e-005
	,1.175472656e-005
	,1.178530672e-005
	,1.181578189e-005
	,1.184615964e-005
	,1.187644661e-005
	,1.190664894e-005
	,1.193677398e-005
	,1.196682962e-005
	,1.199682241e-005
	,1.202675795e-005
	,1.205664129e-005
	,1.208647694e-005
	,1.211626866e-005
	,1.214601851e-005
	,1.217572506e-005
	,1.220538524e-005
	,1.223500673e-005
	,1.226460456e-005
	,1.229418891e-005
	,1.232376567e-005
	,1.235333881e-005
	,1.238291161e-005
	,1.241248691e-005
	,1.244206702e-005
	,1.247165309e-005
	,1.250124394e-005
	,1.253083561e-005
	,1.256042563e-005
	,1.259001805e-005
	,1.261961974e-005
	,1.264923598e-005
	,1.267886882e-005
	,1.270851631e-005
	,1.273818850e-005
	,1.276789383e-005
	,1.279763340e-005
	,1.282740820e-005
	,1.285721995e-005
	,1.288707080e-005
	,-4.528929237e-004
	,-4.353059107e-004
	,-4.178351401e-004
	,-4.006480961e-004
	,-3.838403101e-004
	,-3.674341596e-004
	,-3.514132818e-004
	,-3.357356659e-004
	,-3.203311054e-004
	,-3.050927929e-004
	,-2.898837661e-004
	,-2.745924427e-004
	,-2.592268792e-004
	,-2.438763442e-004
	,-2.285944759e-004
	,-2.134674105e-004
	,-1.986439026e-004
	,-1.842151813e-004
	,-1.702086726e-004
	,-1.566217117e-004
	,-1.434716411e-004
	,-1.308061498e-004
	,-1.186497349e-004
	,-1.070073339e-004
	,-9.588119134e-005
	,-8.527611960e-005
	,-7.519784034e-005
	,-6.564493344e-005
	,-5.661174777e-005
	,-4.815480600e-005
	,-4.035887362e-005
	,-3.327019578e-005
	,-2.691271576e-005
	,-2.129165422e-005
	,-1.639637175e-005
	,-1.220231064e-005
	,-8.671182646e-006
	,-5.751483322e-006
	,-3.380442039e-006
	,-1.487608377e-006
	,-9.033601673e-018
	,1.151856282e-006
	,2.034748929e-006
	,2.708916921e-006
	,3.223741211e-006
	,3.618940246e-006
	,3.925876757e-006
	,4.168188538e-006
	,4.363437410e-006
	,4.524578507e-006
	,4.661135711e-006
	,4.780089503e-006
	,4.886523387e-006
	,4.984108101e-006
	,5.075474258e-006
	,5.162489474e-006
	,5.246382529e-006
	,5.327242895e-006
	,5.406270401e-006
	,5.484672215e-006
	,5.562817652e-006
	,5.640928880e-006
	,5.719156669e-006
	,5.797604938e-006
	,5.876345107e-006
	,5.955425658e-006
	,6.034878721e-006
	,6.114724676e-006
	,6.194975398e-006
	,6.275636552e-006
	,6.356709244e-006
	,6.438191208e-006
	,6.520077678e-006
	,6.602362033e-006
	,6.685036280e-006
	,6.768091417e-006
	,6.851517702e-006
	,6.935304850e-006
	,7.019442156e-006
	,7.103918570e-006
	,7.188722710e-006
	,7.273842822e-006
	,7.359266695e-006
	,7.444981528e-006
	,7.530973757e-006
	,7.617228839e-006
	,7.703731005e-006
	,7.790462973e-006
	,7.877405630e-006
	,7.964537655e-006
	,8.051835074e-006
	,8.139270964e-006
	,8.226815032e-006
	,8.314433057e-006
	,8.402086697e-006
	,8.489733549e-006
	,8.577327462e-006
	,8.664818957e-006
	,8.752155403e-006
	,8.839280811e-006
	,8.926135354e-006
	,9.012654900e-006
	,9.098770733e-006
	,9.184409508e-006
	,9.269493430e-006
	,9.353940590e-006
	,9.437665426e-006
	,9.520579251e-006
	,9.602590812e-006
	,9.683606842e-006
	,9.763532578e-006
	,9.842272244e-006
	,9.919729537e-006
	,9.995808143e-006
	,1.007041233e-005
	,1.014344758e-005
	,1.021482106e-005
	,1.028444139e-005
	,1.035221691e-005
	,1.041805270e-005
	,1.048185643e-005
	,1.054357668e-005
	,1.060324767e-005
	,1.066095997e-005
	,1.071680693e-005
	,1.077087217e-005
	,1.082323554e-005
	,1.087397641e-005
	,1.092316860e-005
	,1.097085727e-005
	,1.101698970e-005
	,1.106142513e-005
	,1.110436583e-005
	,1.114616959e-005
	,1.118703454e-005
	,1.122707719e-005
	,1.126638372e-005
	,1.130502523e-005
	,1.134306295e-005
	,1.138055061e-005
	,1.141753584e-005
	,1.145406119e-005
	,1.149016489e-005
	,1.152588150e-005
	,1.156124252e-005
	,1.159627689e-005
	,1.163101148e-005
	,1.166547148e-005
	,1.169968082e-005
	,1.173366239e-005
	,1.176743818e-005
	,1.180102892e-005
	,1.183445175e-005
	,1.186770902e-005
	,1.190072761e-005
	,1.193317903e-005
	,1.196504061e-005
	,1.199669082e-005
	,1.202821749e-005
	,1.205965918e-005
	,1.209105127e-005
	,1.212240229e-005
	,1.215370997e-005
	,1.218497061e-005
	,1.221618146e-005
	,1.224734090e-005
	,1.227844817e-005
	,1.230950266e-005
	,1.234050189e-005
	,1.237143207e-005
	,1.240224667e-005
	,1.243295553e-005
	,1.246361582e-005
	,1.249424558e-005
	,1.252485047e-005
	,1.255543404e-005
	,1.258599949e-005
	,1.261654963e-005
	,1.264708681e-005
	,1.267761305e-005
	,1.270812975e-005
	,1.273863700e-005
	,1.276913121e-005
	,1.279960425e-005
	,1.283005877e-005
	,1.286051204e-005
	,1.289097659e-005
	,1.292145808e-005
	,1.295195936e-005
	,1.298248236e-005
	,1.301302861e-005
	,1.304359938e-005
	,1.307419542e-005
	,1.310481647e-005
	,1.313545987e-005
	,1.316612162e-005
	,1.319680257e-005
	,1.322750817e-005
	,1.325824372e-005
	,1.328901311e-005
	,1.331981928e-005
	,-8.907097423e-007
	,-7.056068261e-007
	,-5.560050050e-007
	,-4.356189270e-007
	,-3.395303771e-007
	,-2.638955538e-007
	,-2.050517010e-007
	,-1.594968457e-007
	,-1.241990463e-007
	,-9.670473722e-008
	,-7.515709113e-008
	,-5.825503148e-008
	,-4.503256334e-008
	,-3.469515990e-008
	,-2.662270995e-008
	,-2.033941505e-008
	,-1.548148414e-008
	,-1.176106196e-008
	,-8.932295804e-009
	,-6.788178622e-009
	,-5.163099821e-009
	,-3.929172098e-009
	,-2.989502091e-009
	,-2.272014123e-009
	,-1.724124164e-009
	,-1.306775179e-009
	,-9.894170336e-010
	,-7.482536317e-010
	,-5.651178480e-010
	,-4.259882075e-010
	,-3.200570777e-010
	,-2.391933992e-010
	,-1.774409377e-010
	,-1.303411347e-010
	,-9.441767329e-011
	,-6.698471529e-011
	,-4.600812522e-011
	,-2.992517190e-011
	,-1.750283891e-011
	,-7.774755028e-012
	,2.976163325e-018
	,6.378192980e-012
	,1.177409548e-011
	,1.650062282e-011
	,2.080149855e-011
	,2.486788754e-011
	,2.885224158e-011
	,3.288134176e-011
	,3.706379296e-011
	,4.149518732e-011
	,4.626245941e-011
	,5.144600201e-011
	,5.711896812e-011
	,6.334264649e-011
	,7.016139170e-011
	,7.761263190e-011
	,8.576406068e-011
	,9.472172096e-011
	,1.046223150e-010
	,1.156325898e-010
	,1.279312274e-010
	,1.417084322e-010
	,1.571624897e-010
	,1.744675312e-010
	,1.939435290e-010
	,2.161726649e-010
	,2.418510974e-010
	,2.720724824e-010
	,3.084450600e-010
	,3.529325579e-010
	,4.080030412e-010
	,4.769764010e-010
	,5.644014841e-010
	,6.758973439e-010
	,8.190155035e-010
	,1.003576962e-009
	,1.242134191e-009
	,1.550978866e-009
	,1.951177576e-009
	,2.469831174e-009
	,3.141851196e-009
	,4.012175634e-009
	,5.131531388e-009
	,6.572753622e-009
	,8.429376855e-009
	,1.081095992e-008
	,1.384719427e-008
	,1.773743079e-008
	,2.271914211e-008
	,2.909517747e-008
	,3.725212548e-008
	,4.768305746e-008
	,6.101448402e-008
	,7.764493520e-008
	,9.760317272e-008
	,1.224698540e-007
	,1.524789687e-007
	,1.886036497e-007
	,2.332711813e-007
	,2.884787740e-007
	,3.566684769e-007
	,4.408313803e-007
	,5.446311463e-007
	,6.725540294e-007
	,8.300917749e-007
	,1.023965344e-006
	,1.262396318e-006
	,1.555033890e-006
	,1.905808934e-006
	,2.326187315e-006
	,2.835541694e-006
	,3.451546844e-006
	,4.195006519e-006
	,5.090647171e-006
	,6.164791489e-006
	,7.326765354e-006
	,8.645017496e-006
	,1.004739141e-005
	,1.162020978e-005
	,1.342860523e-005
	,1.549911985e-005
	,1.786001436e-005
	,2.054161517e-005
	,2.357653749e-005
	,2.699991537e-005
	,3.084960860e-005
	,3.516624776e-005
	,3.999256693e-005
	,4.525153226e-005
	,5.093373152e-005
	,5.709429199e-005
	,6.382719963e-005
	,7.115674722e-005
	,7.909780536e-005
	,8.739433716e-005
	,9.578306228e-005
	,1.044327754e-004
	,1.125119954e-004
	,1.208416031e-004
	,1.297585425e-004
	,1.392354136e-004
	,1.492327095e-004
	,1.597071869e-004
	,1.706127241e-004
	,1.819017381e-004
	,1.935264991e-004
	,2.053831051e-004
	,2.174765967e-004
	,2.297680548e-004
	,2.422212969e-004
	,2.543181615e-004
	,2.663184252e-004
	,2.783117958e-004
	,2.902795898e-004
	,3.022819997e-004
	,3.143676747e-004
	,3.265151617e-004
	,3.387120965e-004
	,3.511155986e-004
	,3.635465878e-004
	,3.751460374e-004
	,3.870515207e-004
	,3.992608949e-004
	,4.116802309e-004
	,4.244276487e-004
	,4.375680298e-004
	,4.511300178e-004
	,4.651442456e-004
	,4.796423136e-004
	,4.946556323e-004
	,5.087101934e-004
	,5.231235289e-004
	,5.380930735e-004
	,5.533322843e-004
	,5.691752105e-004
	,5.839417336e-004
	,5.990364827e-004
	,6.146339218e-004
	,6.307269801e-004
	,6.473259108e-004
	,6.644513037e-004
	,6.821372139e-004
	,7.004406203e-004
	,7.180519749e-004
	,7.342628285e-004
	,7.513594194e-004
	,7.693161705e-004
	,7.880260416e-004
	,8.076833065e-004
	,8.259313271e-004
	,8.431705486e-004
	,8.607423167e-004
	,8.790072998e-004
	,8.979820725e-004
	,9.175442537e-004
	,9.376877501e-004
	,9.560895142e-004
	,9.716566691e-004
	,9.879979224e-004
	,1.004922037e-003
	,1.022321509e-003
	,-2.610021242e-006
	,-2.083748771e-006
	,-1.652737427e-006
	,-1.303572990e-006
	,-1.024667010e-006
	,-8.044327059e-007
	,-6.313617699e-007
	,-4.950942946e-007
	,-3.872455298e-007
	,-3.018050992e-007
	,-2.342510807e-007
	,-1.808974982e-007
	,-1.390176165e-007
	,-1.065489198e-007
	,-8.163922336e-008
	,-6.260986359e-008
	,-4.807579692e-008
	,-3.695838235e-008
	,-2.843278736e-008
	,-2.186829170e-008
	,-1.679445284e-008
	,-1.287364726e-008
	,-9.851988880e-009
	,-7.525190659e-009
	,-5.729314430e-009
	,-4.340261500e-009
	,-3.269180962e-009
	,-2.450281409e-009
	,-1.829912608e-009
	,-1.363089645e-009
	,-1.013112940e-009
	,-7.509581328e-010
	,-5.543403496e-010
	,-4.064706751e-010
	,-2.948046042e-010
	,-2.099955962e-010
	,-1.450974312e-010
	,-9.499053077e-011
	,-5.590256612e-011
	,-2.497393288e-011
	,-1.201146235e-018
	,2.070274502e-011
	,3.840925983e-011
	,5.409315315e-011
	,6.850183705e-011
	,8.219879193e-011
	,9.558998900e-011
	,1.089673075e-010
	,1.225894447e-010
	,1.367167937e-010
	,1.515632984e-010
	,1.672455443e-010
	,1.837613232e-010
	,2.010462441e-010
	,2.191385525e-010
	,2.382826930e-010
	,2.588293307e-010
	,2.811185370e-010
	,3.054429697e-010
	,3.320507331e-010
	,3.611549764e-010
	,3.929694588e-010
	,4.277818113e-010
	,4.659779693e-010
	,5.080036807e-010
	,5.543479596e-010
	,6.055718923e-010
	,6.623313130e-010
	,7.254171197e-010
	,7.957604997e-010
	,8.746361201e-010
	,9.636991756e-010
	,1.065050435e-009
	,1.181395812e-009
	,1.316244346e-009
	,1.473313840e-009
	,1.659262677e-009
	,1.882252733e-009
	,2.153079563e-009
	,2.481855561e-009
	,2.890496878e-009
	,3.404907737e-009
	,4.056339689e-009
	,4.890125041e-009
	,5.963981978e-009
	,7.350122413e-009
	,9.142734608e-009
	,1.143370920e-008
	,1.437696567e-008
	,1.812905046e-008
	,2.287922691e-008
	,2.894696782e-008
	,3.642762200e-008
	,4.581282328e-008
	,5.767569459e-008
	,7.266316279e-008
	,9.157886306e-008
	,1.154238581e-007
	,1.454458503e-007
	,1.831996672e-007
	,2.306232280e-007
	,2.901301211e-007
	,3.647251119e-007
	,4.581472207e-007
	,5.750445166e-007
	,7.211796512e-007
	,8.991634500e-007
	,1.117397037e-006
	,1.386616146e-006
	,1.718208646e-006
	,2.125923424e-006
	,2.626047653e-006
	,3.238143547e-006
	,3.953771017e-006
	,4.753897826e-006
	,5.674412430e-006
	,6.680226203e-006
	,7.855865453e-006
	,9.225120661e-006
	,1.081331156e-005
	,1.264772640e-005
	,1.475779940e-005
	,1.717523521e-005
	,1.993414444e-005
	,2.307116464e-005
	,2.662543079e-005
	,3.063784556e-005
	,3.504601158e-005
	,3.981532184e-005
	,4.508725453e-005
	,5.089396356e-005
	,5.726176166e-005
	,6.420801415e-005
	,7.148787465e-005
	,7.893461321e-005
	,8.642434390e-005
	,9.350211237e-005
	,1.011200234e-004
	,1.092883775e-004
	,1.179907664e-004
	,1.272011799e-004
	,1.368886641e-004
	,1.470180074e-004
	,1.575508748e-004
	,1.684469995e-004
	,1.796530054e-004
	,1.911104567e-004
	,2.028116857e-004
	,2.147207971e-004
	,2.264421747e-004
	,2.380433961e-004
	,2.496796609e-004
	,2.613257250e-004
	,2.729861481e-004
	,2.846917496e-004
	,2.964885945e-004
	,3.083077668e-004
	,3.202693743e-004
	,3.320804451e-004
	,3.433153413e-004
	,3.547777161e-004
	,3.664822549e-004
	,3.784449967e-004
	,3.906903003e-004
	,4.032505784e-004
	,4.161649401e-004
	,4.294682207e-004
	,4.431365963e-004
	,4.557979799e-004
	,4.690199301e-004
	,4.827851017e-004
	,4.970334463e-004
	,5.117752657e-004
	,5.270757458e-004
	,5.428356566e-004
	,5.576198650e-004
	,5.727516300e-004
	,5.881080832e-004
	,6.039235837e-004
	,6.202124279e-004
	,6.370003674e-004
	,6.543328930e-004
	,6.721388525e-004
	,6.878002287e-004
	,7.042713606e-004
	,7.213105043e-004
	,7.381833601e-004
	,7.559497714e-004
	,7.745618604e-004
	,7.928868160e-004
	,8.096320522e-004
	,8.271934210e-004
	,8.454752166e-004
	,8.644209467e-004
	,8.838975714e-004
	,9.038124218e-004
	,9.200291541e-004
	,9.362641382e-004
	,9.530304524e-004
	,9.699328759e-004
	,9.872723952e-004
	,-7.221246762e-006
	,-5.889071565e-006
	,-4.779251573e-006
	,-3.847721828e-006
	,-3.078055008e-006
	,-2.451527618e-006
	,-1.942198369e-006
	,-1.529930398e-006
	,-1.200529977e-006
	,-9.404031817e-007
	,-7.351559066e-007
	,-5.723363828e-007
	,-4.439264460e-007
	,-3.438900633e-007
	,-2.663816802e-007
	,-2.062813527e-007
	,-1.594851556e-007
	,-1.229535921e-007
	,-9.454142110e-008
	,-7.252083085e-008
	,-5.544051402e-008
	,-4.219424162e-008
	,-3.197208783e-008
	,-2.415508414e-008
	,-1.823189938e-008
	,-1.376510662e-008
	,-1.039966997e-008
	,-7.861325126e-009
	,-5.943588961e-009
	,-4.491341516e-009
	,-3.387883181e-009
	,-2.545848818e-009
	,-1.900951651e-009
	,-1.406643381e-009
	,-1.027838888e-009
	,-7.368847913e-010
	,-5.121008416e-010
	,-3.368813025e-010
	,-1.987898356e-010
	,-8.872211671e-011
	,1.791004499e-017
	,7.254835979e-011
	,1.331149173e-010
	,1.850400218e-010
	,2.309690036e-010
	,2.730728830e-010
	,3.131419383e-010
	,3.526122694e-010
	,3.926286890e-010
	,4.341231629e-010
	,4.778746755e-010
	,5.245371137e-010
	,5.746350429e-010
	,6.285790945e-010
	,6.868039273e-010
	,7.499128102e-010
	,8.186266409e-010
	,8.936782626e-010
	,9.757795320e-010
	,1.065657528e-009
	,1.164142770e-009
	,1.272199923e-009
	,1.390881211e-009
	,1.521278979e-009
	,1.664466743e-009
	,1.821387028e-009
	,1.992694213e-009
	,2.178749510e-009
	,2.380069765e-009
	,2.597923272e-009
	,2.834156531e-009
	,3.090737048e-009
	,3.369678768e-009
	,3.672938516e-009
	,4.002233965e-009
	,4.358779074e-009
	,4.742909635e-009
	,5.154568334e-009
	,5.594899382e-009
	,6.069333177e-009
	,6.585464167e-009
	,7.155832464e-009
	,7.794893785e-009
	,8.522743713e-009
	,9.363701543e-009
	,1.034873213e-008
	,1.151705390e-008
	,1.291050430e-008
	,1.460918729e-008
	,1.670926468e-008
	,1.932965325e-008
	,2.261898673e-008
	,2.679852870e-008
	,3.213744775e-008
	,3.895743006e-008
	,4.771424481e-008
	,5.896782349e-008
	,7.341900109e-008
	,9.196933741e-008
	,1.157705092e-007
	,1.462742040e-007
	,1.850682370e-007
	,2.344017515e-007
	,2.967592998e-007
	,3.752057872e-007
	,4.743051908e-007
	,5.993164921e-007
	,7.567570431e-007
	,9.546574116e-007
	,1.202850986e-006
	,1.512544927e-006
	,1.870543273e-006
	,2.299712024e-006
	,2.797978804e-006
	,3.373587013e-006
	,4.060659046e-006
	,4.878289339e-006
	,5.847425511e-006
	,6.991201913e-006
	,8.335088157e-006
	,9.906970954e-006
	,1.173721607e-005
	,1.385871850e-005
	,1.630688871e-005
	,1.911930875e-005
	,2.231794570e-005
	,2.581944006e-005
	,2.973591326e-005
	,3.411342132e-005
	,3.898329337e-005
	,4.437201039e-005
	,5.029537991e-005
	,5.643375450e-005
	,6.261556618e-005
	,6.880829260e-005
	,7.516249714e-005
	,8.201668228e-005
	,8.937586410e-005
	,9.723524620e-005
	,1.055802053e-004
	,1.143608280e-004
	,1.235752085e-004
	,1.331991795e-004
	,1.432007781e-004
	,1.535460162e-004
	,1.642006861e-004
	,1.751319106e-004
	,1.863107555e-004
	,1.975385965e-004
	,2.086874149e-004
	,2.199394011e-004
	,2.312529811e-004
	,2.425126751e-004
	,2.538075969e-004
	,2.651648295e-004
	,2.766023533e-004
	,2.881013464e-004
	,2.992210129e-004
	,3.100901829e-004
	,3.211564397e-004
	,3.324265357e-004
	,3.439196870e-004
	,3.556624153e-004
	,3.676821254e-004
	,3.800083751e-004
	,3.922034812e-004
	,4.039838794e-004
	,4.162125696e-004
	,4.288763972e-004
	,4.419834239e-004
	,4.555405473e-004
	,4.694840190e-004
	,4.839021483e-004
	,4.988580808e-004
	,5.138925166e-004
	,5.284477212e-004
	,5.434533230e-004
	,5.588873804e-004
	,5.747609083e-004
	,5.910398282e-004
	,6.074452784e-004
	,6.238316253e-004
	,6.385492177e-004
	,6.535379322e-004
	,6.692274782e-004
	,6.855955867e-004
	,7.026631081e-004
	,7.204736869e-004
	,7.389747598e-004
	,7.582037586e-004
	,7.748280573e-004
	,7.922244910e-004
	,8.102650489e-004
	,8.289278870e-004
	,8.482267809e-004
	,8.669825734e-004
	,8.826917729e-004
	,8.990107214e-004
	,9.158601720e-004
	,9.329989674e-004
	,9.472595781e-004
	,-1.856036083e-005
	,-1.560794582e-005
	,-1.300285305e-005
	,-1.070953167e-005
	,-8.723129146e-006
	,-7.047033543e-006
	,-5.671895678e-006
	,-4.560685400e-006
	,-3.666312812e-006
	,-2.942861176e-006
	,-2.350857120e-006
	,-1.864324255e-006
	,-1.467418571e-006
	,-1.147033310e-006
	,-8.904403563e-007
	,-6.873515450e-007
	,-5.290906985e-007
	,-4.071241944e-007
	,-3.135064598e-007
	,-2.415013752e-007
	,-1.858057746e-007
	,-1.425847037e-007
	,-1.091241256e-007
	,-8.337577809e-008
	,-6.367730735e-008
	,-4.862900586e-008
	,-3.710534492e-008
	,-2.824926679e-008
	,-2.144688908e-008
	,-1.623823325e-008
	,-1.225167146e-008
	,-9.191093902e-009
	,-6.832554575e-009
	,-5.015535958e-009
	,-3.622906315e-009
	,-2.561262430e-009
	,-1.753961664e-009
	,-1.138372612e-009
	,-6.648144921e-010
	,-2.950083247e-010
	,2.245286914e-017
	,2.419339728e-010
	,4.470703271e-010
	,6.276054668e-010
	,7.926173616e-010
	,9.487024033e-010
	,1.100585120e-009
	,1.252098266e-009
	,1.406971242e-009
	,1.568756740e-009
	,1.740541147e-009
	,1.924839801e-009
	,2.123584446e-009
	,2.338157728e-009
	,2.569580630e-009
	,2.818548206e-009
	,3.085346624e-009
	,3.370527926e-009
	,3.675780610e-009
	,4.003284765e-009
	,4.354279106e-009
	,4.727976225e-009
	,5.121190835e-009
	,5.529736618e-009
	,5.952246564e-009
	,6.392705632e-009
	,6.858359465e-009
	,7.356592014e-009
	,7.893778933e-009
	,8.475418963e-009
	,9.106479622e-009
	,9.791546550e-009
	,1.053477084e-008
	,1.133989962e-008
	,1.221094488e-008
	,1.315338169e-008
	,1.417440531e-008
	,1.528221073e-008
	,1.648557894e-008
	,1.779406169e-008
	,1.921845499e-008
	,2.077090311e-008
	,2.246482829e-008
	,2.431502430e-008
	,2.633799162e-008
	,2.855276153e-008
	,3.098241162e-008
	,3.365573900e-008
	,3.661112132e-008
	,3.989606899e-008
	,4.356969101e-008
	,4.770509195e-008
	,5.239448107e-008
	,5.775372980e-008
	,6.391513882e-008
	,7.111542853e-008
	,7.967547528e-008
	,9.001971784e-008
	,1.026563056e-007
	,1.182254125e-007
	,1.377317111e-007
	,1.623876264e-007
	,1.936260686e-007
	,2.333537051e-007
	,2.837961740e-007
	,3.472933703e-007
	,4.261573309e-007
	,5.244983200e-007
	,6.475253083e-007
	,7.953931281e-007
	,9.777074957e-007
	,1.203110325e-006
	,1.481342207e-006
	,1.823640311e-006
	,2.243089338e-006
	,2.754862528e-006
	,3.376428677e-006
	,4.127729688e-006
	,5.031327241e-006
	,6.112513241e-006
	,7.399367326e-006
	,8.922690701e-006
	,1.071552874e-005
	,1.279416094e-005
	,1.513632165e-005
	,1.782194002e-005
	,2.088515159e-005
	,2.435877978e-005
	,2.827246376e-005
	,3.264716147e-005
	,3.730058031e-005
	,4.207561737e-005
	,4.699863536e-005
	,5.209740613e-005
	,5.763429193e-005
	,6.361529127e-005
	,7.004369117e-005
	,7.693177761e-005
	,8.427361324e-005
	,9.205846814e-005
	,1.002708826e-004
	,1.088909640e-004
	,1.178950471e-004
	,1.272567192e-004
	,1.369479726e-004
	,1.469407401e-004
	,1.572089808e-004
	,1.676108723e-004
	,1.780242330e-004
	,1.885948940e-004
	,1.992974827e-004
	,2.101042724e-004
	,2.209917337e-004
	,2.319548705e-004
	,2.430121431e-004
	,2.540201333e-004
	,2.643900485e-004
	,2.748632405e-004
	,2.855000131e-004
	,2.963171032e-004
	,3.073406231e-004
	,3.186036338e-004
	,3.301413726e-004
	,3.408825871e-004
	,3.519643013e-004
	,3.633971151e-004
	,3.751740664e-004
	,3.872953048e-004
	,3.997678086e-004
	,4.126206665e-004
	,4.258784557e-004
	,4.395230408e-004
	,4.535956573e-004
	,4.681702195e-004
	,4.824935854e-004
	,4.961347319e-004
	,5.102466366e-004
	,5.248057560e-004
	,5.398131571e-004
	,5.552921520e-004
	,5.712998379e-004
	,5.861241629e-004
	,6.010897927e-004
	,6.163492372e-004
	,6.319590750e-004
	,6.479872793e-004
	,6.646221620e-004
	,6.819076486e-004
	,6.999021847e-004
	,7.187089048e-004
	,7.366043436e-004
	,7.536571695e-004
	,7.712681390e-004
	,7.894487226e-004
	,8.082250961e-004
	,8.250372877e-004
	,8.411382436e-004
	,8.568399654e-004
	,8.694093967e-004
	,8.828523900e-004
	,8.969844239e-004
	,-4.212403430e-005
	,-3.640818023e-005
	,-3.126337304e-005
	,-2.669644346e-005
	,-2.264044290e-005
	,-1.901433180e-005
	,-1.583594063e-005
	,-1.312067962e-005
	,-1.081816801e-005
	,-8.854918436e-006
	,-7.185903230e-006
	,-5.789278308e-006
	,-4.634447775e-006
	,-3.684340701e-006
	,-2.911469007e-006
	,-2.294221098e-006
	,-1.806391263e-006
	,-1.420069245e-006
	,-1.112658477e-006
	,-8.684280705e-007
	,-6.760438426e-007
	,-5.250254633e-007
	,-4.057206152e-007
	,-3.111817643e-007
	,-2.369728857e-007
	,-1.794399956e-007
	,-1.353905989e-007
	,-1.020203143e-007
	,-7.684723570e-008
	,-5.784340109e-008
	,-4.344892958e-008
	,-3.251107900e-008
	,-2.419834976e-008
	,-1.788075857e-008
	,-1.306124850e-008
	,-9.366121076e-009
	,-6.517731174e-009
	,-4.299926656e-009
	,-2.548167766e-009
	,-1.143667279e-009
	,-6.997163253e-018
	,9.519929694e-010
	,1.768573582e-009
	,2.493420530e-009
	,3.158202366e-009
	,3.783179466e-009
	,4.379026678e-009
	,4.952448172e-009
	,5.511859094e-009
	,6.067681086e-009
	,6.630719439e-009
	,7.212096928e-009
	,7.823192270e-009
	,8.474805824e-009
	,9.176617977e-009
	,9.937296480e-009
	,1.076490431e-008
	,1.166698816e-008
	,1.265045115e-008
	,1.372131730e-008
	,1.488450024e-008
	,1.614392887e-008
	,1.750330137e-008
	,1.896782392e-008
	,2.054602921e-008
	,2.224935037e-008
	,2.409044804e-008
	,2.608147039e-008
	,2.823427393e-008
	,3.056182245e-008
	,3.307951508e-008
	,3.580548765e-008
	,3.875946878e-008
	,4.196149952e-008
	,4.543099561e-008
	,4.918524703e-008
	,5.323689064e-008
	,5.759263043e-008
	,6.225841369e-008
	,6.725031213e-008
	,7.259778135e-008
	,7.833548799e-008
	,8.449470263e-008
	,9.109959394e-008
	,9.816710302e-008
	,1.057073897e-007
	,1.137195476e-007
	,1.221820872e-007
	,1.310496813e-007
	,1.402727115e-007
	,1.498383118e-007
	,1.597929260e-007
	,1.702269800e-007
	,1.812648153e-007
	,1.930587635e-007
	,2.057703441e-007
	,2.195688363e-007
	,2.346332391e-007
	,2.511699503e-007
	,2.694171836e-007
	,2.897235692e-007
	,3.125803164e-007
	,3.386200696e-007
	,3.686649875e-007
	,4.037926941e-007
	,4.453402482e-007
	,4.947896068e-007
	,5.548341550e-007
	,6.286490456e-007
	,7.203004936e-007
	,8.342759452e-007
	,9.767761641e-007
	,1.155792650e-006
	,1.380680756e-006
	,1.662066128e-006
	,2.013046862e-006
	,2.449715093e-006
	,2.990230484e-006
	,3.655204027e-006
	,4.462436494e-006
	,5.425661004e-006
	,6.577073650e-006
	,7.947893162e-006
	,9.568856313e-006
	,1.147095848e-005
	,1.368356981e-005
	,1.623166956e-005
	,1.905298242e-005
	,2.206975195e-005
	,2.533807745e-005
	,2.878166102e-005
	,3.255872229e-005
	,3.671428621e-005
	,4.126683843e-005
	,4.622804486e-005
	,5.160548390e-005
	,5.740295778e-005
	,6.362033104e-005
	,7.025348231e-005
	,7.729416564e-005
	,8.473018279e-005
	,9.254574692e-005
	,1.007220766e-004
	,1.092382018e-004
	,1.180719749e-004
	,1.272017517e-004
	,1.364905864e-004
	,1.459218067e-004
	,1.555554243e-004
	,1.653741145e-004
	,1.753597699e-004
	,1.854942906e-004
	,1.957633274e-004
	,2.061667659e-004
	,2.164075429e-004
	,2.264117071e-004
	,2.365536644e-004
	,2.468556586e-004
	,2.572138125e-004
	,2.677608774e-004
	,2.777305009e-004
	,2.878971105e-004
	,2.983398347e-004
	,3.090543402e-004
	,3.200474066e-004
	,3.313319538e-004
	,3.429236247e-004
	,3.547887292e-004
	,3.665032217e-004
	,3.786152551e-004
	,3.909608156e-004
	,4.036821079e-004
	,4.168143526e-004
	,4.304280548e-004
	,4.436462376e-004
	,4.570930919e-004
	,4.709315677e-004
	,4.851695018e-004
	,4.998409272e-004
	,5.149269683e-004
	,5.290482187e-004
	,5.433893571e-004
	,5.581981039e-004
	,5.734527051e-004
	,5.891669519e-004
	,6.053702300e-004
	,6.220190547e-004
	,6.389394669e-004
	,6.564624177e-004
	,6.746577998e-004
	,6.936117903e-004
	,7.106166949e-004
	,7.280953678e-004
	,7.460272395e-004
	,7.643463487e-004
	,7.771070714e-004
	,7.894425577e-004
	,8.027689471e-004
	,8.167775988e-004
	,8.313113975e-004
	,8.462303170e-004
	,-8.389012413e-005
	,-7.463902972e-005
	,-6.621850444e-005
	,-5.863521478e-005
	,-5.177726289e-005
	,-4.547798360e-005
	,-3.958200775e-005
	,-3.401748602e-005
	,-2.887046068e-005
	,-2.427859870e-005
	,-2.029638992e-005
	,-1.689713333e-005
	,-1.400896345e-005
	,-1.154439407e-005
	,-9.451323968e-006
	,-7.701733662e-006
	,-6.234758653e-006
	,-4.987520058e-006
	,-3.943895644e-006
	,-3.096802560e-006
	,-2.424221326e-006
	,-1.895227212e-006
	,-1.476939660e-006
	,-1.144640986e-006
	,-8.844874806e-007
	,-6.830628200e-007
	,-5.271862849e-007
	,-4.057536278e-007
	,-3.106346463e-007
	,-2.367538042e-007
	,-1.799112821e-007
	,-1.361305609e-007
	,-1.021535780e-007
	,-7.564156098e-008
	,-5.503509477e-008
	,-3.914202777e-008
	,-2.692230335e-008
	,-1.751639150e-008
	,-1.024106983e-008
	,-4.547606752e-009
	,2.678682780e-017
	,3.732513000e-009
	,6.876928059e-009
	,9.595160606e-009
	,1.201967924e-008
	,1.426838576e-008
	,1.644070971e-008
	,1.860965493e-008
	,2.083435265e-008
	,2.316327596e-008
	,2.563242849e-008
	,2.826603336e-008
	,3.108210266e-008
	,3.410388096e-008
	,3.736425145e-008
	,4.089822670e-008
	,4.473748835e-008
	,4.890996595e-008
	,5.343918102e-008
	,5.833629126e-008
	,6.358921675e-008
	,6.916165999e-008
	,7.501240674e-008
	,8.113344785e-008
	,8.756958605e-008
	,9.439125811e-008
	,1.016581220e-007
	,1.094012075e-007
	,1.176132288e-007
	,1.262466349e-007
	,1.352444090e-007
	,1.445989066e-007
	,1.543686331e-007
	,1.646330061e-007
	,1.754586442e-007
	,1.869018759e-007
	,1.990269945e-007
	,2.119096421e-007
	,2.256229440e-007
	,2.402248257e-007
	,2.557565208e-007
	,2.722549792e-007
	,2.897738734e-007
	,3.083935826e-007
	,3.282118811e-007
	,3.493327146e-007
	,3.718647097e-007
	,3.959243016e-007
	,4.216374213e-007
	,4.491389130e-007
	,4.785714097e-007
	,5.100849903e-007
	,5.438396172e-007
	,5.800084114e-007
	,6.187762116e-007
	,6.603391517e-007
	,7.049043931e-007
	,7.526886106e-007
	,8.039152659e-007
	,8.588116062e-007
	,9.176081726e-007
	,9.805337474e-007
	,1.047846327e-006
	,1.119838344e-006
	,1.196883976e-006
	,1.279485717e-006
	,1.368395945e-006
	,1.464669799e-006
	,1.569664402e-006
	,1.685083030e-006
	,1.813081133e-006
	,1.956451189e-006
	,2.118466804e-006
	,2.304283144e-006
	,2.520233176e-006
	,2.774289710e-006
	,3.076201853e-006
	,3.437094762e-006
	,3.868440012e-006
	,4.386544349e-006
	,4.999912561e-006
	,5.725357852e-006
	,6.582815369e-006
	,7.585487211e-006
	,8.741314196e-006
	,1.008530541e-005
	,1.164998216e-005
	,1.346018343e-005
	,1.554141408e-005
	,1.791623872e-005
	,2.060456315e-005
	,2.362418502e-005
	,2.699028635e-005
	,3.071456873e-005
	,3.480872695e-005
	,3.928006259e-005
	,4.413272497e-005
	,4.936757204e-005
	,5.498212700e-005
	,6.097063881e-005
	,6.732426937e-005
	,7.402848653e-005
	,8.107091180e-005
	,8.843641819e-005
	,9.608484759e-005
	,1.039412305e-004
	,1.120537431e-004
	,1.204109710e-004
	,1.290009632e-004
	,1.378128751e-004
	,1.468382400e-004
	,1.560728030e-004
	,1.653706185e-004
	,1.745771030e-004
	,1.838668077e-004
	,1.933220342e-004
	,2.026998661e-004
	,2.119130055e-004
	,2.213477876e-004
	,2.309604163e-004
	,2.403427172e-004
	,2.499680806e-004
	,2.596916255e-004
	,2.696756613e-004
	,2.799275086e-004
	,2.904576101e-004
	,3.012785333e-004
	,3.124043558e-004
	,3.238503767e-004
	,3.356332431e-004
	,3.477719528e-004
	,3.602697317e-004
	,3.731436853e-004
	,3.864275707e-004
	,3.993251039e-004
	,4.125909224e-004
	,4.262101971e-004
	,4.401727664e-004
	,4.545440432e-004
	,4.681543804e-004
	,4.820272584e-004
	,4.963461479e-004
	,5.111048626e-004
	,5.261584231e-004
	,5.414980335e-004
	,5.572540525e-004
	,5.734550843e-004
	,5.901366675e-004
	,6.073416038e-004
	,6.251212222e-004
	,6.433011356e-004
	,6.612252428e-004
	,6.760199505e-004
	,6.916589454e-004
	,7.054331925e-004
	,7.184658031e-004
	,7.323074714e-004
	,7.465977030e-004
	,7.612218413e-004
	,7.762053807e-004
	,7.915047857e-004
	,-1.453264054e-004
	,-1.330398732e-004
	,-1.213737297e-004
	,-1.103383854e-004
	,-9.989420435e-005
	,-9.006777011e-005
	,-8.097039645e-005
	,-7.263356947e-005
	,-6.498002060e-005
	,-5.784171338e-005
	,-5.105400726e-005
	,-4.457106318e-005
	,-3.841330028e-005
	,-3.267893728e-005
	,-2.748276487e-005
	,-2.292224007e-005
	,-1.902132804e-005
	,-1.574070285e-005
	,-1.300724820e-005
	,-1.071640520e-005
	,-8.772216926e-006
	,-7.130375098e-006
	,-5.743964088e-006
	,-4.573944969e-006
	,-3.607355244e-006
	,-2.822479427e-006
	,-2.193089676e-006
	,-1.695046945e-006
	,-1.303243268e-006
	,-9.972489981e-007
	,-7.598548295e-007
	,-5.746946012e-007
	,-4.306053113e-007
	,-3.191249821e-007
	,-2.333269665e-007
	,-1.673084151e-007
	,-1.162343558e-007
	,-7.648242144e-008
	,-4.528679200e-008
	,-2.038627624e-008
	,-1.216658383e-017
	,1.716858685e-008
	,3.201975570e-008
	,4.519127021e-008
	,5.713785427e-008
	,6.819881136e-008
	,7.871605555e-008
	,8.898313996e-008
	,9.917123090e-008
	,1.091977259e-007
	,1.189377243e-007
	,1.287783393e-007
	,1.389875786e-007
	,1.497601176e-007
	,1.612930189e-007
	,1.737526575e-007
	,1.872564205e-007
	,2.018696888e-007
	,2.176154273e-007
	,2.345120737e-007
	,2.526353725e-007
	,2.721150386e-007
	,2.930681370e-007
	,3.155661620e-007
	,3.396493003e-007
	,3.653811215e-007
	,3.928945536e-007
	,4.223728674e-007
	,4.539978882e-007
	,4.879153694e-007
	,5.242254400e-007
	,5.630013673e-007
	,6.043445985e-007
	,6.484359419e-007
	,6.955142170e-007
	,7.458109400e-007
	,7.995086124e-007
	,8.567769733e-007
	,9.177691957e-007
	,9.825730144e-007
	,1.051270058e-006
	,1.124005301e-006
	,1.201004815e-006
	,1.282573594e-006
	,1.369057852e-006
	,1.460750429e-006
	,1.557788067e-006
	,1.660066398e-006
	,1.767185106e-006
	,1.878448750e-006
	,1.992897195e-006
	,2.109332737e-006
	,2.226483455e-006
	,2.343407087e-006
	,2.459836445e-006
	,2.576101494e-006
	,2.692776022e-006
	,2.810459946e-006
	,2.929843258e-006
	,3.051818146e-006
	,3.177388547e-006
	,3.307515537e-006
	,3.443039618e-006
	,3.584680590e-006
	,3.733061287e-006
	,3.888735444e-006
	,4.052216677e-006
	,4.223976268e-006
	,4.404511943e-006
	,4.594381368e-006
	,4.794187358e-006
	,5.004621746e-006
	,5.226500378e-006
	,5.460808044e-006
	,5.708761704e-006
	,5.971904095e-006
	,6.252246972e-006
	,6.552352838e-006
	,6.875741627e-006
	,7.227041055e-006
	,7.612203224e-006
	,8.038681313e-006
	,8.515756070e-006
	,9.054936736e-006
	,9.670050951e-006
	,1.037665010e-005
	,1.119664793e-005
	,1.215361361e-005
	,1.327343168e-005
	,1.458348315e-005
	,1.610929876e-005
	,1.787840770e-005
	,1.991787753e-005
	,2.225081608e-005
	,2.489679381e-005
	,2.786907616e-005
	,3.117918922e-005
	,3.483490585e-005
	,3.883554003e-005
	,4.316980597e-005
	,4.784146077e-005
	,5.283683838e-005
	,5.814460268e-005
	,6.376505892e-005
	,6.969146576e-005
	,7.591532231e-005
	,8.242661887e-005
	,8.921601005e-005
	,9.627712865e-005
	,1.035464826e-004
	,1.109455315e-004
	,1.183505549e-004
	,1.258581147e-004
	,1.335770764e-004
	,1.415148707e-004
	,1.496594062e-004
	,1.579998093e-004
	,1.665309315e-004
	,1.752553301e-004
	,1.841795730e-004
	,1.933126502e-004
	,2.026650682e-004
	,2.122484256e-004
	,2.220752415e-004
	,2.321588685e-004
	,2.424946661e-004
	,2.528569597e-004
	,2.635042616e-004
	,2.744502469e-004
	,2.857094047e-004
	,2.972977241e-004
	,3.092295451e-004
	,3.215081051e-004
	,3.341241656e-004
	,3.466055481e-004
	,3.594307815e-004
	,3.725987354e-004
	,3.861354869e-004
	,3.991900830e-004
	,4.124582265e-004
	,4.260716242e-004
	,4.400222627e-004
	,4.543083877e-004
	,4.689614577e-004
	,4.840001867e-004
	,4.994470714e-004
	,5.153286759e-004
	,5.304675589e-004
	,5.453490718e-004
	,5.608042121e-004
	,5.768999426e-004
	,5.936928427e-004
	,6.104400876e-004
	,6.263956265e-004
	,6.398131728e-004
	,6.537274728e-004
	,6.681259650e-004
	,6.828926601e-004
	,6.979693480e-004
	,7.133226342e-004
	,7.289318444e-004
	,-2.208674799e-004
	,-2.074022836e-004
	,-1.942177272e-004
	,-1.813834661e-004
	,-1.688646434e-004
	,-1.565280056e-004
	,-1.444280508e-004
	,-1.327087502e-004
	,-1.215032318e-004
	,-1.108676682e-004
	,-1.007039627e-004
	,-9.085009645e-005
	,-8.127979805e-005
	,-7.223886568e-005
	,-6.392758805e-005
	,-5.636868308e-005
	,-4.944801448e-005
	,-4.304680978e-005
	,-3.721228625e-005
	,-3.199357293e-005
	,-2.735428721e-005
	,-2.320168882e-005
	,-1.943255809e-005
	,-1.605370597e-005
	,-1.311515152e-005
	,-1.061716606e-005
	,-8.535436890e-006
	,-6.828564437e-006
	,-5.450571876e-006
	,-4.345811875e-006
	,-3.455706645e-006
	,-2.726426425e-006
	,-2.116002403e-006
	,-1.598643064e-006
	,-1.168404874e-006
	,-8.315122341e-007
	,-5.746375522e-007
	,-3.773487741e-007
	,-2.228565846e-007
	,-9.972627540e-008
	,-1.556064785e-017
	,8.274731459e-008
	,1.534149594e-007
	,2.152885453e-007
	,2.707917699e-007
	,3.221855804e-007
	,3.713361215e-007
	,4.195135775e-007
	,4.679210596e-007
	,5.176949428e-007
	,5.696787837e-007
	,6.244448914e-007
	,6.823982774e-007
	,7.438901985e-007
	,8.088361352e-007
	,8.762387993e-007
	,9.453195398e-007
	,1.015860206e-006
	,1.088858306e-006
	,1.165516326e-006
	,1.246251931e-006
	,1.331123486e-006
	,1.420101310e-006
	,1.513154827e-006
	,1.610036454e-006
	,1.710418564e-006
	,1.814118713e-006
	,1.921058221e-006
	,2.031111801e-006
	,2.144210358e-006
	,2.260643379e-006
	,2.380983228e-006
	,2.505696282e-006
	,2.634986805e-006
	,2.768966596e-006
	,2.907915350e-006
	,3.052318119e-006
	,3.202720190e-006
	,3.359621536e-006
	,3.523455528e-006
	,3.694615953e-006
	,3.873448717e-006
	,4.060248869e-006
	,4.255491869e-006
	,4.459696075e-006
	,4.673217931e-006
	,4.896277335e-006
	,5.128942683e-006
	,5.371120279e-006
	,5.622662345e-006
	,5.883539710e-006
	,6.153855757e-006
	,6.433702523e-006
	,6.723023001e-006
	,7.021517698e-006
	,7.328579208e-006
	,7.643314050e-006
	,7.964771227e-006
	,8.292296754e-006
	,8.625640948e-006
	,8.964739713e-006
	,9.309483602e-006
	,9.659644189e-006
	,1.001496081e-005
	,1.037534910e-005
	,1.074096931e-005
	,1.111201493e-005
	,1.148857536e-005
	,1.187064459e-005
	,1.225818908e-005
	,1.265118334e-005
	,1.304958634e-005
	,1.345330734e-005
	,1.386216394e-005
	,1.427593574e-005
	,1.469443654e-005
	,1.511742296e-005
	,1.554462740e-005
	,1.597577510e-005
	,1.641061851e-005
	,1.684899478e-005
	,1.729091513e-005
	,1.773670122e-005
	,1.818716955e-005
	,1.864381997e-005
	,1.910903585e-005
	,1.958609685e-005
	,2.007965203e-005
	,2.059568384e-005
	,2.114144954e-005
	,2.172580356e-005
	,2.235947330e-005
	,2.305526675e-005
	,2.382817384e-005
	,2.469577743e-005
	,2.567765072e-005
	,2.679515164e-005
	,2.807060443e-005
	,2.952806088e-005
	,3.119243391e-005
	,3.308983494e-005
	,3.524957190e-005
	,3.769879248e-005
	,4.046106412e-005
	,4.355497450e-005
	,4.699181591e-005
	,5.078090571e-005
	,5.492613820e-005
	,5.942713887e-005
	,6.427940845e-005
	,6.947578847e-005
	,7.500999849e-005
	,8.087261903e-005
	,8.705262843e-005
	,9.353599061e-005
	,1.003101608e-004
	,1.073625282e-004
	,1.146821001e-004
	,1.222616133e-004
	,1.300976562e-004
	,1.381900775e-004
	,1.465429177e-004
	,1.551607719e-004
	,1.640493275e-004
	,1.732151173e-004
	,1.826657502e-004
	,1.924096609e-004
	,2.024561907e-004
	,2.128156083e-004
	,2.234985338e-004
	,2.342389153e-004
	,2.452089610e-004
	,2.565120137e-004
	,2.681376898e-004
	,2.798607912e-004
	,2.919161208e-004
	,3.043132433e-004
	,3.165238797e-004
	,3.290390671e-004
	,3.418530779e-004
	,3.549643012e-004
	,3.683791227e-004
	,3.814423650e-004
	,3.946053625e-004
	,4.080823038e-004
	,4.218746329e-004
	,4.359940605e-004
	,4.504579919e-004
	,4.652891082e-004
	,4.805166425e-004
	,4.961717759e-004
	,5.122932358e-004
	,5.289417402e-004
	,5.456745263e-004
	,5.603318872e-004
	,5.753435897e-004
	,5.901050083e-004
	,6.051516985e-004
	,6.204585648e-004
	,6.358523786e-004
	,6.513821032e-004
	,-2.874641618e-004
	,-2.733013469e-004
	,-2.592586669e-004
	,-2.454205381e-004
	,-2.318590910e-004
	,-2.186210318e-004
	,-2.057286878e-004
	,-1.931851018e-004
	,-1.809880480e-004
	,-1.691458219e-004
	,-1.576658017e-004
	,-1.465530313e-004
	,-1.358371488e-004
	,-1.255796059e-004
	,-1.158397032e-004
	,-1.066326501e-004
	,-9.790661994e-005
	,-8.956224507e-005
	,-8.148650182e-005
	,-7.354935623e-005
	,-6.574118308e-005
	,-5.811326136e-005
	,-5.076540035e-005
	,-4.383049215e-005
	,-3.740792035e-005
	,-3.161618608e-005
	,-2.651763019e-005
	,-2.210484396e-005
	,-1.832339015e-005
	,-1.509939559e-005
	,-1.235704430e-005
	,-1.002595193e-005
	,-8.051557085e-006
	,-6.392541220e-006
	,-4.999630849e-006
	,-3.821392157e-006
	,-2.810998192e-006
	,-1.937868844e-006
	,-1.185361196e-006
	,-5.410715108e-007
	,1.153964791e-017
	,4.475024081e-007
	,8.210827448e-007
	,1.143635032e-006
	,1.432009810e-006
	,1.694691230e-006
	,1.938399712e-006
	,2.171649008e-006
	,2.400266597e-006
	,2.626601557e-006
	,2.852825315e-006
	,3.082947644e-006
	,3.320718059e-006
	,3.566833969e-006
	,3.816527970e-006
	,4.063247849e-006
	,4.304748354e-006
	,4.543670792e-006
	,4.785702209e-006
	,5.035748137e-006
	,5.294466452e-006
	,5.560033814e-006
	,5.834821251e-006
	,6.120421005e-006
	,6.413819992e-006
	,6.712227769e-006
	,7.017302615e-006
	,7.327800155e-006
	,7.642428072e-006
	,7.960515294e-006
	,8.282041418e-006
	,8.607264938e-006
	,8.936554638e-006
	,9.270480532e-006
	,9.609765594e-006
	,9.955092442e-006
	,1.030698955e-005
	,1.066591123e-005
	,1.103196130e-005
	,1.140445258e-005
	,1.178180283e-005
	,1.216232034e-005
	,1.254532871e-005
	,1.293082577e-005
	,1.331842212e-005
	,1.370694692e-005
	,1.409479993e-005
	,1.448056277e-005
	,1.486322347e-005
	,1.524224135e-005
	,1.561694478e-005
	,1.598674428e-005
	,1.635168249e-005
	,1.671240239e-005
	,1.706984009e-005
	,1.742497506e-005
	,1.777865030e-005
	,1.813141488e-005
	,1.848345542e-005
	,1.883467847e-005
	,1.918489292e-005
	,1.953398861e-005
	,1.988200426e-005
	,2.022902488e-005
	,2.057496303e-005
	,2.091938918e-005
	,2.126162879e-005
	,2.160120020e-005
	,2.193816375e-005
	,2.227290867e-005
	,2.260575914e-005
	,2.293678794e-005
	,2.326571865e-005
	,2.359209122e-005
	,2.391559727e-005
	,2.423627103e-005
	,2.455434267e-005
	,2.486998670e-005
	,2.518324493e-005
	,2.549411715e-005
	,2.580265927e-005
	,2.610908557e-005
	,2.641359560e-005
	,2.671636086e-005
	,2.701755475e-005
	,2.731739537e-005
	,2.761616481e-005
	,2.791422228e-005
	,2.821203245e-005
	,2.851020994e-005
	,2.880957116e-005
	,2.911119225e-005
	,2.941647824e-005
	,2.972722290e-005
	,3.004556880e-005
	,3.037477677e-005
	,3.071902613e-005
	,3.108352891e-005
	,3.147489453e-005
	,3.190143845e-005
	,3.237349891e-005
	,3.290374028e-005
	,3.350741632e-005
	,3.420254658e-005
	,3.500995318e-005
	,3.595310719e-005
	,3.705774879e-005
	,3.835127564e-005
	,3.986184487e-005
	,4.161744098e-005
	,4.364502222e-005
	,4.596918703e-005
	,4.861140189e-005
	,5.158943965e-005
	,5.491695747e-005
	,5.860345473e-005
	,6.265595632e-005
	,6.707828180e-005
	,7.187214925e-005
	,7.703679028e-005
	,8.257139268e-005
	,8.847517060e-005
	,9.474664725e-005
	,1.013828950e-004
	,1.083831403e-004
	,1.157467328e-004
	,1.234729582e-004
	,1.315611638e-004
	,1.400133919e-004
	,1.488318835e-004
	,1.580201483e-004
	,1.675832317e-004
	,1.775284894e-004
	,1.877900867e-004
	,1.982874308e-004
	,2.088133776e-004
	,2.193844338e-004
	,2.302553034e-004
	,2.414182927e-004
	,2.528675000e-004
	,2.645986778e-004
	,2.766090102e-004
	,2.888970498e-004
	,3.014627389e-004
	,3.143074815e-004
	,3.274342524e-004
	,3.408477430e-004
	,3.545544542e-004
	,3.685630584e-004
	,3.828850718e-004
	,3.975354319e-004
	,4.125354364e-004
	,4.279001199e-004
	,4.431758775e-004
	,4.586122754e-004
	,4.739716690e-004
	,4.893907292e-004
	,5.051304183e-004
	,5.210429189e-004
	,5.359975262e-004
	,5.510848784e-004
	,-3.410936656e-004
	,-3.267113687e-004
	,-3.123644002e-004
	,-2.980004711e-004
	,-2.836466187e-004
	,-2.694177167e-004
	,-2.554374469e-004
	,-2.417915239e-004
	,-2.285142022e-004
	,-2.155996299e-004
	,-2.030006373e-004
	,-1.907238114e-004
	,-1.788314241e-004
	,-1.673471827e-004
	,-1.562820065e-004
	,-1.456404610e-004
	,-1.354266477e-004
	,-1.256575103e-004
	,-1.163527375e-004
	,-1.075219265e-004
	,-9.915993743e-005
	,-9.123250185e-005
	,-8.364805008e-005
	,-7.624535694e-005
	,-6.890067517e-005
	,-6.165322557e-005
	,-5.463672993e-005
	,-4.800410366e-005
	,-4.182253026e-005
	,-3.607758410e-005
	,-3.073538976e-005
	,-2.580658579e-005
	,-2.133873939e-005
	,-1.734401782e-005
	,-1.379613874e-005
	,-1.065060388e-005
	,-7.881992835e-006
	,-5.472602882e-006
	,-3.383151603e-006
	,-1.572029985e-006
	,6.213578220e-018
	,1.374077060e-006
	,2.587970655e-006
	,3.667185343e-006
	,4.614763137e-006
	,5.445091883e-006
	,6.196615384e-006
	,6.895373112e-006
	,7.556597760e-006
	,8.189641195e-006
	,8.798800834e-006
	,9.383776238e-006
	,9.943627836e-006
	,1.048107674e-005
	,1.099783930e-005
	,1.149341980e-005
	,1.197256326e-005
	,1.244064892e-005
	,1.289870004e-005
	,1.334697111e-005
	,1.378216016e-005
	,1.420636310e-005
	,1.462823708e-005
	,1.505174939e-005
	,1.547644667e-005
	,1.589785632e-005
	,1.630568737e-005
	,1.669416335e-005
	,1.707324247e-005
	,1.745124600e-005
	,1.782851291e-005
	,1.820245434e-005
	,1.856919579e-005
	,1.893106158e-005
	,1.929191925e-005
	,1.965325642e-005
	,2.001548141e-005
	,2.037954514e-005
	,2.074592830e-005
	,2.111475867e-005
	,2.148631296e-005
	,2.186047521e-005
	,2.223642252e-005
	,2.261213661e-005
	,2.298361700e-005
	,2.334634872e-005
	,2.369955860e-005
	,2.404581812e-005
	,2.438794097e-005
	,2.472774117e-005
	,2.506588286e-005
	,2.540216005e-005
	,2.573615657e-005
	,2.606722903e-005
	,2.639424111e-005
	,2.671601267e-005
	,2.703168269e-005
	,2.734118842e-005
	,2.764463159e-005
	,2.794162582e-005
	,2.823160770e-005
	,2.851443971e-005
	,2.879024905e-005
	,2.905898116e-005
	,2.932054535e-005
	,2.957518452e-005
	,2.982354045e-005
	,3.006653229e-005
	,3.030518743e-005
	,3.054041810e-005
	,3.077286164e-005
	,3.100287321e-005
	,3.123059476e-005
	,3.145600090e-005
	,3.167890351e-005
	,3.189894312e-005
	,3.211563966e-005
	,3.232857063e-005
	,3.253750818e-005
	,3.274244015e-005
	,3.294346731e-005
	,3.314067408e-005
	,3.333406856e-005
	,3.352357652e-005
	,3.370907709e-005
	,3.389050337e-005
	,3.406795063e-005
	,3.424170627e-005
	,3.441210655e-005
	,3.457940701e-005
	,3.474378308e-005
	,3.490540312e-005
	,3.506450146e-005
	,3.522137848e-005
	,3.537635820e-005
	,3.552978269e-005
	,3.568205229e-005
	,3.583366957e-005
	,3.598526591e-005
	,3.613763361e-005
	,3.629178019e-005
	,3.644898752e-005
	,3.661077445e-005
	,3.677940224e-005
	,3.695781369e-005
	,3.714968992e-005
	,3.735973980e-005
	,3.759395656e-005
	,3.785989903e-005
	,3.816699473e-005
	,3.852684807e-005
	,3.895352544e-005
	,3.946377887e-005
	,4.007716165e-005
	,4.081598840e-005
	,4.170510347e-005
	,4.277143245e-005
	,4.404331899e-005
	,4.554976611e-005
	,4.731939413e-005
	,4.937939164e-005
	,5.175456241e-005
	,5.446662964e-005
	,5.753385246e-005
	,6.097052330e-005
	,6.478896488e-005
	,6.899819534e-005
	,7.360449087e-005
	,7.861168269e-005
	,8.402131525e-005
	,8.983403829e-005
	,9.604919052e-005
	,1.026651207e-004
	,1.096797348e-004
	,1.170910313e-004
	,1.248964715e-004
	,1.330936456e-004
	,1.416805805e-004
	,1.506551352e-004
	,1.600157009e-004
	,1.697611480e-004
	,1.798905832e-004
	,1.903307876e-004
	,2.007185486e-004
	,2.114618807e-004
	,2.225566228e-004
	,2.339998056e-004
	,2.457896504e-004
	,2.579059215e-004
	,2.703155826e-004
	,2.829929390e-004
	,2.959131702e-004
	,3.091276169e-004
	,3.226315315e-004
	,3.364215635e-004
	,3.504982359e-004
	,3.646804018e-004
	,3.791235366e-004
	,3.938256818e-004
	,4.087792536e-004
	,4.239776480e-004
	,-3.827848014e-004
	,-3.671201844e-004
	,-3.514878696e-004
	,-3.360309428e-004
	,-3.208358865e-004
	,-3.059522612e-004
	,-2.914061792e-004
	,-2.771947661e-004
	,-2.633128737e-004
	,-2.497605205e-004
	,-2.365375277e-004
	,-2.236369142e-004
	,-2.110367484e-004
	,-1.987153552e-004
	,-1.867076398e-004
	,-1.750823079e-004
	,-1.638748160e-004
	,-1.530997074e-004
	,-1.427552386e-004
	,-1.328016590e-004
	,-1.231622078e-004
	,-1.138075241e-004
	,-1.047330568e-004
	,-9.591376186e-005
	,-8.735245751e-005
	,-7.909068740e-005
	,-7.117555954e-005
	,-6.363812139e-005
	,-5.649441293e-005
	,-4.974211496e-005
	,-4.335806606e-005
	,-3.733815042e-005
	,-3.171324159e-005
	,-2.649776978e-005
	,-2.168185288e-005
	,-1.724499198e-005
	,-1.316353914e-005
	,-9.414409062e-006
	,-5.978357533e-006
	,-2.842703211e-006
	,-7.101595998e-018
	,2.556619895e-006
	,4.838651232e-006
	,6.868640851e-006
	,8.677014845e-006
	,1.029267508e-005
	,1.173525163e-005
	,1.300838489e-005
	,1.411254965e-005
	,1.505990084e-005
	,1.588871065e-005
	,1.663706756e-005
	,1.732525771e-005
	,1.796426043e-005
	,1.856253527e-005
	,1.912851493e-005
	,1.966632971e-005
	,2.017298823e-005
	,2.065213506e-005
	,2.111326725e-005
	,2.156063964e-005
	,2.199576818e-005
	,2.241923868e-005
	,2.283115173e-005
	,2.323123997e-005
	,2.361911353e-005
	,2.399488103e-005
	,2.435947463e-005
	,2.471382300e-005
	,2.505831701e-005
	,2.539309905e-005
	,2.571678709e-005
	,2.602769947e-005
	,2.632925006e-005
	,2.662476932e-005
	,2.691497212e-005
	,2.720020990e-005
	,2.748139169e-005
	,2.775869486e-005
	,2.803035756e-005
	,2.829503664e-005
	,2.855558248e-005
	,2.881282086e-005
	,2.906658083e-005
	,2.931683522e-005
	,2.956340880e-005
	,2.980601794e-005
	,3.004473836e-005
	,3.027975769e-005
	,3.051120575e-005
	,3.073915141e-005
	,3.096377808e-005
	,3.118527054e-005
	,3.140368667e-005
	,3.161903370e-005
	,3.183138891e-005
	,3.204082751e-005
	,3.224734460e-005
	,3.245085513e-005
	,3.265116320e-005
	,3.284804604e-005
	,3.304153039e-005
	,3.323158161e-005
	,3.341795540e-005
	,3.360043661e-005
	,3.377903514e-005
	,3.395393421e-005
	,3.412530293e-005
	,3.429319216e-005
	,3.445758286e-005
	,3.461845248e-005
	,3.477583729e-005
	,3.492985379e-005
	,3.508066940e-005
	,3.522844937e-005
	,3.537330643e-005
	,3.551526741e-005
	,3.565429254e-005
	,3.579036584e-005
	,3.592354157e-005
	,3.605392232e-005
	,3.618162748e-005
	,3.630676946e-005
	,3.642946821e-005
	,3.654984090e-005
	,3.666796758e-005
	,3.678388806e-005
	,3.689760637e-005
	,3.700909875e-005
	,3.711833087e-005
	,3.722529228e-005
	,3.733004091e-005
	,3.743271928e-005
	,3.753351911e-005
	,3.763264612e-005
	,3.773026511e-005
	,3.782649992e-005
	,3.792145131e-005
	,3.801522562e-005
	,3.810795645e-005
	,3.819980495e-005
	,3.829095018e-005
	,3.838158868e-005
	,3.847194946e-005
	,3.856231788e-005
	,3.865305501e-005
	,3.874461149e-005
	,3.883755227e-005
	,3.893259777e-005
	,3.903066781e-005
	,3.913284050e-005
	,3.924070278e-005
	,3.935633954e-005
	,3.948236206e-005
	,3.962212892e-005
	,3.977994981e-005
	,3.996132163e-005
	,4.017319924e-005
	,4.042429459e-005
	,4.072539077e-005
	,4.108964601e-005
	,4.153285517e-005
	,4.207362248e-005
	,4.273339615e-005
	,4.353631651e-005
	,4.450884131e-005
	,4.567914328e-005
	,4.707630580e-005
	,4.872938654e-005
	,5.066644694e-005
	,5.291365753e-005
	,5.549457718e-005
	,5.842967867e-005
	,6.173611150e-005
	,6.542773039e-005
	,6.951531746e-005
	,7.400693464e-005
	,7.890837653e-005
	,8.422373677e-005
	,8.994633678e-005
	,9.608220699e-005
	,1.026305937e-004
	,1.095925506e-004
	,1.169670020e-004
	,1.247530973e-004
	,1.329497532e-004
	,1.415552923e-004
	,1.505687875e-004
	,1.599887585e-004
	,1.698141401e-004
	,1.798230674e-004
	,1.899249765e-004
	,2.003969146e-004
	,2.112322476e-004
	,2.224250497e-004
	,2.339432233e-004
	,2.457996510e-004
	,2.579901762e-004
	,2.705086680e-004
	,2.833491304e-004
	,2.965057384e-004
	,-4.124050077e-004
	,-3.966401159e-004
	,-3.810600550e-004
	,-3.656688047e-004
	,-3.504455560e-004
	,-3.354029029e-004
	,-3.205619012e-004
	,-3.059641334e-004
	,-2.916405727e-004
	,-2.775850010e-004
	,-2.637595017e-004
	,-2.501389064e-004
	,-2.367530498e-004
	,-2.236729118e-004
	,-2.109497199e-004
	,-1.986137105e-004
	,-1.866780723e-004
	,-1.751239883e-004
	,-1.639141067e-004
	,-1.530029679e-004
	,-1.423416323e-004
	,-1.318904057e-004
	,-1.216554220e-004
	,-1.117031874e-004
	,-1.021034495e-004
	,-9.289548188e-005
	,-8.409411157e-005
	,-7.569921120e-005
	,-6.769930083e-005
	,-6.006980851e-005
	,-5.279216627e-005
	,-4.586790040e-005
	,-3.928454467e-005
	,-3.303363408e-005
	,-2.713717402e-005
	,-2.163016148e-005
	,-1.653010846e-005
	,-1.183413240e-005
	,-7.527316960e-006
	,-3.589725980e-006
	,2.186819856e-016
	,3.263027154e-006
	,6.219672255e-006
	,8.889558748e-006
	,1.129232190e-005
	,1.344788333e-005
	,1.537611781e-005
	,1.709644157e-005
	,1.862744895e-005
	,1.998652650e-005
	,2.118943189e-005
	,2.224960686e-005
	,2.317750626e-005
	,2.398486452e-005
	,2.469076224e-005
	,2.531448228e-005
	,2.587010292e-005
	,2.636876293e-005
	,2.681882792e-005
	,2.722472205e-005
	,2.759451617e-005
	,2.794052124e-005
	,2.826968414e-005
	,2.858483362e-005
	,2.888715829e-005
	,2.917726325e-005
	,2.945582598e-005
	,2.972305923e-005
	,2.997883629e-005
	,3.022235918e-005
	,3.045216612e-005
	,3.067055091e-005
	,3.088185337e-005
	,3.108861039e-005
	,3.129194933e-005
	,3.149220624e-005
	,3.168916087e-005
	,3.188173498e-005
	,3.206889485e-005
	,3.225191601e-005
	,3.243203595e-005
	,3.260963468e-005
	,3.278474552e-005
	,3.295718299e-005
	,3.312651016e-005
	,3.329250485e-005
	,3.345579988e-005
	,3.361550224e-005
	,3.377204168e-005
	,3.392686937e-005
	,3.408010880e-005
	,3.423163162e-005
	,3.438134757e-005
	,3.452914839e-005
	,3.467488371e-005
	,3.481839036e-005
	,3.495954088e-005
	,3.509829742e-005
	,3.523471809e-005
	,3.536891077e-005
	,3.550106906e-005
	,3.563136771e-005
	,3.575988180e-005
	,3.588662308e-005
	,3.601153558e-005
	,3.613446998e-005
	,3.625527264e-005
	,3.637402874e-005
	,3.649086089e-005
	,3.660580512e-005
	,3.671888421e-005
	,3.683013473e-005
	,3.693960550e-005
	,3.704733854e-005
	,3.715336391e-005
	,3.725771954e-005
	,3.736045433e-005
	,3.746162594e-005
	,3.756129984e-005
	,3.765954805e-005
	,3.775645273e-005
	,3.785209959e-005
	,3.794656605e-005
	,3.803991356e-005
	,3.813218651e-005
	,3.822342658e-005
	,3.831367807e-005
	,3.840297127e-005
	,3.849131988e-005
	,3.857875336e-005
	,3.866533011e-005
	,3.875110654e-005
	,3.883612559e-005
	,3.892042183e-005
	,3.900402705e-005
	,3.908697096e-005
	,3.916928131e-005
	,3.925098456e-005
	,3.933210489e-005
	,3.941265222e-005
	,3.949261710e-005
	,3.957195868e-005
	,3.965063321e-005
	,3.972863963e-005
	,3.980604259e-005
	,3.988295531e-005
	,3.995950737e-005
	,4.003582410e-005
	,4.011202262e-005
	,4.018821815e-005
	,4.026453380e-005
	,4.034111157e-005
	,4.041812423e-005
	,4.049578928e-005
	,4.057438606e-005
	,4.065427728e-005
	,4.073593568e-005
	,4.081997080e-005
	,4.090708375e-005
	,4.099836743e-005
	,4.109527745e-005
	,4.119963409e-005
	,4.131379605e-005
	,4.144081586e-005
	,4.158462595e-005
	,4.175025858e-005
	,4.194410412e-005
	,4.217420155e-005
	,4.245054685e-005
	,4.278540681e-005
	,4.319359944e-005
	,4.369270201e-005
	,4.430314327e-005
	,4.504812440e-005
	,4.595332520e-005
	,4.704638667e-005
	,4.835617737e-005
	,4.991189909e-005
	,5.174212270e-005
	,5.387385217e-005
	,5.633173473e-005
	,5.913748220e-005
	,6.230954628e-005
	,6.586304490e-005
	,6.980989958e-005
	,7.415912895e-005
	,7.891725012e-005
	,8.408875374e-005
	,8.967629689e-005
	,9.568068377e-005
	,1.021019218e-004
	,1.089422456e-004
	,1.162012934e-004
	,1.238788184e-004
	,1.319758842e-004
	,1.404915785e-004
	,1.494261533e-004
	,1.587806184e-004
	,1.683825590e-004
	,1.780484729e-004
	,1.881013568e-004
	,-4.347510186e-004
	,-4.191594747e-004
	,-4.036929041e-004
	,-3.883486779e-004
	,-3.731962166e-004
	,-3.582933473e-004
	,-3.436504744e-004
	,-3.292384905e-004
	,-3.149957924e-004
	,-3.008710380e-004
	,-2.868549327e-004
	,-2.729338142e-004
	,-2.591180595e-004
	,-2.454699796e-004
	,-2.320858420e-004
	,-2.190181999e-004
	,-2.062580832e-004
	,-1.937631256e-004
	,-1.814833115e-004
	,-1.694091834e-004
	,-1.575914248e-004
	,-1.460944721e-004
	,-1.349669914e-004
	,-1.242298179e-004
	,-1.138824681e-004
	,-1.039109280e-004
	,-9.430024031e-005
	,-8.505296987e-005
	,-7.617858118e-005
	,-6.767463642e-005
	,-5.953870736e-005
	,-5.178098058e-005
	,-4.440958378e-005
	,-3.742817431e-005
	,-3.084350178e-005
	,-2.466665749e-005
	,-1.890837111e-005
	,-1.357054768e-005
	,-8.646405011e-006
	,-4.126874131e-006
	,1.586331607e-016
	,3.751259090e-006
	,7.146094742e-006
	,1.020440352e-005
	,1.294640371e-005
	,1.539253827e-005
	,1.756400557e-005
	,1.948346964e-005
	,2.117433150e-005
	,2.265945823e-005
	,2.396009504e-005
	,2.509426552e-005
	,2.607574216e-005
	,2.692090269e-005
	,2.765282300e-005
	,2.829184069e-005
	,2.885478252e-005
	,2.935632945e-005
	,2.980821975e-005
	,3.021930132e-005
	,3.059625547e-005
	,3.094421020e-005
	,3.126712016e-005
	,3.156799968e-005
	,3.184911704e-005
	,3.211228272e-005
	,3.235936594e-005
	,3.259239992e-005
	,3.281306575e-005
	,3.302272336e-005
	,3.322262689e-005
	,3.341348715e-005
	,3.359579085e-005
	,3.377131028e-005
	,3.394192247e-005
	,3.410873081e-005
	,3.427228329e-005
	,3.443298785e-005
	,3.459114140e-005
	,3.474682169e-005
	,3.490000095e-005
	,3.505046338e-005
	,3.519736120e-005
	,3.533880918e-005
	,3.547471871e-005
	,3.560728360e-005
	,3.573762674e-005
	,3.586606313e-005
	,3.599269238e-005
	,3.611753222e-005
	,3.624055449e-005
	,3.636170653e-005
	,3.648091496e-005
	,3.659802108e-005
	,3.671236702e-005
	,3.682283505e-005
	,3.693039414e-005
	,3.703560281e-005
	,3.713831824e-005
	,3.723871924e-005
	,3.733723726e-005
	,3.743413415e-005
	,3.752957861e-005
	,3.762369385e-005
	,3.771657577e-005
	,3.780830646e-005
	,3.789896032e-005
	,3.798859476e-005
	,3.807725177e-005
	,3.816496235e-005
	,3.825172925e-005
	,3.833748463e-005
	,3.842213874e-005
	,3.850581465e-005
	,3.858873006e-005
	,3.867100843e-005
	,3.875270941e-005
	,3.883387674e-005
	,3.891454860e-005
	,3.899476169e-005
	,3.907454270e-005
	,3.915390311e-005
	,3.923285512e-005
	,3.931142243e-005
	,3.938963701e-005
	,3.946752144e-005
	,3.954507534e-005
	,3.962229653e-005
	,3.969919270e-005
	,3.977577940e-005
	,3.985207943e-005
	,3.992811756e-005
	,4.000389978e-005
	,4.007941653e-005
	,4.015466015e-005
	,4.022964338e-005
	,4.030441850e-005
	,4.037904615e-005
	,4.045357096e-005
	,4.052801271e-005
	,4.060237746e-005
	,4.067667338e-005
	,4.075090608e-005
	,4.082506654e-005
	,4.089914010e-005
	,4.097311950e-005
	,4.104701169e-005
	,4.112083445e-005
	,4.119460030e-005
	,4.126830964e-005
	,4.134196363e-005
	,4.141557215e-005
	,4.148915355e-005
	,4.156273519e-005
	,4.163635648e-005
	,4.171007225e-005
	,4.178395173e-005
	,4.185807338e-005
	,4.193251814e-005
	,4.200736476e-005
	,4.208269968e-005
	,4.215863868e-005
	,4.223534307e-005
	,4.231302480e-005
	,4.239195271e-005
	,4.247246081e-005
	,4.255488782e-005
	,4.263988678e-005
	,4.272844425e-005
	,4.282190023e-005
	,4.292202059e-005
	,4.303104517e-005
	,4.315181729e-005
	,4.328796870e-005
	,4.344413984e-005
	,4.362623241e-005
	,4.384169305e-005
	,4.409982221e-005
	,4.441209114e-005
	,4.479244031e-005
	,4.525751179e-005
	,4.582676540e-005
	,4.652247472e-005
	,4.736950817e-005
	,4.839492262e-005
	,4.962728412e-005
	,5.109585088e-005
	,5.282963086e-005
	,5.485641656e-005
	,5.720194817e-005
	,5.988925294e-005
	,6.293822478e-005
	,6.636546311e-005
	,7.018431414e-005
	,7.440511739e-005
	,7.903556332e-005
	,8.408109995e-005
	,8.954536004e-005
	,9.543056470e-005
	,1.017379091e-004
	,1.084678934e-004
	,-4.511588817e-004
	,-4.357027264e-004
	,-4.205374536e-004
	,-4.056588128e-004
	,-3.910681005e-004
	,-3.767087829e-004
	,-3.624712494e-004
	,-3.482348786e-004
	,-3.339552869e-004
	,-3.196507783e-004
	,-3.053294448e-004
	,-2.910342269e-004
	,-2.768542273e-004
	,-2.628716206e-004
	,-2.491169325e-004
	,-2.355702368e-004
	,-2.221944826e-004
	,-2.089965648e-004
	,-1.960082756e-004
	,-1.832460308e-004
	,-1.707337654e-004
	,-1.584975090e-004
	,-1.465549137e-004
	,-1.349460457e-004
	,-1.237140655e-004
	,-1.128796039e-004
	,-1.024434416e-004
	,-9.239493546e-005
	,-8.273207189e-005
	,-7.347447926e-005
	,-6.463551474e-005
	,-5.621611931e-005
	,-4.822010375e-005
	,-4.065296064e-005
	,-3.352061189e-005
	,-2.683074492e-005
	,-2.058808849e-005
	,-1.479135926e-005
	,-9.434288157e-006
	,-4.507557801e-006
	,9.305477508e-016
	,4.100926224e-006
	,7.808972838e-006
	,1.113913167e-005
	,1.410859008e-005
	,1.673775867e-005
	,1.904851511e-005
	,2.106021022e-005
	,2.279177003e-005
	,2.427859209e-005
	,2.556147229e-005
	,2.667310486e-005
	,2.764019517e-005
	,2.848528621e-005
	,2.922743796e-005
	,2.988270254e-005
	,3.046464629e-005
	,3.098470688e-005
	,3.145196653e-005
	,3.187267298e-005
	,3.225337915e-005
	,3.260321954e-005
	,3.292861449e-005
	,3.323320928e-005
	,3.351931048e-005
	,3.378852211e-005
	,3.404226824e-005
	,3.428190290e-005
	,3.450808742e-005
	,3.472043478e-005
	,3.491946316e-005
	,3.510794590e-005
	,3.528818808e-005
	,3.546133421e-005
	,3.562794825e-005
	,3.578834366e-005
	,3.594272854e-005
	,3.609127216e-005
	,3.623420906e-005
	,3.637198854e-005
	,3.650517235e-005
	,3.663422388e-005
	,3.675945801e-005
	,3.688103310e-005
	,3.699896152e-005
	,3.711346176e-005
	,3.722518689e-005
	,3.733450765e-005
	,3.744120141e-005
	,3.754504385e-005
	,3.764645639e-005
	,3.774593904e-005
	,3.784375447e-005
	,3.794003992e-005
	,3.803485472e-005
	,3.812813265e-005
	,3.821965480e-005
	,3.830962553e-005
	,3.839861532e-005
	,3.848691152e-005
	,3.857460506e-005
	,3.866157301e-005
	,3.874699604e-005
	,3.883065362e-005
	,3.891362250e-005
	,3.899620183e-005
	,3.907842105e-005
	,3.916027808e-005
	,3.924177240e-005
	,3.932290387e-005
	,3.940365319e-005
	,3.948393145e-005
	,3.956363644e-005
	,3.964291741e-005
	,3.972191406e-005
	,3.980065269e-005
	,3.987909367e-005
	,3.995711028e-005
	,4.003455539e-005
	,4.011154395e-005
	,4.018826031e-005
	,4.026478923e-005
	,4.034115324e-005
	,4.041733970e-005
	,4.049333899e-005
	,4.056914487e-005
	,4.064474652e-005
	,4.072013455e-005
	,4.079532467e-005
	,4.087032742e-005
	,4.094514811e-005
	,4.101978174e-005
	,4.109418718e-005
	,4.116828737e-005
	,4.124198106e-005
	,4.131520909e-005
	,4.138802917e-005
	,4.146056355e-005
	,4.153290876e-005
	,4.160511940e-005
	,4.167721589e-005
	,4.174920980e-005
	,4.182114838e-005
	,4.189307028e-005
	,4.196497616e-005
	,4.203685916e-005
	,4.210871808e-005
	,4.218055647e-005
	,4.225238226e-005
	,4.232420971e-005
	,4.239605678e-005
	,4.246792770e-005
	,4.253982109e-005
	,4.261175289e-005
	,4.268374664e-005
	,4.275582383e-005
	,4.282799953e-005
	,4.290027831e-005
	,4.297265927e-005
	,4.304514342e-005
	,4.311773834e-005
	,4.319045915e-005
	,4.326331566e-005
	,4.333631085e-005
	,4.340945499e-005
	,4.348277279e-005
	,4.355630474e-005
	,4.363010951e-005
	,4.370426890e-005
	,4.377889205e-005
	,4.385411468e-005
	,4.393010908e-005
	,4.400710729e-005
	,4.408540498e-005
	,4.416528848e-005
	,4.424732234e-005
	,4.433224637e-005
	,4.442094515e-005
	,4.451456707e-005
	,4.461460905e-005
	,4.472302228e-005
	,4.484234927e-005
	,4.497588937e-005
	,4.512789561e-005
	,4.530380498e-005
	,4.551050287e-005
	,4.575661297e-005
	,4.605280542e-005
	,4.641210429e-005
	,4.685015403e-005
	,4.738539779e-005
	,4.803912234e-005
	,4.883532485e-005
	,4.980036890e-005
	,5.096242165e-005
	,5.235069600e-005
	,5.399460386e-005
	,5.592275427e-005
	,5.816193316e-005
	,6.073648832e-005
	,6.366771215e-005
	,-4.665527914e-004
	,-4.509219771e-004
	,-4.355800291e-004
	,-4.205457300e-004
	,-4.057939893e-004
	,-3.912471960e-004
	,-3.768391173e-004
	,-3.625496155e-004
	,-3.483271424e-004
	,-3.340605836e-004
	,-3.196826284e-004
	,-3.052426578e-004
	,-2.908318493e-004
	,-2.764950565e-004
	,-2.622434290e-004
	,-2.481196186e-004
	,-2.341796840e-004
	,-2.204547960e-004
	,-2.069437164e-004
	,-1.936567991e-004
	,-1.806479388e-004
	,-1.679629295e-004
	,-1.556165200e-004
	,-1.436024793e-004
	,-1.319069439e-004
	,-1.205242819e-004
	,-1.094628670e-004
	,-9.875662209e-005
	,-8.844985515e-005
	,-7.856086042e-005
	,-6.909502925e-005
	,-6.006799934e-005
	,-5.149760049e-005
	,-4.339646718e-005
	,-3.577304178e-005
	,-2.863069538e-005
	,-2.196798156e-005
	,-1.578034761e-005
	,-1.006153642e-005
	,-4.804199763e-006
	,2.401936021e-017
	,4.360419328e-006
	,8.287705885e-006
	,1.179509621e-005
	,1.489779247e-005
	,1.761029376e-005
	,1.995968810e-005
	,2.198859100e-005
	,2.373813111e-005
	,2.524570126e-005
	,2.654566008e-005
	,2.766918958e-005
	,2.864400079e-005
	,2.949413280e-005
	,3.023973426e-005
	,3.089617056e-005
	,3.147404405e-005
	,3.198901307e-005
	,3.245590944e-005
	,3.288293215e-005
	,3.327435182e-005
	,3.362999504e-005
	,3.394907588e-005
	,3.424266578e-005
	,3.451863330e-005
	,3.477998730e-005
	,3.502835686e-005
	,3.526485210e-005
	,3.549031448e-005
	,3.570542674e-005
	,3.591077546e-005
	,3.610689097e-005
	,3.629427335e-005
	,3.647340923e-005
	,3.664478352e-005
	,3.680888798e-005
	,3.696622331e-005
	,3.711729161e-005
	,3.726258367e-005
	,3.740256828e-005
	,3.753768555e-005
	,3.766834333e-005
	,3.779491548e-005
	,3.791774128e-005
	,3.803712548e-005
	,3.815333819e-005
	,3.826661382e-005
	,3.837714803e-005
	,3.848509308e-005
	,3.859055751e-005
	,3.869362442e-005
	,3.879439910e-005
	,3.889301436e-005
	,3.898950099e-005
	,3.908395645e-005
	,3.917675573e-005
	,3.926815441e-005
	,3.935818711e-005
	,3.944686730e-005
	,3.953432637e-005
	,3.962076836e-005
	,3.970643720e-005
	,3.979138022e-005
	,3.987552521e-005
	,3.995875745e-005
	,4.004108890e-005
	,4.012271559e-005
	,4.020382999e-005
	,4.028444925e-005
	,4.036411163e-005
	,4.044187997e-005
	,4.051861895e-005
	,4.059520919e-005
	,4.067180968e-005
	,4.074843118e-005
	,4.082506104e-005
	,4.090168525e-005
	,4.097829238e-005
	,4.105487379e-005
	,4.113142244e-005
	,4.120793009e-005
	,4.128437876e-005
	,4.136071116e-005
	,4.143675587e-005
	,4.151226809e-005
	,4.158722474e-005
	,4.166179644e-005
	,4.173623131e-005
	,4.181063975e-005
	,4.188505469e-005
	,4.195947429e-005
	,4.203388205e-005
	,4.210826444e-005
	,4.218261261e-005
	,4.225691926e-005
	,4.233118356e-005
	,4.240542102e-005
	,4.247965082e-005
	,4.255387029e-005
	,4.262805702e-005
	,4.270218973e-005
	,4.277625489e-005
	,4.285026277e-005
	,4.292422013e-005
	,4.299812720e-005
	,4.307198061e-005
	,4.314577180e-005
	,4.321949829e-005
	,4.329318596e-005
	,4.336686894e-005
	,4.344056580e-005
	,4.351428572e-005
	,4.358804062e-005
	,4.366184479e-005
	,4.373570069e-005
	,4.380959716e-005
	,4.388352330e-005
	,4.395746925e-005
	,4.403142900e-005
	,4.410541856e-005
	,4.417946623e-005
	,4.425358344e-005
	,4.432775633e-005
	,4.440197066e-005
	,4.447622194e-005
	,4.455051294e-005
	,4.462485213e-005
	,4.469925492e-005
	,4.477374722e-005
	,4.484836644e-005
	,4.492314297e-005
	,4.499808556e-005
	,4.507320413e-005
	,4.514852214e-005
	,4.522407174e-005
	,4.529988716e-005
	,4.537600976e-005
	,4.545250031e-005
	,4.552944877e-005
	,4.560698029e-005
	,4.568525406e-005
	,4.576444708e-005
	,4.584467502e-005
	,4.592633908e-005
	,4.600997871e-005
	,4.609621665e-005
	,4.618586334e-005
	,4.627998493e-005
	,4.637998071e-005
	,4.648767910e-005
	,4.660545648e-005
	,4.673638034e-005
	,4.688438078e-005
	,4.705446659e-005
	,4.725299218e-005
	,4.748795429e-005
	,4.776930307e-005
	,4.810925036e-005
	,4.852254484e-005
	,4.902667309e-005
	,4.964195992e-005
	,-4.815664704e-004
	,-4.658010137e-004
	,-4.502892145e-004
	,-4.350107275e-004
	,-4.198919947e-004
	,-4.048882697e-004
	,-3.899908649e-004
	,-3.751436781e-004
	,-3.602304860e-004
	,-3.451891406e-004
	,-3.301116318e-004
	,-3.151212620e-004
	,-3.002813983e-004
	,-2.856306616e-004
	,-2.711875678e-004
	,-2.569358221e-004
	,-2.428571626e-004
	,-2.289520797e-004
	,-2.152263123e-004
	,-2.017078221e-004
	,-1.884442045e-004
	,-1.754716538e-004
	,-1.628082516e-004
	,-1.504559003e-004
	,-1.383997473e-004
	,-1.266210831e-004
	,-1.151383236e-004
	,-1.039906318e-004
	,-9.320138257e-005
	,-8.279262884e-005
	,-7.280571478e-005
	,-6.328293628e-005
	,-5.424868410e-005
	,-4.571370126e-005
	,-3.768234742e-005
	,-3.015563908e-005
	,-2.313208716e-005
	,-1.660874789e-005
	,-1.058192749e-005
	,-5.047317215e-006
	,4.594870763e-018
	,4.565464646e-006
	,8.655266514e-006
	,1.227611992e-005
	,1.544706616e-005
	,1.820515376e-005
	,2.059156240e-005
	,2.264758748e-005
	,2.441395500e-005
	,2.592984711e-005
	,2.723188386e-005
	,2.835327120e-005
	,2.932306335e-005
	,3.016482992e-005
	,3.089551711e-005
	,3.153734485e-005
	,3.211165632e-005
	,3.262861979e-005
	,3.308613736e-005
	,3.349020187e-005
	,3.386105665e-005
	,3.420742026e-005
	,3.453349706e-005
	,3.484195253e-005
	,3.513461894e-005
	,3.541277618e-005
	,3.567730290e-005
	,3.592874239e-005
	,3.616734266e-005
	,3.639345478e-005
	,3.660794944e-005
	,3.681178140e-005
	,3.700577779e-005
	,3.719070708e-005
	,3.736731549e-005
	,3.753632738e-005
	,3.769843436e-005
	,3.785428393e-005
	,3.800447146e-005
	,3.814953624e-005
	,3.828996069e-005
	,3.842617086e-005
	,3.855853540e-005
	,3.868735745e-005
	,3.881284041e-005
	,3.893496418e-005
	,3.905327281e-005
	,3.916768271e-005
	,3.927923618e-005
	,3.938867560e-005
	,3.949631578e-005
	,3.960232166e-005
	,3.970680341e-005
	,3.980984243e-005
	,3.991149345e-005
	,4.001176824e-005
	,4.011059009e-005
	,4.020775879e-005
	,4.030319693e-005
	,4.039721966e-005
	,4.049015094e-005
	,4.058212886e-005
	,4.067318321e-005
	,4.076329920e-005
	,4.085247181e-005
	,4.094076008e-005
	,4.102826612e-005
	,4.111507602e-005
	,4.120124305e-005
	,4.128677666e-005
	,4.137158939e-005
	,4.145550544e-005
	,4.153878012e-005
	,4.162175923e-005
	,4.170458003e-005
	,4.178727320e-005
	,4.186966195e-005
	,4.195083045e-005
	,4.203048675e-005
	,4.210974043e-005
	,4.218890721e-005
	,4.226798578e-005
	,4.234688985e-005
	,4.242552354e-005
	,4.250398268e-005
	,4.258241268e-005
	,4.266086389e-005
	,4.273933249e-005
	,4.281775680e-005
	,4.289596508e-005
	,4.297380268e-005
	,4.305135830e-005
	,4.312874654e-005
	,4.320601264e-005
	,4.328317075e-005
	,4.336022499e-005
	,4.343717630e-005
	,4.351402121e-005
	,4.359073683e-005
	,4.366726430e-005
	,4.374363184e-005
	,4.381993851e-005
	,4.389622224e-005
	,4.397249802e-005
	,4.404878093e-005
	,4.412507519e-005
	,4.420136444e-005
	,4.427763552e-005
	,4.435389108e-005
	,4.443013072e-005
	,4.450635216e-005
	,4.458254895e-005
	,4.465870130e-005
	,4.473477038e-005
	,4.481073920e-005
	,4.488663887e-005
	,4.496251506e-005
	,4.503838757e-005
	,4.511426151e-005
	,4.519013866e-005
	,4.526602092e-005
	,4.534191218e-005
	,4.541782157e-005
	,4.549376773e-005
	,4.556976222e-005
	,4.564579847e-005
	,4.572187810e-005
	,4.579800603e-005
	,4.587418856e-005
	,4.595043834e-005
	,4.602677263e-005
	,4.610319965e-005
	,4.617971396e-005
	,4.625631098e-005
	,4.633298842e-005
	,4.640974208e-005
	,4.648657712e-005
	,4.656351137e-005
	,4.664057315e-005
	,4.671778219e-005
	,4.679513548e-005
	,4.687263003e-005
	,4.695027829e-005
	,4.702810809e-005
	,4.710616234e-005
	,4.718450100e-005
	,4.726320359e-005
	,4.734237192e-005
	,4.742213132e-005
	,4.750259850e-005
	,4.758378216e-005
	,4.766599911e-005
	,4.774966693e-005
	,4.783522094e-005
	,4.792321436e-005
	,4.801437751e-005
	,4.810967655e-005
	,4.821038342e-005
	,4.831816544e-005
	,4.843519905e-005
	,4.856430188e-005
	,-4.956012266e-004
	,-4.796731517e-004
	,-4.638928108e-004
	,-4.481842187e-004
	,-4.325122696e-004
	,-4.168916769e-004
	,-4.013010908e-004
	,-3.856641038e-004
	,-3.699257954e-004
	,-3.541738444e-004
	,-3.385391720e-004
	,-3.230924812e-004
	,-3.078641317e-004
	,-2.928709498e-004
	,-2.781337083e-004
	,-2.636632724e-004
	,-2.494507849e-004
	,-2.354718680e-004
	,-2.217075870e-004
	,-2.081642318e-004
	,-1.948489720e-004
	,-1.817555109e-004
	,-1.688671225e-004
	,-1.561592976e-004
	,-1.436213655e-004
	,-1.313098519e-004
	,-1.193160210e-004
	,-1.076999559e-004
	,-9.649385482e-005
	,-8.573223710e-005
	,-7.544752525e-005
	,-6.565259460e-005
	,-5.634953488e-005
	,-4.753876054e-005
	,-3.922305013e-005
	,-3.140726587e-005
	,-2.409681118e-005
	,-1.729711196e-005
	,-1.101271883e-005
	,-5.246421543e-006
	,-2.819853704e-018
	,4.723797509e-006
	,8.925799273e-006
	,1.262582158e-005
	,1.585804343e-005
	,1.866194662e-005
	,2.107975531e-005
	,2.315498961e-005
	,2.493097855e-005
	,2.644939063e-005
	,2.774890437e-005
	,2.886387599e-005
	,2.982186793e-005
	,3.064575628e-005
	,3.136585585e-005
	,3.200176041e-005
	,3.255432154e-005
	,3.303820679e-005
	,3.347661676e-005
	,3.388104179e-005
	,3.425805450e-005
	,3.461203948e-005
	,3.494608770e-005
	,3.526239737e-005
	,3.556253196e-005
	,3.584762196e-005
	,3.611853471e-005
	,3.637601535e-005
	,3.662079317e-005
	,3.685364567e-005
	,3.707541892e-005
	,3.728701198e-005
	,3.748933999e-005
	,3.768329152e-005
	,3.786968967e-005
	,3.804925740e-005
	,3.822256819e-005
	,3.838988709e-005
	,3.855042085e-005
	,3.870249772e-005
	,3.884838630e-005
	,3.899012793e-005
	,3.912850688e-005
	,3.926390854e-005
	,3.939658121e-005
	,3.952671808e-005
	,3.965448503e-005
	,3.978003110e-005
	,3.990349283e-005
	,4.002499618e-005
	,4.014465746e-005
	,4.026258382e-005
	,4.037887371e-005
	,4.049361701e-005
	,4.060689496e-005
	,4.071877914e-005
	,4.082932920e-005
	,4.093858707e-005
	,4.104656319e-005
	,4.115320335e-005
	,4.125832993e-005
	,4.136167447e-005
	,4.146324517e-005
	,4.156342862e-005
	,4.166255897e-005
	,4.176080003e-005
	,4.185822545e-005
	,4.195487263e-005
	,4.205076484e-005
	,4.214591974e-005
	,4.224035268e-005
	,4.233407773e-005
	,4.242710750e-005
	,4.251945189e-005
	,4.261111570e-005
	,4.270209576e-005
	,4.279238258e-005
	,4.288197773e-005
	,4.297092811e-005
	,4.305932257e-005
	,4.314724072e-005
	,4.323471080e-005
	,4.332159711e-005
	,4.340763885e-005
	,4.349244975e-005
	,4.357512514e-005
	,4.365683925e-005
	,4.373842140e-005
	,4.381999612e-005
	,4.390156023e-005
	,4.398309355e-005
	,4.406457666e-005
	,4.414599111e-005
	,4.422731054e-005
	,4.430847451e-005
	,4.438936340e-005
	,4.446990207e-005
	,4.455014305e-005
	,4.463019907e-005
	,4.471013754e-005
	,4.478998139e-005
	,4.486973760e-005
	,4.494940791e-005
	,4.502899213e-005
	,4.510848930e-005
	,4.518789822e-005
	,4.526721758e-005
	,4.534644616e-005
	,4.542558290e-005
	,4.550462719e-005
	,4.558357895e-005
	,4.566243754e-005
	,4.574119501e-005
	,4.581983809e-005
	,4.589841122e-005
	,4.597696934e-005
	,4.605552294e-005
	,4.613406162e-005
	,4.621255314e-005
	,4.629095149e-005
	,4.636926160e-005
	,4.644753075e-005
	,4.652578673e-005
	,4.660403950e-005
	,4.668229420e-005
	,4.676055531e-005
	,4.683882844e-005
	,4.691712319e-005
	,4.699545864e-005
	,4.707385240e-005
	,4.715227364e-005
	,4.723068653e-005
	,4.730909552e-005
	,4.738751590e-005
	,4.746595792e-005
	,4.754442813e-005
	,4.762293253e-005
	,4.770147946e-005
	,4.778008358e-005
	,4.785877306e-005
	,4.793758662e-005
	,4.801653075e-005
	,4.809558577e-005
	,4.817473993e-005
	,4.825398919e-005
	,4.833333730e-005
	,4.841279793e-005
	,4.849239360e-005
	,4.857214412e-005
	,4.865205736e-005
	,4.873214210e-005
	,4.881241244e-005
	,4.889288299e-005
	,4.897358336e-005
	,4.905456256e-005
	,4.913589143e-005
	,4.921766075e-005
	,4.929992398e-005
	,4.938258840e-005
	,4.946592873e-005
	,4.955028815e-005
	,-5.076759870e-004
	,-4.912933988e-004
	,-4.750218567e-004
	,-4.588458549e-004
	,-4.427593660e-004
	,-4.267233513e-004
	,-4.106568674e-004
	,-3.944656065e-004
	,-3.781757469e-004
	,-3.619382527e-004
	,-3.458770441e-004
	,-3.300706197e-004
	,-3.145633638e-004
	,-2.993698989e-004
	,-2.844835445e-004
	,-2.698827582e-004
	,-2.555336314e-004
	,-2.413969271e-004
	,-2.274535694e-004
	,-2.136995618e-004
	,-2.001163818e-004
	,-1.866766490e-004
	,-1.733625695e-004
	,-1.601865852e-004
	,-1.472294751e-004
	,-1.345931532e-004
	,-1.223325940e-004
	,-1.104681940e-004
	,-9.902361922e-005
	,-8.803529026e-005
	,-7.752467774e-005
	,-6.749924804e-005
	,-5.796204868e-005
	,-4.891662813e-005
	,-4.036958814e-005
	,-3.232959752e-005
	,-2.480492428e-005
	,-1.780271545e-005
	,-1.132918953e-005
	,-5.391065505e-006
	,-2.187882856e-017
	,4.834394840e-006
	,9.123465911e-006
	,1.289423125e-005
	,1.618152565e-005
	,1.902547421e-005
	,2.146990709e-005
	,2.356057959e-005
	,2.534324629e-005
	,2.686178438e-005
	,2.815626351e-005
	,2.925977563e-005
	,3.020099257e-005
	,3.101483707e-005
	,3.171754967e-005
	,3.232100701e-005
	,3.285427368e-005
	,3.333539981e-005
	,3.377631464e-005
	,3.418480038e-005
	,3.456631531e-005
	,3.492478801e-005
	,3.526303404e-005
	,3.558305652e-005
	,3.588629734e-005
	,3.617385735e-005
	,3.644668364e-005
	,3.670571006e-005
	,3.695193709e-005
	,3.718644847e-005
	,3.741037844e-005
	,3.762485221e-005
	,3.783091454e-005
	,3.802941372e-005
	,3.822044635e-005
	,3.840165233e-005
	,3.857525463e-005
	,3.874468365e-005
	,3.891073891e-005
	,3.907374971e-005
	,3.923393161e-005
	,3.939144667e-005
	,3.954642220e-005
	,3.969895969e-005
	,3.984914000e-005
	,3.999702573e-005
	,4.014265964e-005
	,4.028605443e-005
	,4.042715903e-005
	,4.056577057e-005
	,4.070148332e-005
	,4.083418360e-005
	,4.096434162e-005
	,4.109239008e-005
	,4.121857017e-005
	,4.134303243e-005
	,4.146589033e-005
	,4.158723895e-005
	,4.170716062e-005
	,4.182572522e-005
	,4.194298616e-005
	,4.205896999e-005
	,4.217365242e-005
	,4.228691175e-005
	,4.239850031e-005
	,4.250824094e-005
	,4.261634125e-005
	,4.272317937e-005
	,4.282900648e-005
	,4.293394777e-005
	,4.303806574e-005
	,4.314139534e-005
	,4.324395937e-005
	,4.334577518e-005
	,4.344685765e-005
	,4.354722080e-005
	,4.364687857e-005
	,4.374584532e-005
	,4.384413615e-005
	,4.394176714e-005
	,4.403875559e-005
	,4.413512016e-005
	,4.423088108e-005
	,4.432606024e-005
	,4.442068130e-005
	,4.451476956e-005
	,4.460835139e-005
	,4.470145248e-005
	,4.479409300e-005
	,4.488627188e-005
	,4.497789953e-005
	,4.506843690e-005
	,4.515640556e-005
	,4.524238523e-005
	,4.532755771e-005
	,4.541222613e-005
	,4.549672974e-005
	,4.558111653e-005
	,4.566536147e-005
	,4.574947433e-005
	,4.583343634e-005
	,4.591718650e-005
	,4.600073640e-005
	,4.608413561e-005
	,4.616740723e-005
	,4.625055754e-005
	,4.633358671e-005
	,4.641649169e-005
	,4.649926440e-005
	,4.658188341e-005
	,4.666430998e-005
	,4.674655273e-005
	,4.682867393e-005
	,4.691070786e-005
	,4.699266565e-005
	,4.707455110e-005
	,4.715636582e-005
	,4.723811077e-005
	,4.731978669e-005
	,4.740139422e-005
	,4.748293372e-005
	,4.756440475e-005
	,4.764580463e-005
	,4.772712455e-005
	,4.780834018e-005
	,4.788940941e-005
	,4.797033094e-005
	,4.805116969e-005
	,4.813198576e-005
	,4.821281291e-005
	,4.829364384e-005
	,4.837444827e-005
	,4.845525154e-005
	,4.853606436e-005
	,4.861688717e-005
	,4.869771250e-005
	,4.877851312e-005
	,4.885926515e-005
	,4.893999238e-005
	,4.902073398e-005
	,4.910151385e-005
	,4.918234455e-005
	,4.926323751e-005
	,4.934420877e-005
	,4.942527560e-005
	,4.950646698e-005
	,4.958778630e-005
	,4.966920331e-005
	,4.975069631e-005
	,4.983225719e-005
	,4.991388436e-005
	,4.999557949e-005
	,5.007734678e-005
	,5.015919381e-005
	,5.024113390e-005
	,5.032319147e-005
	,5.040541054e-005
	,5.048783410e-005
	,5.057045883e-005
	,5.065327384e-005
	,5.073628465e-005
	,-5.179024083e-004
	,-5.013063278e-004
	,-4.847835379e-004
	,-4.683326912e-004
	,-4.519191393e-004
	,-4.354604812e-004
	,-4.188390551e-004
	,-4.020320336e-004
	,-3.852265462e-004
	,-3.686231924e-004
	,-3.523243228e-004
	,-3.363667133e-004
	,-3.207541587e-004
	,-3.054725145e-004
	,-2.904950155e-004
	,-2.757821449e-004
	,-2.612793811e-004
	,-2.469294739e-004
	,-2.326967116e-004
	,-2.185559859e-004
	,-2.045004513e-004
	,-1.905511058e-004
	,-1.767429416e-004
	,-1.631600152e-004
	,-1.499091735e-004
	,-1.370472105e-004
	,-1.245895155e-004
	,-1.125452452e-004
	,-1.009432389e-004
	,-8.980613410e-005
	,-7.914073990e-005
	,-6.894936300e-005
	,-5.923562713e-005
	,-5.000663024e-005
	,-4.127391590e-005
	,-3.305124603e-005
	,-2.535097191e-005
	,-1.818283588e-005
	,-1.155587463e-005
	,-5.488062563e-006
	,2.595136588e-017
	,4.910502509e-006
	,9.263106256e-006
	,1.308654445e-005
	,1.641607695e-005
	,1.929230114e-005
	,2.175980484e-005
	,2.386541012e-005
	,2.565611441e-005
	,2.717676979e-005
	,2.846656247e-005
	,2.955846581e-005
	,3.049034648e-005
	,3.128111623e-005
	,3.196044237e-005
	,3.255714278e-005
	,3.308980074e-005
	,3.357310992e-005
	,3.401703290e-005
	,3.442865719e-005
	,3.481314063e-005
	,3.517421332e-005
	,3.551454153e-005
	,3.583603552e-005
	,3.614012545e-005
	,3.642800299e-005
	,3.670080922e-005
	,3.695974624e-005
	,3.720610472e-005
	,3.744122137e-005
	,3.766638509e-005
	,3.788262663e-005
	,3.808936488e-005
	,3.828414159e-005
	,3.847243829e-005
	,3.865673783e-005
	,3.883768611e-005
	,3.901565797e-005
	,3.919092973e-005
	,3.936371673e-005
	,3.953418894e-005
	,3.970248061e-005
	,3.986869721e-005
	,4.003292096e-005
	,4.019521526e-005
	,4.035562838e-005
	,4.051419656e-005
	,4.067094661e-005
	,4.082589818e-005
	,4.097906574e-005
	,4.113046024e-005
	,4.128009053e-005
	,4.142796451e-005
	,4.157408991e-005
	,4.171847466e-005
	,4.186112640e-005
	,4.200205061e-005
	,4.214124557e-005
	,4.227868914e-005
	,4.241430279e-005
	,4.254785870e-005
	,4.267889490e-005
	,4.280720864e-005
	,4.293331038e-005
	,4.305769415e-005
	,4.318057040e-005
	,4.330195991e-005
	,4.342173220e-005
	,4.353971280e-005
	,4.365595697e-005
	,4.377076365e-005
	,4.388441030e-005
	,4.399706439e-005
	,4.410882014e-005
	,4.421973429e-005
	,4.432984450e-005
	,4.443917806e-005
	,4.454775617e-005
	,4.465559629e-005
	,4.476271348e-005
	,4.486912136e-005
	,4.497483276e-005
	,4.507986023e-005
	,4.518421645e-005
	,4.528791462e-005
	,4.539096877e-005
	,4.549339409e-005
	,4.559520724e-005
	,4.569642671e-005
	,4.579707311e-005
	,4.589716956e-005
	,4.599674199e-005
	,4.609581930e-005
	,4.619443311e-005
	,4.629261613e-005
	,4.639039628e-005
	,4.648777616e-005
	,4.658464986e-005
	,4.668041046e-005
	,4.677320637e-005
	,4.686331246e-005
	,4.695275631e-005
	,4.704204119e-005
	,4.713117110e-005
	,4.722005904e-005
	,4.730853928e-005
	,4.739627863e-005
	,4.748338622e-005
	,4.757021285e-005
	,4.765685979e-005
	,4.774333717e-005
	,4.782962839e-005
	,4.791573293e-005
	,4.800168107e-005
	,4.808749661e-005
	,4.817318952e-005
	,4.825876378e-005
	,4.834422146e-005
	,4.842956414e-005
	,4.851479329e-005
	,4.859991016e-005
	,4.868491516e-005
	,4.876980586e-005
	,4.885457243e-005
	,4.893920119e-005
	,4.902371408e-005
	,4.910815180e-005
	,4.919253251e-005
	,4.927685914e-005
	,4.936112321e-005
	,4.944529570e-005
	,4.952931839e-005
	,4.961316645e-005
	,4.969691084e-005
	,4.978062214e-005
	,4.986433106e-005
	,4.994804885e-005
	,5.003177996e-005
	,5.011552604e-005
	,5.019928568e-005
	,5.028305104e-005
	,5.036679462e-005
	,5.045040027e-005
	,5.053373169e-005
	,5.061691206e-005
	,5.070006646e-005
	,5.078325680e-005
	,5.086650479e-005
	,5.094981762e-005
	,5.103320189e-005
	,5.111667130e-005
	,5.120024809e-005
	,5.128394433e-005
	,5.136774889e-005
	,5.145164725e-005
	,5.153563255e-005
	,5.161970533e-005
	,5.170387230e-005
	,5.178813348e-005
	,5.187249204e-005
	,5.195696972e-005
	,-5.274676585e-004
	,-5.106331398e-004
	,-4.938323984e-004
	,-4.770283347e-004
	,-4.601359607e-004
	,-4.430751381e-004
	,-4.258427856e-004
	,-4.085873355e-004
	,-3.915233050e-004
	,-3.747767624e-004
	,-3.583924005e-004
	,-3.423749716e-004
	,-3.267090531e-004
	,-3.113652687e-004
	,-2.962990683e-004
	,-2.814439551e-004
	,-2.667080264e-004
	,-2.520079039e-004
	,-2.373184374e-004
	,-2.226742667e-004
	,-2.081323861e-004
	,-1.937329339e-004
	,-1.795466757e-004
	,-1.656845092e-004
	,-1.522128682e-004
	,-1.391506081e-004
	,-1.264994423e-004
	,-1.142801587e-004
	,-1.025217217e-004
	,-9.123501547e-005
	,-8.042175862e-005
	,-7.008342368e-005
	,-6.022395127e-005
	,-5.085077569e-005
	,-4.197562212e-005
	,-3.361225824e-005
	,-2.577239333e-005
	,-1.846626886e-005
	,-1.171778351e-005
	,-5.559397717e-006
	,-2.612515999e-019
	,4.971057651e-006
	,9.374855186e-006
	,1.324005193e-005
	,1.660198748e-005
	,1.950180831e-005
	,2.198508004e-005
	,2.409984300e-005
	,2.589419829e-005
	,2.741292733e-005
	,2.869339070e-005
	,2.977407370e-005
	,3.068252089e-005
	,3.145984447e-005
	,3.213691032e-005
	,3.273387646e-005
	,3.326915312e-005
	,3.375583240e-005
	,3.420320835e-005
	,3.461809691e-005
	,3.500548188e-005
	,3.536895635e-005
	,3.571108929e-005
	,3.603375678e-005
	,3.633844301e-005
	,3.662649044e-005
	,3.689926702e-005
	,3.715822919e-005
	,3.740488396e-005
	,3.764063727e-005
	,3.786601257e-005
	,3.807767070e-005
	,3.827993575e-005
	,3.847738709e-005
	,3.867103696e-005
	,3.886142851e-005
	,3.904896326e-005
	,3.923395726e-005
	,3.941666281e-005
	,3.959728174e-005
	,3.977597471e-005
	,3.995287060e-005
	,4.012807196e-005
	,4.030165877e-005
	,4.047369272e-005
	,4.064422038e-005
	,4.081327571e-005
	,4.098088207e-005
	,4.114705393e-005
	,4.131179829e-005
	,4.147511598e-005
	,4.163700272e-005
	,4.179745026e-005
	,4.195644729e-005
	,4.211398046e-005
	,4.227003530e-005
	,4.242459714e-005
	,4.257765203e-005
	,4.272918762e-005
	,4.287919390e-005
	,4.302766383e-005
	,4.317459368e-005
	,4.331998299e-005
	,4.346383413e-005
	,4.360615114e-005
	,4.374693763e-005
	,4.388619286e-005
	,4.402390467e-005
	,4.416003626e-005
	,4.429450284e-005
	,4.442713703e-005
	,4.455764323e-005
	,4.468552742e-005
	,4.481044480e-005
	,4.493296343e-005
	,4.505383695e-005
	,4.517346693e-005
	,4.529204904e-005
	,4.540969292e-005
	,4.552646923e-005
	,4.564242810e-005
	,4.575760739e-005
	,4.587203689e-005
	,4.598574071e-005
	,4.609873886e-005
	,4.621104844e-005
	,4.632268448e-005
	,4.643366057e-005
	,4.654398934e-005
	,4.665368295e-005
	,4.676275340e-005
	,4.687121301e-005
	,4.697907483e-005
	,4.708635300e-005
	,4.719306324e-005
	,4.729922319e-005
	,4.740485287e-005
	,4.750997507e-005
	,4.761461564e-005
	,4.771880363e-005
	,4.782257065e-005
	,4.792594860e-005
	,4.802896200e-005
	,4.813160291e-005
	,4.823373468e-005
	,4.833465851e-005
	,4.843215855e-005
	,4.852614858e-005
	,4.861924122e-005
	,4.871220283e-005
	,4.880505007e-005
	,4.889766406e-005
	,4.898999059e-005
	,4.908210902e-005
	,4.917407038e-005
	,4.926585250e-005
	,4.935738025e-005
	,4.944843817e-005
	,4.953860233e-005
	,4.962809613e-005
	,4.971729909e-005
	,4.980631403e-005
	,4.989516655e-005
	,4.998386253e-005
	,5.007239899e-005
	,5.016077043e-005
	,5.024898837e-005
	,5.033707828e-005
	,5.042505711e-005
	,5.051293326e-005
	,5.060071174e-005
	,5.068839632e-005
	,5.077598991e-005
	,5.086349405e-005
	,5.095090703e-005
	,5.103821880e-005
	,5.112539860e-005
	,5.121238158e-005
	,5.129912982e-005
	,5.138573276e-005
	,5.147229778e-005
	,5.155887397e-005
	,5.164547856e-005
	,5.173211743e-005
	,5.181879202e-005
	,5.190550017e-005
	,5.199223304e-005
	,5.207896685e-005
	,5.216565021e-005
	,5.225221095e-005
	,5.233861659e-005
	,5.242490309e-005
	,5.251112091e-005
	,5.259729947e-005
	,5.268342515e-005
	,5.276948879e-005
	,5.285559577e-005
	,5.294177151e-005
	,5.302801966e-005
	,5.311434786e-005
	,5.320076660e-005
	,-5.364862366e-004
	,-5.193172851e-004
	,-5.020809887e-004
	,-4.847449010e-004
	,-4.673025915e-004
	,-4.497548233e-004
	,-4.321600320e-004
	,-4.146957296e-004
	,-3.975274609e-004
	,-3.807281208e-004
	,-3.643131299e-004
	,-3.482699252e-004
	,-3.325677834e-004
	,-3.171561714e-004
	,-3.019550475e-004
	,-2.868458225e-004
	,-2.717028764e-004
	,-2.564942393e-004
	,-2.412978957e-004
	,-2.262024112e-004
	,-2.112502705e-004
	,-1.964905987e-004
	,-1.820332827e-004
	,-1.679600634e-004
	,-1.542984943e-004
	,-1.410485313e-004
	,-1.282180782e-004
	,-1.158388089e-004
	,-1.039303720e-004
	,-9.249688946e-005
	,-8.153928314e-005
	,-7.106007626e-005
	,-6.106410262e-005
	,-5.155878915e-005
	,-4.255473703e-005
	,-3.406288818e-005
	,-2.609256449e-005
	,-1.867061811e-005
	,-1.183851934e-005
	,-5.615402682e-006
	,-1.932175423e-018
	,5.020377666e-006
	,9.466489283e-006
	,1.336643439e-005
	,1.675536212e-005
	,1.967472811e-005
	,2.217082461e-005
	,2.429258826e-005
	,2.608852910e-005
	,2.760148958e-005
	,2.886911399e-005
	,2.992721950e-005
	,3.082611401e-005
	,3.160243792e-005
	,3.227884994e-005
	,3.287709087e-005
	,3.341455746e-005
	,3.390352408e-005
	,3.435300759e-005
	,3.476967881e-005
	,3.515841393e-005
	,3.552272734e-005
	,3.586515560e-005
	,3.618761309e-005
	,3.649170789e-005
	,3.677898238e-005
	,3.705104061e-005
	,3.730954456e-005
	,3.755602700e-005
	,3.779045959e-005
	,3.800939690e-005
	,3.822006662e-005
	,3.842592116e-005
	,3.862789180e-005
	,3.882657694e-005
	,3.902243698e-005
	,3.921583741e-005
	,3.940706946e-005
	,3.959636417e-005
	,3.978390304e-005
	,3.996982659e-005
	,4.015424172e-005
	,4.033722861e-005
	,4.051884796e-005
	,4.069914792e-005
	,4.087816959e-005
	,4.105594971e-005
	,4.123252081e-005
	,4.140791009e-005
	,4.158213821e-005
	,4.175521831e-005
	,4.192715754e-005
	,4.209795828e-005
	,4.226761658e-005
	,4.243612353e-005
	,4.260346609e-005
	,4.276962780e-005
	,4.293458937e-005
	,4.309832937e-005
	,4.326082474e-005
	,4.342205141e-005
	,4.358198485e-005
	,4.374060050e-005
	,4.389787418e-005
	,4.405378225e-005
	,4.420830153e-005
	,4.436140868e-005
	,4.451307880e-005
	,4.466328259e-005
	,4.481198125e-005
	,4.495911810e-005
	,4.510460850e-005
	,4.524834097e-005
	,4.539022519e-005
	,4.553029319e-005
	,4.566873116e-005
	,4.580577207e-005
	,4.594159558e-005
	,4.607630981e-005
	,4.620996521e-005
	,4.634255965e-005
	,4.647401387e-005
	,4.660407728e-005
	,4.673212939e-005
	,4.685742654e-005
	,4.698029114e-005
	,4.710159630e-005
	,4.722183303e-005
	,4.734121490e-005
	,4.745984483e-005
	,4.757778058e-005
	,4.769505885e-005
	,4.781170519e-005
	,4.792773874e-005
	,4.804317473e-005
	,4.815802605e-005
	,4.827230435e-005
	,4.838602078e-005
	,4.849918675e-005
	,4.861181442e-005
	,4.872391721e-005
	,4.883551026e-005
	,4.894661073e-005
	,4.905723819e-005
	,4.916741490e-005
	,4.927716602e-005
	,4.938651949e-005
	,4.949550493e-005
	,4.960415041e-005
	,4.971247247e-005
	,4.982044540e-005
	,4.992788869e-005
	,5.003398183e-005
	,5.013614711e-005
	,5.023398273e-005
	,5.033058144e-005
	,5.042687563e-005
	,5.052290337e-005
	,5.061879460e-005
	,5.071467964e-005
	,5.081056543e-005
	,5.090640481e-005
	,5.100214364e-005
	,5.109773454e-005
	,5.119313895e-005
	,5.128832547e-005
	,5.138326605e-005
	,5.147792703e-005
	,5.157223612e-005
	,5.166593530e-005
	,5.175856698e-005
	,5.185048239e-005
	,5.194209592e-005
	,5.203351902e-005
	,5.212478834e-005
	,5.221592044e-005
	,5.230692405e-005
	,5.239780443e-005
	,5.248856481e-005
	,5.257920859e-005
	,5.266974264e-005
	,5.276016557e-005
	,5.285044591e-005
	,5.294050369e-005
	,5.303026423e-005
	,5.311980719e-005
	,5.320927729e-005
	,5.329874984e-005
	,5.338825019e-005
	,5.347778500e-005
	,5.356735478e-005
	,5.365695803e-005
	,5.374659287e-005
	,5.383624973e-005
	,5.392589375e-005
	,5.401546416e-005
	,5.410491426e-005
	,5.419425757e-005
	,5.428353912e-005
	,5.437279552e-005
	,5.446204954e-005
	,-1.349122623e-006
	,-1.072610115e-006
	,-8.519390348e-007
	,-6.760678068e-007
	,-5.350702132e-007
	,-4.217799782e-007
	,-3.308603919e-007
	,-2.581501545e-007
	,-2.005159487e-007
	,-1.554058635e-007
	,-1.204464297e-007
	,-9.345975827e-008
	,-7.259866575e-008
	,-5.639143149e-008
	,-4.373491003e-008
	,-3.383743872e-008
	,-2.611391634e-008
	,-2.009295782e-008
	,-1.540613890e-008
	,-1.176603611e-008
	,-8.949561538e-009
	,-6.787831395e-009
	,-5.142502677e-009
	,-3.896375838e-009
	,-2.953889803e-009
	,-2.240386454e-009
	,-1.699036081e-009
	,-1.287184954e-009
	,-9.731381435e-010
	,-7.337427031e-010
	,-5.515920506e-010
	,-4.130675996e-010
	,-3.076834386e-010
	,-2.274304234e-010
	,-1.661233155e-010
	,-1.190223256e-010
	,-8.257403495e-011
	,-5.417753063e-011
	,-3.189550005e-011
	,-1.422340596e-011
	,1.691793398e-017
	,1.165918605e-011
	,2.144904560e-011
	,2.993851517e-011
	,3.758982814e-011
	,4.476635333e-011
	,5.174449046e-011
	,5.873040423e-011
	,6.588919956e-011
	,7.337544046e-011
	,8.133337897e-011
	,8.989450276e-011
	,9.918984128e-011
	,1.093549800e-010
	,1.205305205e-010
	,1.328653727e-010
	,1.465195410e-010
	,1.616632382e-010
	,1.784699610e-010
	,1.970992769e-010
	,2.176746171e-010
	,2.402958335e-010
	,2.651432581e-010
	,2.925418630e-010
	,3.229221266e-010
	,3.568589660e-010
	,3.949930961e-010
	,4.380443218e-010
	,4.868032172e-010
	,5.420153764e-010
	,6.046688150e-010
	,6.764370447e-010
	,7.596040380e-010
	,8.578467816e-010
	,9.757654705e-010
	,1.119840126e-009
	,1.298015972e-009
	,1.519072063e-009
	,1.796404191e-009
	,2.146078419e-009
	,2.587911436e-009
	,3.147790956e-009
	,3.859051584e-009
	,4.763928879e-009
	,5.916157524e-009
	,7.384386041e-009
	,9.244803224e-009
	,1.160826337e-008
	,1.461556983e-008
	,1.844145083e-008
	,2.326719411e-008
	,2.937062902e-008
	,3.711706083e-008
	,4.695316979e-008
	,5.944977971e-008
	,7.533112763e-008
	,9.546648554e-008
	,1.200619010e-007
	,1.496859604e-007
	,1.863265510e-007
	,2.295019223e-007
	,2.819331155e-007
	,3.465616851e-007
	,4.262349622e-007
	,5.244233940e-007
	,6.453768979e-007
	,7.943059928e-007
	,9.776011202e-007
	,1.203100686e-006
	,1.480414824e-006
	,1.821285890e-006
	,2.230957439e-006
	,2.720785205e-006
	,3.314824454e-006
	,4.034299617e-006
	,4.903853428e-006
	,5.953143614e-006
	,7.215689976e-006
	,8.588023759e-006
	,1.012928143e-005
	,1.178287875e-005
	,1.363114203e-005
	,1.576223161e-005
	,1.821084274e-005
	,2.101401963e-005
	,2.421230541e-005
	,2.785034021e-005
	,3.197731399e-005
	,3.664715303e-005
	,4.191760890e-005
	,4.778799799e-005
	,5.420735469e-005
	,6.125888198e-005
	,6.898705314e-005
	,7.749072111e-005
	,8.679939465e-005
	,9.691319951e-005
	,1.070951318e-004
	,1.179190956e-004
	,1.286361861e-004
	,1.390076786e-004
	,1.501819925e-004
	,1.621998227e-004
	,1.750308745e-004
	,1.886239970e-004
	,2.029176893e-004
	,2.177934372e-004
	,2.331903145e-004
	,2.490540552e-004
	,2.653043715e-004
	,2.818604778e-004
	,2.986428413e-004
	,3.155758256e-004
	,3.325882784e-004
	,3.491203974e-004
	,3.655419754e-004
	,3.818047368e-004
	,3.978875049e-004
	,4.137584370e-004
	,4.293991453e-004
	,4.448060973e-004
	,4.599933569e-004
	,4.749949851e-004
	,4.897192759e-004
	,5.043015400e-004
	,5.179021783e-004
	,5.311652217e-004
	,5.444448940e-004
	,5.577622436e-004
	,5.711507566e-004
	,5.846545512e-004
	,5.982459403e-004
	,6.120264586e-004
	,6.260758273e-004
	,6.404404050e-004
	,6.551648715e-004
	,6.702909614e-004
	,6.854789730e-004
	,6.999472958e-004
	,7.149866722e-004
	,7.305878556e-004
	,7.466610296e-004
	,7.632550860e-004
	,7.804689445e-004
	,7.982493133e-004
	,8.143308024e-004
	,8.310248072e-004
	,8.482540833e-004
	,8.659515423e-004
	,8.840515559e-004
	,9.026875615e-004
	,9.219105880e-004
	,9.418132028e-004
	,9.612138581e-004
	,9.790944524e-004
	,9.979421815e-004
	,1.017613085e-003
	,1.038091606e-003
	,1.059198398e-003
	,1.081265827e-003
	,1.104276555e-003
	,-3.814564101e-006
	,-3.070564403e-006
	,-2.467109902e-006
	,-1.976074794e-006
	,-1.574070539e-006
	,-1.245564936e-006
	,-9.798022339e-007
	,-7.673247246e-007
	,-5.998673648e-007
	,-4.690382491e-007
	,-3.669084601e-007
	,-2.868393011e-007
	,-2.236822634e-007
	,-1.738080113e-007
	,-1.345246663e-007
	,-1.036279544e-007
	,-7.943055949e-008
	,-6.070569638e-008
	,-4.637246259e-008
	,-3.544941213e-008
	,-2.713109238e-008
	,-2.079056210e-008
	,-1.594687724e-008
	,-1.223360951e-008
	,-9.374560493e-009
	,-7.168611239e-009
	,-5.470608926e-009
	,-4.167125575e-009
	,-3.165688999e-009
	,-2.393795140e-009
	,-1.797830960e-009
	,-1.338942970e-009
	,-9.881613731e-010
	,-7.219414838e-010
	,-5.207074669e-010
	,-3.686501767e-010
	,-2.533161953e-010
	,-1.651365692e-010
	,-9.689412714e-011
	,-4.319079858e-011
	,1.310613900e-017
	,3.566787715e-011
	,6.602013002e-011
	,9.272512990e-011
	,1.171082571e-010
	,1.402306034e-010
	,1.629243792e-010
	,1.858497942e-010
	,2.095648741e-010
	,2.345483858e-010
	,2.611913888e-010
	,2.897827063e-010
	,3.204854660e-010
	,3.533951657e-010
	,3.887254057e-010
	,4.268447406e-010
	,4.680960164e-010
	,5.126309777e-010
	,5.603092490e-010
	,6.107472454e-010
	,6.637167049e-010
	,7.196472791e-010
	,7.794899054e-010
	,8.442785284e-010
	,9.149240127e-010
	,9.922052172e-010
	,1.076798365e-009
	,1.169343620e-009
	,1.270638000e-009
	,1.381810226e-009
	,1.504248638e-009
	,1.639525868e-009
	,1.789466522e-009
	,1.956249554e-009
	,2.142512252e-009
	,2.351462149e-009
	,2.587436686e-009
	,2.856244477e-009
	,3.165322426e-009
	,3.524338431e-009
	,3.945801888e-009
	,4.443210393e-009
	,5.039975626e-009
	,5.764212880e-009
	,6.652044244e-009
	,7.735849243e-009
	,9.079051870e-009
	,1.076090869e-008
	,1.287675570e-008
	,1.554773934e-008
	,1.893383707e-008
	,2.323492788e-008
	,2.861291733e-008
	,3.538066574e-008
	,4.382231570e-008
	,5.427427276e-008
	,6.721482383e-008
	,8.283024830e-008
	,1.022791195e-007
	,1.265707813e-007
	,1.569322304e-007
	,1.948753809e-007
	,2.422766171e-007
	,3.014686214e-007
	,3.753547171e-007
	,4.675471724e-007
	,5.825401836e-007
	,7.259192521e-007
	,9.045984702e-007
	,1.123995477e-006
	,1.390608425e-006
	,1.718261428e-006
	,2.121288782e-006
	,2.616370747e-006
	,3.223535833e-006
	,3.966377459e-006
	,4.852243563e-006
	,5.820676654e-006
	,6.950652150e-006
	,8.164768267e-006
	,9.583798005e-006
	,1.123935553e-005
	,1.316401116e-005
	,1.539299825e-005
	,1.796490819e-005
	,2.092210571e-005
	,2.431106929e-005
	,2.818251746e-005
	,3.259051145e-005
	,3.754008114e-005
	,4.300952547e-005
	,4.901513206e-005
	,5.569513372e-005
	,6.309475100e-005
	,7.124592012e-005
	,8.015161817e-005
	,8.921988963e-005
	,9.867817182e-005
	,1.079842060e-004
	,1.173843685e-004
	,1.275497901e-004
	,1.385120422e-004
	,1.502544312e-004
	,1.627442120e-004
	,1.759386438e-004
	,1.897858887e-004
	,2.042264711e-004
	,2.191945528e-004
	,2.345818283e-004
	,2.502249529e-004
	,2.661647353e-004
	,2.823293626e-004
	,2.986513026e-004
	,3.147483321e-004
	,3.307382430e-004
	,3.466647736e-004
	,3.624824385e-004
	,3.781508707e-004
	,3.936389453e-004
	,4.089284697e-004
	,4.240167387e-004
	,4.389198598e-004
	,4.536598249e-004
	,4.681137166e-004
	,4.814218965e-004
	,4.946579756e-004
	,5.078421340e-004
	,5.209960945e-004
	,5.341514489e-004
	,5.473388708e-004
	,5.605992719e-004
	,5.739912931e-004
	,5.875673764e-004
	,6.013848554e-004
	,6.155038061e-004
	,6.291011075e-004
	,6.426074257e-004
	,6.565998600e-004
	,6.710603729e-004
	,6.859831194e-004
	,7.013825413e-004
	,7.172079229e-004
	,7.335046115e-004
	,7.503779008e-004
	,7.677695096e-004
	,7.839112305e-004
	,8.006696638e-004
	,8.179353816e-004
	,8.354330754e-004
	,8.533479095e-004
	,8.716163422e-004
	,8.904586141e-004
	,9.100161074e-004
	,9.272990060e-004
	,9.452427925e-004
	,9.639295985e-004
	,9.832987527e-004
	,1.002525479e-003
	,1.022618775e-003
	,1.043623121e-003
	,1.065642862e-003
	,-1.015427783e-005
	,-8.320624188e-006
	,-6.773906714e-006
	,-5.494915994e-006
	,-4.449478789e-006
	,-3.590744761e-006
	,-2.877031132e-006
	,-2.290090260e-006
	,-1.816146962e-006
	,-1.435135836e-006
	,-1.127886795e-006
	,-8.818639017e-007
	,-6.876788461e-007
	,-5.355048302e-007
	,-4.158745070e-007
	,-3.216658467e-007
	,-2.482289465e-007
	,-1.915257991e-007
	,-1.478733787e-007
	,-1.142180322e-007
	,-8.814939182e-008
	,-6.786337031e-008
	,-5.209781172e-008
	,-3.990889039e-008
	,-3.049006943e-008
	,-2.318582397e-008
	,-1.752766337e-008
	,-1.318725379e-008
	,-9.895559113e-009
	,-7.415520160e-009
	,-5.550360229e-009
	,-4.146070433e-009
	,-3.085835320e-009
	,-2.282135358e-009
	,-1.669607614e-009
	,-1.199455078e-009
	,-8.353672148e-010
	,-5.507049341e-010
	,-3.260154409e-010
	,-1.463889059e-010
	,3.653448477e-019
	,1.223666586e-010
	,2.276814490e-010
	,3.210203681e-010
	,4.059552764e-010
	,4.850053425e-010
	,5.602828813e-010
	,6.337929007e-010
	,7.071216916e-010
	,7.813427595e-010
	,8.574247314e-010
	,9.366422790e-010
	,1.020457087e-009
	,1.110251797e-009
	,1.207261301e-009
	,1.312610055e-009
	,1.427346565e-009
	,1.552433735e-009
	,1.688700219e-009
	,1.836840878e-009
	,1.997691030e-009
	,2.172600457e-009
	,2.363314498e-009
	,2.571658840e-009
	,2.799433837e-009
	,3.048526021e-009
	,3.321142598e-009
	,3.619863899e-009
	,3.947538744e-009
	,4.307218172e-009
	,4.702093820e-009
	,5.135342293e-009
	,5.609794458e-009
	,6.127460627e-009
	,6.689506666e-009
	,7.297638141e-009
	,7.956030594e-009
	,8.670746488e-009
	,9.448427569e-009
	,1.029631502e-008
	,1.122273945e-008
	,1.223665300e-008
	,1.334653723e-008
	,1.455915791e-008
	,1.587974494e-008
	,1.731489895e-008
	,1.888614762e-008
	,2.062203962e-008
	,2.257974618e-008
	,2.483623799e-008
	,2.748416971e-008
	,3.063940100e-008
	,3.441307726e-008
	,3.898695189e-008
	,4.460648121e-008
	,5.157194653e-008
	,6.022079588e-008
	,7.101310125e-008
	,8.456054756e-008
	,1.016077108e-007
	,1.230539474e-007
	,1.500702157e-007
	,1.841672654e-007
	,2.272166463e-007
	,2.815697371e-007
	,3.495956549e-007
	,4.351046574e-007
	,5.422592469e-007
	,6.750764294e-007
	,8.411576293e-007
	,1.048801599e-006
	,1.308221761e-006
	,1.631860598e-006
	,2.034315087e-006
	,2.515713679e-006
	,3.069351502e-006
	,3.727162801e-006
	,4.459328997e-006
	,5.329446147e-006
	,6.363377070e-006
	,7.588234047e-006
	,9.033710056e-006
	,1.073268201e-005
	,1.272152731e-005
	,1.504036995e-005
	,1.773325351e-005
	,2.084797349e-005
	,2.443440615e-005
	,2.847544313e-005
	,3.296765293e-005
	,3.800851005e-005
	,4.366528265e-005
	,4.998144776e-005
	,5.698572789e-005
	,6.458780293e-005
	,7.242987978e-005
	,8.047047984e-005
	,8.835869369e-005
	,9.678308415e-005
	,1.059257852e-004
	,1.158007533e-004
	,1.264051709e-004
	,1.377203389e-004
	,1.496825597e-004
	,1.622939649e-004
	,1.755113144e-004
	,1.892837596e-004
	,2.035540424e-004
	,2.182602288e-004
	,2.333371830e-004
	,2.487179891e-004
	,2.642799126e-004
	,2.797251884e-004
	,2.951054838e-004
	,3.104996466e-004
	,3.258616786e-004
	,3.411471974e-004
	,3.563179969e-004
	,3.713456698e-004
	,3.862149270e-004
	,4.009271891e-004
	,4.155031874e-004
	,4.295607920e-004
	,4.428625897e-004
	,4.560535442e-004
	,4.691534108e-004
	,4.821860875e-004
	,4.951837816e-004
	,5.081858251e-004
	,5.212372300e-004
	,5.343871979e-004
	,5.476863631e-004
	,5.606810255e-004
	,5.732554685e-004
	,5.861587515e-004
	,5.993852671e-004
	,6.129315275e-004
	,6.268101861e-004
	,6.410476064e-004
	,6.556802220e-004
	,6.706972078e-004
	,6.861387768e-004
	,7.020412954e-004
	,7.185160722e-004
	,7.353087736e-004
	,7.512216008e-004
	,7.676946613e-004
	,7.846329819e-004
	,8.020316512e-004
	,8.199196767e-004
	,8.383589518e-004
	,8.571877861e-004
	,8.743587624e-004
	,8.906215509e-004
	,9.077269924e-004
	,9.255102577e-004
	,9.439417844e-004
	,9.630359443e-004
	,9.828288858e-004
	,1.003376275e-003
	,1.024786231e-003
	,-2.436011689e-005
	,-2.054472900e-005
	,-1.723852650e-005
	,-1.441927785e-005
	,-1.200553753e-005
	,-9.916133675e-006
	,-8.105051209e-006
	,-6.551590252e-006
	,-5.249398908e-006
	,-4.188216932e-006
	,-3.339153458e-006
	,-2.663832365e-006
	,-2.124294040e-006
	,-1.687224441e-006
	,-1.330923907e-006
	,-1.043455799e-006
	,-8.144435791e-007
	,-6.331358885e-007
	,-4.895453144e-007
	,-3.765294819e-007
	,-2.886832814e-007
	,-2.211008398e-007
	,-1.693661136e-007
	,-1.297183012e-007
	,-9.917273856e-008
	,-7.558118219e-008
	,-5.745992204e-008
	,-4.363666651e-008
	,-3.312488558e-008
	,-2.513096177e-008
	,-1.903574899e-008
	,-1.436740051e-008
	,-1.077612284e-008
	,-8.010029967e-009
	,-5.878726823e-009
	,-4.230708297e-009
	,-2.947073212e-009
	,-1.938176241e-009
	,-1.139860225e-009
	,-5.060140643e-010
	,1.514257741e-017
	,4.100353186e-010
	,7.513674428e-010
	,1.045966494e-009
	,1.310856066e-009
	,1.559082250e-009
	,1.800683937e-009
	,2.043447691e-009
	,2.293433186e-009
	,2.555340060e-009
	,2.832774299e-009
	,3.128419216e-009
	,3.444594182e-009
	,3.784574128e-009
	,4.152796482e-009
	,4.553746737e-009
	,4.991459190e-009
	,5.469515613e-009
	,5.991028508e-009
	,6.558926617e-009
	,7.176192672e-009
	,7.845171220e-009
	,8.566515667e-009
	,9.339647931e-009
	,1.016596680e-008
	,1.105077306e-008
	,1.200042525e-008
	,1.301854863e-008
	,1.410335619e-008
	,1.524591931e-008
	,1.643251233e-008
	,1.765515396e-008
	,1.892207528e-008
	,2.025389141e-008
	,2.167313253e-008
	,2.319931203e-008
	,2.484884274e-008
	,2.663607431e-008
	,2.857397863e-008
	,3.067431710e-008
	,3.294788768e-008
	,3.540642409e-008
	,3.806607801e-008
	,4.094825487e-008
	,4.407763727e-008
	,4.748122949e-008
	,5.118927019e-008
	,5.523647171e-008
	,5.966234318e-008
	,6.451178571e-008
	,6.983692344e-008
	,7.570048511e-008
	,8.217959027e-008
	,8.938459772e-008
	,9.745585270e-008
	,1.065732413e-007
	,1.169665223e-007
	,1.289324391e-007
	,1.428401852e-007
	,1.591344410e-007
	,1.785080117e-007
	,2.017847940e-007
	,2.299713567e-007
	,2.644281572e-007
	,3.067552513e-007
	,3.594202240e-007
	,4.252681444e-007
	,5.078091587e-007
	,6.108146891e-007
	,7.384283483e-007
	,8.951086443e-007
	,1.083843332e-006
	,1.313127597e-006
	,1.584578022e-006
	,1.907864058e-006
	,2.301333531e-006
	,2.780706213e-006
	,3.363513391e-006
	,4.069775968e-006
	,4.922448636e-006
	,5.947740266e-006
	,7.175376016e-006
	,8.638812257e-006
	,1.037522907e-005
	,1.242546134e-005
	,1.483295932e-005
	,1.760947143e-005
	,2.075520072e-005
	,2.435104553e-005
	,2.845318971e-005
	,3.310680500e-005
	,3.834806234e-005
	,4.418783008e-005
	,5.032435363e-005
	,5.666484900e-005
	,6.312154178e-005
	,6.991173463e-005
	,7.731540913e-005
	,8.535907467e-005
	,9.405002692e-005
	,1.034087216e-004
	,1.134302831e-004
	,1.241024065e-004
	,1.354048865e-004
	,1.473095291e-004
	,1.597801661e-004
	,1.727732811e-004
	,1.862392711e-004
	,2.001238006e-004
	,2.143687628e-004
	,2.289140725e-004
	,2.435815922e-004
	,2.582771639e-004
	,2.730725406e-004
	,2.878049985e-004
	,3.024769867e-004
	,3.171103019e-004
	,3.316707067e-004
	,3.461345501e-004
	,3.604925645e-004
	,3.747521555e-004
	,3.883085747e-004
	,4.015288096e-004
	,4.146182866e-004
	,4.276080171e-004
	,4.405235496e-004
	,4.533990304e-004
	,4.662763599e-004
	,4.792034554e-004
	,4.916829279e-004
	,5.038380418e-004
	,5.162059311e-004
	,5.287787485e-004
	,5.415539536e-004
	,5.545398138e-004
	,5.677523304e-004
	,5.812122237e-004
	,5.949320732e-004
	,6.089395071e-004
	,6.232715964e-004
	,6.379654598e-004
	,6.530350843e-004
	,6.685012424e-004
	,6.845027744e-004
	,7.007353530e-004
	,7.162497453e-004
	,7.317626838e-004
	,7.477945701e-004
	,7.643294916e-004
	,7.813905373e-004
	,7.990586048e-004
	,8.165563508e-004
	,8.329047271e-004
	,8.498709332e-004
	,8.673716321e-004
	,8.851316899e-004
	,9.033039043e-004
	,9.220288405e-004
	,9.413503035e-004
	,9.613211290e-004
	,9.820143619e-004
	,-5.182105081e-005
	,-4.525406901e-005
	,-3.923900795e-005
	,-3.380001487e-005
	,-2.892421130e-005
	,-2.458879197e-005
	,-2.076328521e-005
	,-1.738701782e-005
	,-1.441496800e-005
	,-1.186239753e-005
	,-9.724848510e-006
	,-7.950268289e-006
	,-6.467284559e-006
	,-5.219399464e-006
	,-4.179156175e-006
	,-3.318528406e-006
	,-2.609976437e-006
	,-2.039749413e-006
	,-1.590862313e-006
	,-1.240123920e-006
	,-9.670469153e-007
	,-7.540613529e-007
	,-5.869198944e-007
	,-4.555867558e-007
	,-3.529652110e-007
	,-2.727977370e-007
	,-2.098797043e-007
	,-1.603712567e-007
	,-1.215834320e-007
	,-9.156845456e-008
	,-6.857110560e-008
	,-5.107244798e-008
	,-3.783331773e-008
	,-2.783290143e-008
	,-2.025165742e-008
	,-1.446195377e-008
	,-1.001218218e-008
	,-6.569721099e-009
	,-3.877027052e-009
	,-1.736965623e-009
	,1.247954256e-017
	,1.447489182e-009
	,2.692818639e-009
	,3.802277762e-009
	,4.824597655e-009
	,5.796113448e-009
	,6.748517232e-009
	,7.711122619e-009
	,8.708525268e-009
	,9.758898140e-009
	,1.087193064e-008
	,1.204517001e-008
	,1.326329001e-008
	,1.451104745e-008
	,1.579013931e-008
	,1.711413282e-008
	,1.849652153e-008
	,1.995043920e-008
	,2.149406448e-008
	,2.315014968e-008
	,2.494047963e-008
	,2.688303754e-008
	,2.899237372e-008
	,3.128151766e-008
	,3.376451926e-008
	,3.645738219e-008
	,3.937658284e-008
	,4.253716076e-008
	,4.594921839e-008
	,4.961773262e-008
	,5.355050537e-008
	,5.776720912e-008
	,6.229821655e-008
	,6.717802493e-008
	,7.244099308e-008
	,7.812050425e-008
	,8.425168280e-008
	,9.087546398e-008
	,9.803936091e-008
	,1.057954539e-007
	,1.141984114e-007
	,1.233035561e-007
	,1.331637833e-007
	,1.438240552e-007
	,1.553139447e-007
	,1.676457664e-007
	,1.808336222e-007
	,1.949269746e-007
	,2.100156460e-007
	,2.262028548e-007
	,2.435823242e-007
	,2.622308356e-007
	,2.822107974e-007
	,3.035773784e-007
	,3.263740360e-007
	,3.506083615e-007
	,3.762260923e-007
	,4.031354314e-007
	,4.312942049e-007
	,4.608600809e-007
	,4.921723615e-007
	,5.256651910e-007
	,5.620048145e-007
	,6.019791784e-007
	,6.464843498e-007
	,6.967721979e-007
	,7.543573979e-007
	,8.211271496e-007
	,8.996067011e-007
	,9.930092014e-007
	,1.104324770e-006
	,1.239029671e-006
	,1.403456636e-006
	,1.605262609e-006
	,1.853764795e-006
	,2.158267789e-006
	,2.532972532e-006
	,2.993987791e-006
	,3.560075673e-006
	,4.253207716e-006
	,5.097716404e-006
	,6.121521515e-006
	,7.354147742e-006
	,8.821373544e-006
	,1.054014742e-005
	,1.256379144e-005
	,1.493617818e-005
	,1.770009980e-005
	,2.089252685e-005
	,2.454143628e-005
	,2.860949122e-005
	,3.286876633e-005
	,3.745705973e-005
	,4.220192868e-005
	,4.738555043e-005
	,5.308596254e-005
	,5.934622721e-005
	,6.618677744e-005
	,7.362128038e-005
	,8.165763351e-005
	,9.029920432e-005
	,9.954369742e-005
	,1.093822016e-004
	,1.197991549e-004
	,1.307720173e-004
	,1.422712327e-004
	,1.542607168e-004
	,1.666983708e-004
	,1.795367250e-004
	,1.927241063e-004
	,2.061267768e-004
	,2.196795064e-004
	,2.334114758e-004
	,2.472820720e-004
	,2.612477606e-004
	,2.752659458e-004
	,2.892986993e-004
	,3.031557849e-004
	,3.169161057e-004
	,3.304177949e-004
	,3.435299918e-004
	,3.565333693e-004
	,3.694055166e-004
	,3.822111919e-004
	,3.949786584e-004
	,4.077429380e-004
	,4.197924404e-004
	,4.318251901e-004
	,4.439606987e-004
	,4.561979642e-004
	,4.685419115e-004
	,4.810057316e-004
	,4.936080027e-004
	,5.063707551e-004
	,5.193170285e-004
	,5.324702249e-004
	,5.458534847e-004
	,5.591426984e-004
	,5.725979005e-004
	,5.863837057e-004
	,6.005216349e-004
	,6.150324197e-004
	,6.298669861e-004
	,6.451654032e-004
	,6.605792298e-004
	,6.753413833e-004
	,6.905792208e-004
	,7.062531114e-004
	,7.223954713e-004
	,7.390347010e-004
	,7.560948410e-004
	,7.718778276e-004
	,7.884110884e-004
	,8.052438187e-004
	,8.223102436e-004
	,8.397941580e-004
	,8.577240221e-004
	,8.761373798e-004
	,8.950779407e-004
	,9.142680622e-004
	,9.340606290e-004
	,-9.809115805e-005
	,-8.800242334e-005
	,-7.841323832e-005
	,-6.948045001e-005
	,-6.134065685e-005
	,-5.403949261e-005
	,-4.752451830e-005
	,-4.164900056e-005
	,-3.618408518e-005
	,-3.101590362e-005
	,-2.621549181e-005
	,-2.189350814e-005
	,-1.812254828e-005
	,-1.491919461e-005
	,-1.224736853e-005
	,-1.003123261e-005
	,-8.181405110e-006
	,-6.636453571e-006
	,-5.360502848e-006
	,-4.303954681e-006
	,-3.425061804e-006
	,-2.699879505e-006
	,-2.112590961e-006
	,-1.643325501e-006
	,-1.270364788e-006
	,-9.765049806e-007
	,-7.476606368e-007
	,-5.716636557e-007
	,-4.371416465e-007
	,-3.340989843e-007
	,-2.545848656e-007
	,-1.929238717e-007
	,-1.451321513e-007
	,-1.082254278e-007
	,-7.976732575e-008
	,-5.770806924e-008
	,-4.042561374e-008
	,-2.673165493e-008
	,-1.581548767e-008
	,-7.077292581e-009
	,2.809223704e-017
	,5.854684760e-009
	,1.082256273e-008
	,1.513709534e-008
	,1.897660155e-008
	,2.247954225e-008
	,2.577840815e-008
	,2.900335414e-008
	,3.225907169e-008
	,3.562971157e-008
	,3.917805778e-008
	,4.295533732e-008
	,4.701475954e-008
	,5.141105093e-008
	,5.619509207e-008
	,6.141004026e-008
	,6.708793180e-008
	,7.324744465e-008
	,7.989782151e-008
	,8.706155873e-008
	,9.479945450e-008
	,1.031988182e-007
	,1.123476939e-007
	,1.223238329e-007
	,1.331893846e-007
	,1.449832828e-007
	,1.577152837e-007
	,1.713653137e-007
	,1.858805598e-007
	,2.011909708e-007
	,2.172826967e-007
	,2.342732083e-007
	,2.523819378e-007
	,2.718280721e-007
	,2.927312498e-007
	,3.150490255e-007
	,3.385355161e-007
	,3.627769342e-007
	,3.873859528e-007
	,4.122527087e-007
	,4.375919485e-007
	,4.637700887e-007
	,4.911359003e-007
	,5.199672090e-007
	,5.504918555e-007
	,5.829141723e-007
	,6.174178300e-007
	,6.541564122e-007
	,6.932523736e-007
	,7.348198243e-007
	,7.790062361e-007
	,8.260131025e-007
	,8.760804309e-007
	,9.294715973e-007
	,9.864695151e-007
	,1.047371691e-006
	,1.112491274e-006
	,1.182161581e-006
	,1.256740814e-006
	,1.336616745e-006
	,1.422211759e-006
	,1.513988683e-006
	,1.612450678e-006
	,1.718162104e-006
	,1.831750500e-006
	,1.953921467e-006
	,2.085488543e-006
	,2.227412812e-006
	,2.380896486e-006
	,2.547458236e-006
	,2.729061673e-006
	,2.928161404e-006
	,3.147824978e-006
	,3.391929942e-006
	,3.665380843e-006
	,3.975049399e-006
	,4.329904656e-006
	,4.742773825e-006
	,5.228898480e-006
	,5.806463446e-006
	,6.496673068e-006
	,7.321915384e-006
	,8.305014030e-006
	,9.475165046e-006
	,1.085405891e-005
	,1.244240687e-005
	,1.422818504e-005
	,1.624344635e-005
	,1.846875980e-005
	,2.094139725e-005
	,2.373859413e-005
	,2.691090064e-005
	,3.049372543e-005
	,3.451362535e-005
	,3.899448174e-005
	,4.396052813e-005
	,4.943062083e-005
	,5.542045909e-005
	,6.194222940e-005
	,6.900420654e-005
	,7.661019049e-005
	,8.475777410e-005
	,9.344293543e-005
	,1.026542459e-004
	,1.123743918e-004
	,1.225799024e-004
	,1.332409185e-004
	,1.443210385e-004
	,1.557741614e-004
	,1.674988954e-004
	,1.794993505e-004
	,1.917532636e-004
	,2.042269089e-004
	,2.168834352e-004
	,2.296854519e-004
	,2.425981026e-004
	,2.555928768e-004
	,2.685865243e-004
	,2.813402123e-004
	,2.940518506e-004
	,3.066383063e-004
	,3.190575129e-004
	,3.310795597e-004
	,3.429450145e-004
	,3.548650747e-004
	,3.668467691e-004
	,3.788676464e-004
	,3.904915682e-004
	,4.022252106e-004
	,4.140689939e-004
	,4.260261542e-004
	,4.381045772e-004
	,4.503164834e-004
	,4.626773051e-004
	,4.752021153e-004
	,4.879104916e-004
	,5.008240296e-004
	,5.139625899e-004
	,5.273476037e-004
	,5.410011243e-004
	,5.549474574e-004
	,5.692168431e-004
	,5.838078280e-004
	,5.987811959e-004
	,6.140341608e-004
	,6.287550097e-004
	,6.438995074e-004
	,6.594023533e-004
	,6.753241394e-004
	,6.917645691e-004
	,7.071451262e-004
	,7.230129603e-004
	,7.394143174e-004
	,7.562327556e-004
	,7.729786404e-004
	,7.899397757e-004
	,8.072889284e-004
	,8.250506717e-004
	,8.432560838e-004
	,8.619422339e-004
	,8.811524031e-004
	,-1.624376606e-004
	,-1.495661729e-004
	,-1.372869770e-004
	,-1.255737881e-004
	,-1.144188483e-004
	,-1.038059906e-004
	,-9.375379092e-005
	,-8.429560107e-005
	,-7.546209078e-005
	,-6.728542261e-005
	,-5.973093434e-005
	,-5.266636888e-005
	,-4.597111475e-005
	,-3.966186548e-005
	,-3.389080994e-005
	,-2.875820942e-005
	,-2.421164732e-005
	,-2.017713448e-005
	,-1.665311451e-005
	,-1.365254492e-005
	,-1.114921530e-005
	,-9.066689304e-006
	,-7.317852891e-006
	,-5.865693243e-006
	,-4.681242898e-006
	,-3.717846686e-006
	,-2.936243583e-006
	,-2.309824077e-006
	,-1.807550036e-006
	,-1.400505855e-006
	,-1.072395073e-006
	,-8.131496511e-007
	,-6.101793920e-007
	,-4.517971975e-007
	,-3.294066945e-007
	,-2.353476293e-007
	,-1.628402046e-007
	,-1.067525641e-007
	,-6.299996643e-008
	,-2.826042067e-008
	,-2.198326130e-017
	,2.362762034e-008
	,4.399719206e-008
	,6.222515746e-008
	,7.922840501e-008
	,9.570094411e-008
	,1.120461208e-007
	,1.283825878e-007
	,1.447601308e-007
	,1.613042434e-007
	,1.779429997e-007
	,1.948726324e-007
	,2.128488285e-007
	,2.322353771e-007
	,2.530074623e-007
	,2.749917482e-007
	,2.980426181e-007
	,3.220520891e-007
	,3.469243676e-007
	,3.726403246e-007
	,3.993291391e-007
	,4.272602110e-007
	,4.567969703e-007
	,4.883418655e-007
	,5.222439919e-007
	,5.587758146e-007
	,5.981700717e-007
	,6.406555732e-007
	,6.864529926e-007
	,7.357350620e-007
	,7.885804084e-007
	,8.449597416e-007
	,9.048208807e-007
	,9.682656697e-007
	,1.035635244e-006
	,1.107412232e-006
	,1.184072146e-006
	,1.266016544e-006
	,1.353686201e-006
	,1.447597225e-006
	,1.548212942e-006
	,1.655889828e-006
	,1.770861454e-006
	,1.893305513e-006
	,2.023480482e-006
	,2.161752596e-006
	,2.308447044e-006
	,2.463678801e-006
	,2.627303794e-006
	,2.799071569e-006
	,2.978929516e-006
	,3.167224991e-006
	,3.364630131e-006
	,3.571889481e-006
	,3.789593565e-006
	,4.018071097e-006
	,4.257370461e-006
	,4.507241565e-006
	,4.767015400e-006
	,5.035390180e-006
	,5.310221994e-006
	,5.588605553e-006
	,5.867662261e-006
	,6.145782630e-006
	,6.423203033e-006
	,6.701302060e-006
	,6.981592032e-006
	,7.265448495e-006
	,7.554479319e-006
	,7.850972072e-006
	,8.157578702e-006
	,8.476921403e-006
	,8.811457743e-006
	,9.163506527e-006
	,9.535367056e-006
	,9.929463352e-006
	,1.034851424e-005
	,1.079572290e-005
	,1.127497786e-005
	,1.179115710e-005
	,1.235065039e-005
	,1.296139731e-005
	,1.363403409e-005
	,1.438179087e-005
	,1.522090062e-005
	,1.617069329e-005
	,1.725386808e-005
	,1.849686954e-005
	,1.992624048e-005
	,2.157578276e-005
	,2.348100647e-005
	,2.567714781e-005
	,2.819865814e-005
	,3.107815676e-005
	,3.434212906e-005
	,3.801909394e-005
	,4.213363389e-005
	,4.670489775e-005
	,5.174756649e-005
	,5.727153716e-005
	,6.328035751e-005
	,6.977351159e-005
	,7.674615801e-005
	,8.417933418e-005
	,9.205517902e-005
	,1.003620156e-004
	,1.090749423e-004
	,1.181655633e-004
	,1.276147999e-004
	,1.374042430e-004
	,1.475103962e-004
	,1.579049571e-004
	,1.685559652e-004
	,1.794293724e-004
	,1.904931137e-004
	,2.016353179e-004
	,2.127626532e-004
	,2.236804628e-004
	,2.346257133e-004
	,2.457334373e-004
	,2.570186376e-004
	,2.684649932e-004
	,2.800484994e-004
	,2.917419730e-004
	,3.034314737e-004
	,3.149898559e-004
	,3.266116884e-004
	,3.382940978e-004
	,3.500396628e-004
	,3.618555870e-004
	,3.737528181e-004
	,3.857451948e-004
	,3.978486764e-004
	,4.100806724e-004
	,4.224594461e-004
	,4.350040485e-004
	,4.477337963e-004
	,4.606681898e-004
	,4.738269596e-004
	,4.872301343e-004
	,5.008985438e-004
	,5.148569650e-004
	,5.291365997e-004
	,5.437300451e-004
	,5.587478329e-004
	,5.733398587e-004
	,5.882548265e-004
	,6.035503034e-004
	,6.192689952e-004
	,6.346422996e-004
	,6.498614278e-004
	,6.655302980e-004
	,6.815531541e-004
	,6.979433057e-004
	,7.147105896e-004
	,7.313478831e-004
	,7.482182405e-004
	,7.654990120e-004
	,7.830738080e-004
	,8.008684401e-004
	,8.173775039e-004
	,-2.425020714e-004
	,-2.291071684e-004
	,-2.154646541e-004
	,-2.016841958e-004
	,-1.878976822e-004
	,-1.742273734e-004
	,-1.607968905e-004
	,-1.477602816e-004
	,-1.353295097e-004
	,-1.236362194e-004
	,-1.126982066e-004
	,-1.024329955e-004
	,-9.274078438e-005
	,-8.345454673e-005
	,-7.450011775e-005
	,-6.598662169e-005
	,-5.806580226e-005
	,-5.079938991e-005
	,-4.412163505e-005
	,-3.801682769e-005
	,-3.259389397e-005
	,-2.787055664e-005
	,-2.375871667e-005
	,-2.010094147e-005
	,-1.672039275e-005
	,-1.359195626e-005
	,-1.085216652e-005
	,-8.584952074e-006
	,-6.766070699e-006
	,-5.323701747e-006
	,-4.185720086e-006
	,-3.291296396e-006
	,-2.587414013e-006
	,-2.027051124e-006
	,-1.563847545e-006
	,-1.159969779e-006
	,-8.146867658e-007
	,-5.352358376e-007
	,-3.141466243e-007
	,-1.394128955e-007
	,-5.743970389e-018
	,1.133617371e-007
	,2.083186040e-007
	,2.910966732e-007
	,3.665466407e-007
	,4.380481519e-007
	,5.075001877e-007
	,5.759395479e-007
	,6.439738275e-007
	,7.123238257e-007
	,7.829889722e-007
	,8.581231193e-007
	,9.390449639e-007
	,1.026386036e-006
	,1.120046321e-006
	,1.219046621e-006
	,1.321513769e-006
	,1.426389737e-006
	,1.535081800e-006
	,1.651221821e-006
	,1.776852896e-006
	,1.912991601e-006
	,2.059783154e-006
	,2.216369483e-006
	,2.381635989e-006
	,2.554912433e-006
	,2.736047549e-006
	,2.925328703e-006
	,3.122968298e-006
	,3.328919119e-006
	,3.543313592e-006
	,3.766300537e-006
	,3.997230738e-006
	,4.234305630e-006
	,4.475126123e-006
	,4.717916492e-006
	,4.962424266e-006
	,5.209581500e-006
	,5.460629519e-006
	,5.716848543e-006
	,5.979637066e-006
	,6.250408197e-006
	,6.530391628e-006
	,6.820807332e-006
	,7.123404241e-006
	,7.439869328e-006
	,7.771450046e-006
	,8.119022034e-006
	,8.483110747e-006
	,8.863973432e-006
	,9.261848879e-006
	,9.677161547e-006
	,1.011044854e-005
	,1.056216146e-005
	,1.103250587e-005
	,1.152130440e-005
	,1.202788212e-005
	,1.255112831e-005
	,1.308997089e-005
	,1.364404251e-005
	,1.421375789e-005
	,1.479972203e-005
	,1.540217895e-005
	,1.602084665e-005
	,1.665516710e-005
	,1.730487436e-005
	,1.797011218e-005
	,1.865107477e-005
	,1.934771606e-005
	,2.005970008e-005
	,2.078657279e-005
	,2.152799949e-005
	,2.228391792e-005
	,2.305458325e-005
	,2.384047593e-005
	,2.464245555e-005
	,2.546147878e-005
	,2.629855855e-005
	,2.715471879e-005
	,2.803099867e-005
	,2.892850130e-005
	,2.984847445e-005
	,3.079241295e-005
	,3.176217620e-005
	,3.276011554e-005
	,3.378913034e-005
	,3.485255261e-005
	,3.595569439e-005
	,3.710548530e-005
	,3.831037300e-005
	,3.958092998e-005
	,4.093026055e-005
	,4.237432872e-005
	,4.393218525e-005
	,4.562604395e-005
	,4.748116833e-005
	,4.952555875e-005
	,5.178984651e-005
	,5.430806230e-005
	,5.711171029e-005
	,6.023218670e-005
	,6.369799036e-005
	,6.753226080e-005
	,7.175063791e-005
	,7.636052118e-005
	,8.135677986e-005
	,8.672115148e-005
	,9.242949255e-005
	,9.844974120e-005
	,1.047706351e-004
	,1.114137299e-004
	,1.184275657e-004
	,1.258459120e-004
	,1.336772005e-004
	,1.419132539e-004
	,1.505365548e-004
	,1.595240842e-004
	,1.688495943e-004
	,1.784857188e-004
	,1.884047271e-004
	,1.985795120e-004
	,2.089856034e-004
	,2.196000364e-004
	,2.304002115e-004
	,2.413677051e-004
	,2.524878519e-004
	,2.637491487e-004
	,2.751441112e-004
	,2.866693050e-004
	,2.980803565e-004
	,3.094965090e-004
	,3.210481196e-004
	,3.327420666e-004
	,3.445873723e-004
	,3.565947380e-004
	,3.687761542e-004
	,3.811428487e-004
	,3.937094416e-004
	,4.064909220e-004
	,4.195022323e-004
	,4.327591155e-004
	,4.462789688e-004
	,4.600823283e-004
	,4.741908132e-004
	,4.886274770e-004
	,5.031514286e-004
	,5.177395378e-004
	,5.326995975e-004
	,5.479430779e-004
	,5.626804739e-004
	,5.778338038e-004
	,5.933093815e-004
	,6.090866765e-004
	,6.251727503e-004
	,6.415843288e-004
	,6.576376884e-004
	,6.730873922e-004
	,6.883560372e-004
	,7.039855379e-004
	,7.199784991e-004
	,7.363469304e-004
	,-3.144199864e-004
	,-2.999686790e-004
	,-2.856817764e-004
	,-2.714713359e-004
	,-2.572952859e-004
	,-2.431933075e-004
	,-2.292588191e-004
	,-2.156007420e-004
	,-2.023129757e-004
	,-1.894616170e-004
	,-1.770854111e-004
	,-1.651920805e-004
	,-1.537554528e-004
	,-1.427260234e-004
	,-1.320552504e-004
	,-1.217235308e-004
	,-1.117360964e-004
	,-1.020943277e-004
	,-9.279842766e-005
	,-8.388482049e-005
	,-7.539009739e-005
	,-6.731433125e-005
	,-5.957087938e-005
	,-5.201775922e-005
	,-4.483814738e-005
	,-3.826675161e-005
	,-3.233768969e-005
	,-2.703515850e-005
	,-2.239649265e-005
	,-1.842345407e-005
	,-1.505604525e-005
	,-1.221277928e-005
	,-9.822152178e-006
	,-7.813071285e-006
	,-6.118688425e-006
	,-4.689153054e-006
	,-3.477224855e-006
	,-2.433721705e-006
	,-1.517412350e-006
	,-7.066422602e-007
	,1.159186428e-017
	,5.992000602e-007
	,1.107335358e-006
	,1.546778946e-006
	,1.936776492e-006
	,2.295703407e-006
	,2.640520786e-006
	,2.983575990e-006
	,3.332769294e-006
	,3.691780961e-006
	,4.059300858e-006
	,4.431631809e-006
	,4.807152639e-006
	,5.181165506e-006
	,5.544644221e-006
	,5.897184967e-006
	,6.248980103e-006
	,6.612405841e-006
	,6.996070296e-006
	,7.404253810e-006
	,7.837558258e-006
	,8.290972401e-006
	,8.759214111e-006
	,9.246541158e-006
	,9.752232811e-006
	,1.026649143e-005
	,1.079203258e-005
	,1.133245316e-005
	,1.188612148e-005
	,1.245123160e-005
	,1.302730205e-005
	,1.361439333e-005
	,1.421346372e-005
	,1.482702603e-005
	,1.545830023e-005
	,1.610980987e-005
	,1.678283309e-005
	,1.747753958e-005
	,1.819348576e-005
	,1.892924244e-005
	,1.968203205e-005
	,2.044951776e-005
	,2.123111452e-005
	,2.202651403e-005
	,2.283409968e-005
	,2.365057660e-005
	,2.447184054e-005
	,2.529468864e-005
	,2.611754338e-005
	,2.694144157e-005
	,2.776889904e-005
	,2.860183780e-005
	,2.944220495e-005
	,3.029209301e-005
	,3.115319828e-005
	,3.202661186e-005
	,3.291303265e-005
	,3.381294177e-005
	,3.472650325e-005
	,3.565337199e-005
	,3.659260320e-005
	,3.754264426e-005
	,3.850131345e-005
	,3.946573469e-005
	,4.043228086e-005
	,4.139659597e-005
	,4.235377921e-005
	,4.329896108e-005
	,4.422855413e-005
	,4.514161923e-005
	,4.604006139e-005
	,4.692711891e-005
	,4.780506488e-005
	,4.867426858e-005
	,4.953346074e-005
	,5.038079711e-005
	,5.121539708e-005
	,5.203823557e-005
	,5.285166541e-005
	,5.365836870e-005
	,5.446079768e-005
	,5.526129117e-005
	,5.606218371e-005
	,5.686573779e-005
	,5.767384042e-005
	,5.848789805e-005
	,5.930901670e-005
	,6.013822382e-005
	,6.097655646e-005
	,6.182507082e-005
	,6.268489575e-005
	,6.355733893e-005
	,6.444390863e-005
	,6.534582857e-005
	,6.626537060e-005
	,6.720726482e-005
	,6.817658746e-005
	,6.917956228e-005
	,7.022410965e-005
	,7.132023750e-005
	,7.248041487e-005
	,7.371992051e-005
	,7.505712656e-005
	,7.651365837e-005
	,7.811436180e-005
	,7.988702341e-005
	,8.186178740e-005
	,8.407028066e-005
	,8.654451447e-005
	,8.931534969e-005
	,9.241133585e-005
	,9.585760312e-005
	,9.967469609e-005
	,1.038780124e-004
	,1.084816840e-004
	,1.134909575e-004
	,1.189055566e-004
	,1.247230056e-004
	,1.309375137e-004
	,1.375407134e-004
	,1.445265401e-004
	,1.518807325e-004
	,1.595902973e-004
	,1.676429838e-004
	,1.760267528e-004
	,1.847301451e-004
	,1.937426046e-004
	,2.030528092e-004
	,2.126521288e-004
	,2.225334953e-004
	,2.326913706e-004
	,2.431217206e-004
	,2.538192975e-004
	,2.647838138e-004
	,2.760166958e-004
	,2.870805352e-004
	,2.983860467e-004
	,3.099506452e-004
	,3.217762963e-004
	,3.338628121e-004
	,3.462175114e-004
	,3.588470767e-004
	,3.717597812e-004
	,3.849672881e-004
	,3.984824949e-004
	,4.122984025e-004
	,4.262232787e-004
	,4.405015032e-004
	,4.547090950e-004
	,4.692358240e-004
	,4.838168090e-004
	,4.982934864e-004
	,5.130670538e-004
	,5.281008959e-004
	,5.433817507e-004
	,5.589076413e-004
	,5.746823403e-004
	,5.907142192e-004
	,6.070142855e-004
	,6.232180129e-004
	,6.388643165e-004
	,-3.769366501e-004
	,-3.621136399e-004
	,-3.474897075e-004
	,-3.330040896e-004
	,-3.186334254e-004
	,-3.043779081e-004
	,-2.902288559e-004
	,-2.761476528e-004
	,-2.620936668e-004
	,-2.480871445e-004
	,-2.341785499e-004
	,-2.204902634e-004
	,-2.071630689e-004
	,-1.942512863e-004
	,-1.817764891e-004
	,-1.697561337e-004
	,-1.582090558e-004
	,-1.471513941e-004
	,-1.365919917e-004
	,-1.265314828e-004
	,-1.169665869e-004
	,-1.078986903e-004
	,-9.933694750e-005
	,-9.127855324e-005
	,-8.366388736e-005
	,-7.630246453e-005
	,-6.886615299e-005
	,-6.123828576e-005
	,-5.370067050e-005
	,-4.649874627e-005
	,-3.971776235e-005
	,-3.343583004e-005
	,-2.773551260e-005
	,-2.263179350e-005
	,-1.808309789e-005
	,-1.403151307e-005
	,-1.045836600e-005
	,-7.332226153e-006
	,-4.590531619e-006
	,-2.165459172e-006
	,-4.490777523e-018
	,1.948092492e-006
	,3.720297960e-006
	,5.352277310e-006
	,6.850643097e-006
	,8.204615215e-006
	,9.456224118e-006
	,1.065987214e-005
	,1.184316942e-005
	,1.301645961e-005
	,1.417813695e-005
	,1.532126707e-005
	,1.644355464e-005
	,1.754563794e-005
	,1.862390984e-005
	,1.968138554e-005
	,2.073249090e-005
	,2.178262511e-005
	,2.282663725e-005
	,2.385584384e-005
	,2.485932183e-005
	,2.585501506e-005
	,2.686783347e-005
	,2.790689292e-005
	,2.897138826e-005
	,3.005007051e-005
	,3.110780803e-005
	,3.210486453e-005
	,3.306820834e-005
	,3.403161267e-005
	,3.499948586e-005
	,3.596130973e-005
	,3.689759333e-005
	,3.782162638e-005
	,3.874903009e-005
	,3.968399693e-005
	,4.062835474e-005
	,4.158594794e-005
	,4.255826227e-005
	,4.354523714e-005
	,4.454838877e-005
	,4.556926899e-005
	,4.660727633e-005
	,4.765729362e-005
	,4.870623497e-005
	,4.973624647e-005
	,5.073970082e-005
	,5.172365660e-005
	,5.270046541e-005
	,5.368050207e-005
	,5.466933423e-005
	,5.566734897e-005
	,5.667196341e-005
	,5.767840852e-005
	,5.868067870e-005
	,5.967371606e-005
	,6.065094735e-005
	,6.160819613e-005
	,6.254683007e-005
	,6.346998736e-005
	,6.437897433e-005
	,6.527368894e-005
	,6.615515652e-005
	,6.702583418e-005
	,6.788762437e-005
	,6.874151374e-005
	,6.958880695e-005
	,7.043137904e-005
	,7.127095432e-005
	,7.210900114e-005
	,7.294697731e-005
	,7.378613165e-005
	,7.462719667e-005
	,7.547037308e-005
	,7.631534897e-005
	,7.716124070e-005
	,7.800706892e-005
	,7.885183801e-005
	,7.969374332e-005
	,8.053016906e-005
	,8.135835676e-005
	,8.217637698e-005
	,8.298361628e-005
	,8.378028306e-005
	,8.456654813e-005
	,8.534199569e-005
	,8.610550869e-005
	,8.685547810e-005
	,8.759031535e-005
	,8.830930223e-005
	,8.901289305e-005
	,8.970207942e-005
	,9.037759060e-005
	,9.103965695e-005
	,9.168837869e-005
	,9.232430113e-005
	,9.294860029e-005
	,9.356275432e-005
	,9.416822988e-005
	,9.476651844e-005
	,9.535914278e-005
	,9.594723478e-005
	,9.653400615e-005
	,9.712358741e-005
	,9.772007100e-005
	,9.832832976e-005
	,9.895438056e-005
	,9.960566225e-005
	,1.002913615e-004
	,1.010227441e-004
	,1.018135011e-004
	,1.026800286e-004
	,1.036416184e-004
	,1.047205125e-004
	,1.059417405e-004
	,1.073327417e-004
	,1.089227216e-004
	,1.107417810e-004
	,1.128198905e-004
	,1.151858155e-004
	,1.178661163e-004
	,1.208843263e-004
	,1.242604132e-004
	,1.280105277e-004
	,1.321470913e-004
	,1.366790583e-004
	,1.416119901e-004
	,1.469490269e-004
	,1.526912758e-004
	,1.588383680e-004
	,1.653890422e-004
	,1.723412941e-004
	,1.796924724e-004
	,1.874406911e-004
	,1.955843215e-004
	,2.041220237e-004
	,2.130526447e-004
	,2.223747474e-004
	,2.320882284e-004
	,2.421931062e-004
	,2.526895853e-004
	,2.635404846e-004
	,2.742818845e-004
	,2.853634978e-004
	,2.967066769e-004
	,3.083589028e-004
	,3.203454983e-004
	,3.326688832e-004
	,3.453229606e-004
	,3.582990069e-004
	,3.715772682e-004
	,3.851380124e-004
	,3.989518545e-004
	,4.130122254e-004
	,4.273477653e-004
	,4.419565153e-004
	,4.568374618e-004
	,4.719903755e-004
	,4.874164126e-004
	,5.031182630e-004
	,5.190993142e-004
	,-4.282177362e-004
	,-4.129969413e-004
	,-3.977354195e-004
	,-3.824175267e-004
	,-3.669923693e-004
	,-3.514320598e-004
	,-3.358202531e-004
	,-3.203167676e-004
	,-3.050580957e-004
	,-2.901292609e-004
	,-2.755609894e-004
	,-2.613523434e-004
	,-2.474902751e-004
	,-2.339676180e-004
	,-2.207892847e-004
	,-2.079593551e-004
	,-1.954692290e-004
	,-1.833011785e-004
	,-1.714616470e-004
	,-1.599864609e-004
	,-1.488791786e-004
	,-1.381539236e-004
	,-1.278802943e-004
	,-1.180598505e-004
	,-1.086318738e-004
	,-9.950366687e-005
	,-9.058617497e-005
	,-8.184317720e-005
	,-7.332985833e-005
	,-6.514194193e-005
	,-5.733841368e-005
	,-4.991549584e-005
	,-4.284388883e-005
	,-3.615612938e-005
	,-2.989163045e-005
	,-2.404414925e-005
	,-1.858511794e-005
	,-1.348006617e-005
	,-8.694828998e-006
	,-4.203387870e-006
	,7.571203826e-018
	,3.901103873e-006
	,7.496801708e-006
	,1.081894125e-005
	,1.391476244e-005
	,1.682184984e-005
	,1.954617370e-005
	,2.206196961e-005
	,2.434729190e-005
	,2.637676864e-005
	,2.822011969e-005
	,2.995997644e-005
	,3.163173958e-005
	,3.324869244e-005
	,3.481898581e-005
	,3.635477117e-005
	,3.785840017e-005
	,3.930988955e-005
	,4.071496155e-005
	,4.210030651e-005
	,4.347675306e-005
	,4.484620445e-005
	,4.620722828e-005
	,4.755644695e-005
	,4.888918860e-005
	,5.020114952e-005
	,5.149128957e-005
	,5.276173653e-005
	,5.401338636e-005
	,5.524421045e-005
	,5.645029177e-005
	,5.761586933e-005
	,5.871979158e-005
	,5.978348860e-005
	,6.083159542e-005
	,6.186898670e-005
	,6.289421585e-005
	,6.390862413e-005
	,6.490564374e-005
	,6.586449178e-005
	,6.680551490e-005
	,6.774374663e-005
	,6.868029638e-005
	,6.961352301e-005
	,7.054029961e-005
	,7.145851228e-005
	,7.236698488e-005
	,7.326367245e-005
	,7.414962661e-005
	,7.502719541e-005
	,7.589715945e-005
	,7.675945823e-005
	,7.761454804e-005
	,7.846329717e-005
	,7.930605915e-005
	,8.014250632e-005
	,8.097212493e-005
	,8.179453162e-005
	,8.260825120e-005
	,8.341073400e-005
	,8.420252201e-005
	,8.498550089e-005
	,8.575973694e-005
	,8.652385893e-005
	,8.727555034e-005
	,8.801232713e-005
	,8.873289712e-005
	,8.943784896e-005
	,9.012914074e-005
	,9.080925701e-005
	,9.147999843e-005
	,9.214235382e-005
	,9.279689221e-005
	,9.344380303e-005
	,9.408299832e-005
	,9.471420532e-005
	,9.533695343e-005
	,9.595044336e-005
	,9.655326826e-005
	,9.714312412e-005
	,9.771726470e-005
	,9.827387160e-005
	,9.881278074e-005
	,9.933510162e-005
	,9.984230632e-005
	,1.003358844e-004
	,1.008172472e-004
	,1.012876316e-004
	,1.017480803e-004
	,1.021994134e-004
	,1.026422113e-004
	,1.030768522e-004
	,1.035035601e-004
	,1.039224827e-004
	,1.043336917e-004
	,1.047372361e-004
	,1.051331856e-004
	,1.055216055e-004
	,1.059024915e-004
	,1.062757200e-004
	,1.066410533e-004
	,1.069982500e-004
	,1.073472802e-004
	,1.076884716e-004
	,1.080224096e-004
	,1.083497141e-004
	,1.086709327e-004
	,1.089866144e-004
	,1.092974045e-004
	,1.096039051e-004
	,1.099080958e-004
	,1.102125254e-004
	,1.105197440e-004
	,1.108329023e-004
	,1.111560815e-004
	,1.114945138e-004
	,1.118548308e-004
	,1.122453747e-004
	,1.126765551e-004
	,1.131611384e-004
	,1.137144577e-004
	,1.143545611e-004
	,1.151022426e-004
	,1.159809467e-004
	,1.170165271e-004
	,1.182369857e-004
	,1.196719952e-004
	,1.213525805e-004
	,1.233094164e-004
	,1.255715839e-004
	,1.281655293e-004
	,1.311143705e-004
	,1.344375450e-004
	,1.381508590e-004
	,1.422668562e-004
	,1.467957291e-004
	,1.517453678e-004
	,1.571211731e-004
	,1.629262455e-004
	,1.691596336e-004
	,1.758233590e-004
	,1.829171630e-004
	,1.904401622e-004
	,1.983911154e-004
	,2.067688030e-004
	,2.155721346e-004
	,2.247992539e-004
	,2.344491012e-004
	,2.445210490e-004
	,2.548280212e-004
	,2.651904015e-004
	,2.759338366e-004
	,2.870505128e-004
	,2.985374163e-004
	,3.103879997e-004
	,3.225957203e-004
	,3.351546108e-004
	,3.480587853e-004
	,3.613025078e-004
	,3.748811339e-004
	,3.887908483e-004
	,-4.648440301e-004
	,-4.491799557e-004
	,-4.333617360e-004
	,-4.174063113e-004
	,-4.013552413e-004
	,-3.853305100e-004
	,-3.694265167e-004
	,-3.536717579e-004
	,-3.381116688e-004
	,-3.227895381e-004
	,-3.077322730e-004
	,-2.929608434e-004
	,-2.784903759e-004
	,-2.643221044e-004
	,-2.504331774e-004
	,-2.367832493e-004
	,-2.233770175e-004
	,-2.102909597e-004
	,-1.975781483e-004
	,-1.852535889e-004
	,-1.733227338e-004
	,-1.617675571e-004
	,-1.505497001e-004
	,-1.396215409e-004
	,-1.289343348e-004
	,-1.184617847e-004
	,-1.082201085e-004
	,-9.825025989e-005
	,-8.858739723e-005
	,-7.925531680e-005
	,-7.026958005e-005
	,-6.166632177e-005
	,-5.345854862e-005
	,-4.562509135e-005
	,-3.812484104e-005
	,-3.092564794e-005
	,-2.404631326e-005
	,-1.751592902e-005
	,-1.133846881e-005
	,-5.504563310e-006
	,1.315835536e-017
	,5.192653568e-006
	,1.009323196e-005
	,1.472258086e-005
	,1.910242218e-005
	,2.325487097e-005
	,2.720033023e-005
	,3.095501691e-005
	,3.452820856e-005
	,3.791731870e-005
	,4.109927113e-005
	,4.403994352e-005
	,4.674803463e-005
	,4.926536722e-005
	,5.161844090e-005
	,5.382052760e-005
	,5.588505473e-005
	,5.781577457e-005
	,5.960088452e-005
	,6.126237931e-005
	,6.285637813e-005
	,6.441393021e-005
	,6.594367796e-005
	,6.744601425e-005
	,6.891845665e-005
	,7.035656593e-005
	,7.175632381e-005
	,7.311674300e-005
	,7.443238320e-005
	,7.568955238e-005
	,7.686350169e-005
	,7.795410791e-005
	,7.899921549e-005
	,8.002162118e-005
	,8.102563694e-005
	,8.200461931e-005
	,8.294115097e-005
	,8.382813641e-005
	,8.468356339e-005
	,8.551874232e-005
	,8.633606119e-005
	,8.713545718e-005
	,8.791593307e-005
	,8.867614189e-005
	,8.941433238e-005
	,9.012159514e-005
	,9.077497883e-005
	,9.139364869e-005
	,9.200162481e-005
	,9.260260775e-005
	,9.319586807e-005
	,9.378010116e-005
	,9.435432886e-005
	,9.491853005e-005
	,9.547286594e-005
	,9.601718898e-005
	,9.655119770e-005
	,9.707454196e-005
	,9.758684047e-005
	,9.808765306e-005
	,9.857639781e-005
	,9.905231490e-005
	,9.951513850e-005
	,9.996504636e-005
	,1.004010809e-004
	,1.008221144e-004
	,1.012296519e-004
	,1.016258618e-004
	,1.020119477e-004
	,1.023887072e-004
	,1.027567968e-004
	,1.031167985e-004
	,1.034692377e-004
	,1.038145894e-004
	,1.041532893e-004
	,1.044857114e-004
	,1.048121023e-004
	,1.051326320e-004
	,1.054474643e-004
	,1.057567595e-004
	,1.060606750e-004
	,1.063593713e-004
	,1.066530080e-004
	,1.069417719e-004
	,1.072258855e-004
	,1.075055585e-004
	,1.077809171e-004
	,1.080519702e-004
	,1.083187791e-004
	,1.085816200e-004
	,1.088407219e-004
	,1.090961907e-004
	,1.093480893e-004
	,1.095964661e-004
	,1.098413497e-004
	,1.100827247e-004
	,1.103205292e-004
	,1.105546588e-004
	,1.107849658e-004
	,1.110112863e-004
	,1.112334595e-004
	,1.114513808e-004
	,1.116651182e-004
	,1.118749937e-004
	,1.120815277e-004
	,1.122852962e-004
	,1.124868204e-004
	,1.126865213e-004
	,1.128847274e-004
	,1.130817020e-004
	,1.132776707e-004
	,1.134728447e-004
	,1.136674438e-004
	,1.138617186e-004
	,1.140559734e-004
	,1.142505830e-004
	,1.144459373e-004
	,1.146422801e-004
	,1.148407691e-004
	,1.150429592e-004
	,1.152505356e-004
	,1.154656298e-004
	,1.156909965e-004
	,1.159301988e-004
	,1.161878185e-004
	,1.164696970e-004
	,1.167832193e-004
	,1.171376229e-004
	,1.175443270e-004
	,1.180172483e-004
	,1.185730587e-004
	,1.192313473e-004
	,1.200146649e-004
	,1.209483498e-004
	,1.220600910e-004
	,1.233793320e-004
	,1.249364514e-004
	,1.267617134e-004
	,1.288843434e-004
	,1.313315982e-004
	,1.341280344e-004
	,1.372949791e-004
	,1.408503495e-004
	,1.448086570e-004
	,1.491812296e-004
	,1.539765627e-004
	,1.592007355e-004
	,1.648578788e-004
	,1.709505909e-004
	,1.774803318e-004
	,1.844476884e-004
	,1.918525155e-004
	,1.996939513e-004
	,2.079688932e-004
	,2.166789042e-004
	,2.258270960e-004
	,2.354162217e-004
	,2.452768358e-004
	,2.551956347e-004
	,2.655254529e-004
	,2.762606851e-004
	,-4.898850491e-004
	,-4.741877876e-004
	,-4.583373828e-004
	,-4.423528240e-004
	,-4.263483849e-004
	,-4.104126166e-004
	,-3.945807648e-004
	,-3.789192284e-004
	,-3.634939270e-004
	,-3.483364307e-004
	,-3.334491630e-004
	,-3.188068092e-004
	,-3.043477619e-004
	,-2.899760532e-004
	,-2.756275339e-004
	,-2.613481114e-004
	,-2.472546773e-004
	,-2.334240473e-004
	,-2.199020243e-004
	,-2.067105072e-004
	,-1.938317456e-004
	,-1.812292561e-004
	,-1.688719806e-004
	,-1.567401248e-004
	,-1.448255835e-004
	,-1.331662831e-004
	,-1.218352619e-004
	,-1.108808161e-004
	,-1.003194001e-004
	,-9.014953598e-005
	,-8.036020195e-005
	,-7.093432169e-005
	,-6.184986594e-005
	,-5.308030385e-005
	,-4.459748351e-005
	,-3.638016840e-005
	,-2.842918752e-005
	,-2.078163281e-005
	,-1.348120544e-005
	,-6.552585181e-006
	,1.383716816e-017
	,6.192830244e-006
	,1.204904042e-005
	,1.759146650e-005
	,2.284199164e-005
	,2.782194283e-005
	,3.255073630e-005
	,3.704398377e-005
	,4.131110757e-005
	,4.535131736e-005
	,4.914959115e-005
	,5.268784217e-005
	,5.597755470e-005
	,5.905650863e-005
	,6.195727509e-005
	,6.469957043e-005
	,6.729445536e-005
	,6.974819541e-005
	,7.206456907e-005
	,7.424603769e-005
	,7.629436548e-005
	,7.821135678e-005
	,8.000116763e-005
	,8.167273059e-005
	,8.323729588e-005
	,8.470416148e-005
	,8.607913148e-005
	,8.736433392e-005
	,8.855776202e-005
	,8.965359406e-005
	,9.065009682e-005
	,9.156210174e-005
	,9.241141580e-005
	,9.321389403e-005
	,9.397927726e-005
	,9.471341657e-005
	,9.541973743e-005
	,9.609971160e-005
	,9.675447562e-005
	,9.738542702e-005
	,9.798983934e-005
	,9.856002073e-005
	,9.908937664e-005
	,9.957839039e-005
	,1.000359993e-004
	,1.004760225e-004
	,1.009051384e-004
	,1.013255645e-004
	,1.017380665e-004
	,1.021428371e-004
	,1.025397500e-004
	,1.029281852e-004
	,1.033052522e-004
	,1.036608688e-004
	,1.039967897e-004
	,1.043252744e-004
	,1.046487417e-004
	,1.049669994e-004
	,1.052794329e-004
	,1.055848793e-004
	,1.058817612e-004
	,1.061713105e-004
	,1.064555263e-004
	,1.067349425e-004
	,1.070095372e-004
	,1.072791417e-004
	,1.075435682e-004
	,1.078026956e-004
	,1.080564848e-004
	,1.083048217e-004
	,1.085471795e-004
	,1.087830088e-004
	,1.090135116e-004
	,1.092402768e-004
	,1.094640525e-004
	,1.096850910e-004
	,1.099036154e-004
	,1.101199776e-004
	,1.103343250e-004
	,1.105467182e-004
	,1.107572137e-004
	,1.109658315e-004
	,1.111725416e-004
	,1.113773099e-004
	,1.115801338e-004
	,1.117810575e-004
	,1.119801476e-004
	,1.121773965e-004
	,1.123727405e-004
	,1.125661567e-004
	,1.127576746e-004
	,1.129473501e-004
	,1.131352381e-004
	,1.133213556e-004
	,1.135056950e-004
	,1.136883727e-004
	,1.138695787e-004
	,1.140494722e-004
	,1.142281957e-004
	,1.144058857e-004
	,1.145826608e-004
	,1.147585974e-004
	,1.149337195e-004
	,1.151080368e-004
	,1.152815433e-004
	,1.154541996e-004
	,1.156259766e-004
	,1.157968738e-004
	,1.159669176e-004
	,1.161361552e-004
	,1.163046198e-004
	,1.164722844e-004
	,1.166390939e-004
	,1.168050082e-004
	,1.169699979e-004
	,1.171340298e-004
	,1.172970569e-004
	,1.174590139e-004
	,1.176198101e-004
	,1.177793549e-004
	,1.179376489e-004
	,1.180948780e-004
	,1.182514430e-004
	,1.184079051e-004
	,1.185648418e-004
	,1.187226042e-004
	,1.188821689e-004
	,1.190447337e-004
	,1.192115175e-004
	,1.193840416e-004
	,1.195642676e-004
	,1.197547323e-004
	,1.199587073e-004
	,1.201803874e-004
	,1.204251155e-004
	,1.206996575e-004
	,1.210125108e-004
	,1.213742240e-004
	,1.217977138e-004
	,1.222985522e-004
	,1.228951796e-004
	,1.236090001e-004
	,1.244643042e-004
	,1.254879918e-004
	,1.267090492e-004
	,1.281577180e-004
	,1.298646506e-004
	,1.318597515e-004
	,1.341714111e-004
	,1.368255066e-004
	,1.398449057e-004
	,1.432492131e-004
	,1.470544842e-004
	,1.512735601e-004
	,1.559163603e-004
	,1.609901759e-004
	,1.665001689e-004
	,1.724498152e-004
	,1.788413085e-004
	,1.856759382e-004
	,1.929543082e-004
	,-5.090789369e-004
	,-4.926806578e-004
	,-4.763015719e-004
	,-4.601008035e-004
	,-4.441690255e-004
	,-4.285065341e-004
	,-4.131224838e-004
	,-3.980278835e-004
	,-3.831830968e-004
	,-3.685094413e-004
	,-3.539150866e-004
	,-3.393225921e-004
	,-3.247057767e-004
	,-3.100970209e-004
	,-2.955271807e-004
	,-2.810409943e-004
	,-2.666856825e-004
	,-2.525059937e-004
	,-2.385211028e-004
	,-2.247172814e-004
	,-2.110685252e-004
	,-1.975581571e-004
	,-1.842077247e-004
	,-1.710899645e-004
	,-1.582801387e-004
	,-1.458266651e-004
	,-1.337466207e-004
	,-1.220351802e-004
	,-1.106740386e-004
	,-9.964177646e-005
	,-8.893345710e-005
	,-7.855695423e-005
	,-6.850997697e-005
	,-5.877968375e-005
	,-4.935943365e-005
	,-4.025216353e-005
	,-3.146760947e-005
	,-2.303226138e-005
	,-1.497337143e-005
	,-7.298698968e-006
	,-1.211436747e-017
	,6.938013381e-006
	,1.353267228e-005
	,1.980102250e-005
	,2.575840899e-005
	,3.141666186e-005
	,3.678073071e-005
	,4.185085831e-005
	,4.663199689e-005
	,5.112327567e-005
	,5.531824044e-005
	,5.922216685e-005
	,6.285706567e-005
	,6.624855361e-005
	,6.941731955e-005
	,7.237865368e-005
	,7.514373335e-005
	,7.772014305e-005
	,8.011099434e-005
	,8.231375051e-005
	,8.432628146e-005
	,8.616234157e-005
	,8.784788491e-005
	,8.940488725e-005
	,9.084843912e-005
	,9.218946996e-005
	,9.343665381e-005
	,9.459729944e-005
	,9.567775682e-005
	,9.668363545e-005
	,9.761997413e-005
	,9.849140768e-005
	,9.930234861e-005
	,1.000573059e-004
	,1.007612975e-004
	,1.014197261e-004
	,1.020376424e-004
	,1.026192154e-004
	,1.031676278e-004
	,1.036850792e-004
	,1.041727179e-004
	,1.046307590e-004
	,1.050599792e-004
	,1.054642153e-004
	,1.058483982e-004
	,1.062146778e-004
	,1.065637621e-004
	,1.068981378e-004
	,1.072203862e-004
	,1.075314874e-004
	,1.078329581e-004
	,1.081263451e-004
	,1.084122890e-004
	,1.086910477e-004
	,1.089624823e-004
	,1.092256253e-004
	,1.094789974e-004
	,1.097242568e-004
	,1.099645944e-004
	,1.102005781e-004
	,1.104279862e-004
	,1.106418352e-004
	,1.108502184e-004
	,1.110570449e-004
	,1.112625811e-004
	,1.114666156e-004
	,1.116689401e-004
	,1.118694031e-004
	,1.120679003e-004
	,1.122643464e-004
	,1.124586287e-004
	,1.126505437e-004
	,1.128396547e-004
	,1.130249896e-004
	,1.132058815e-004
	,1.133828644e-004
	,1.135557421e-004
	,1.137238173e-004
	,1.138878861e-004
	,1.140495195e-004
	,1.142095664e-004
	,1.143684379e-004
	,1.145263890e-004
	,1.146835456e-004
	,1.148399086e-004
	,1.149954754e-004
	,1.151502812e-004
	,1.153043501e-004
	,1.154576919e-004
	,1.156102840e-004
	,1.157621822e-004
	,1.159135488e-004
	,1.160645209e-004
	,1.162152091e-004
	,1.163656222e-004
	,1.165157336e-004
	,1.166655586e-004
	,1.168151117e-004
	,1.169643312e-004
	,1.171130561e-004
	,1.172611065e-004
	,1.174085289e-004
	,1.175555510e-004
	,1.177023530e-004
	,1.178490042e-004
	,1.179954626e-004
	,1.181416502e-004
	,1.182875182e-004
	,1.184330448e-004
	,1.185782186e-004
	,1.187230377e-004
	,1.188675421e-004
	,1.190118440e-004
	,1.191560417e-004
	,1.193001583e-004
	,1.194442196e-004
	,1.195882790e-004
	,1.197323931e-004
	,1.198765935e-004
	,1.200208765e-004
	,1.201652298e-004
	,1.203096674e-004
	,1.204542200e-004
	,1.205989117e-004
	,1.207437381e-004
	,1.208886715e-004
	,1.210337075e-004
	,1.211788858e-004
	,1.213242908e-004
	,1.214700535e-004
	,1.216163578e-004
	,1.217634298e-004
	,1.219114087e-004
	,1.220601776e-004
	,1.222104605e-004
	,1.223631862e-004
	,1.225192653e-004
	,1.226798256e-004
	,1.228462963e-004
	,1.230204929e-004
	,1.232047398e-004
	,1.234020180e-004
	,1.236161292e-004
	,1.238519214e-004
	,1.241155868e-004
	,1.244149808e-004
	,1.247599365e-004
	,1.251625773e-004
	,1.256375914e-004
	,1.262024381e-004
	,1.268774850e-004
	,1.276860039e-004
	,1.286539420e-004
	,1.298094499e-004
	,1.311821793e-004
	,1.328023844e-004
	,1.346998690e-004
	,1.369028294e-004
	,1.394369124e-004
	,1.423257364e-004
	,1.455916345e-004
	,-5.264686369e-004
	,-5.094279147e-004
	,-4.925848637e-004
	,-4.760526053e-004
	,-4.598387808e-004
	,-4.439348728e-004
	,-4.283773102e-004
	,-4.131750543e-004
	,-3.982927292e-004
	,-3.836551708e-004
	,-3.691652765e-004
	,-3.547579849e-004
	,-3.403748796e-004
	,-3.259130498e-004
	,-3.113039389e-004
	,-2.965720242e-004
	,-2.818277550e-004
	,-2.671893916e-004
	,-2.527147249e-004
	,-2.384006700e-004
	,-2.242515433e-004
	,-2.103159256e-004
	,-1.966272252e-004
	,-1.831919767e-004
	,-1.700035683e-004
	,-1.570317302e-004
	,-1.442595674e-004
	,-1.317295964e-004
	,-1.195033811e-004
	,-1.076159160e-004
	,-9.607451562e-005
	,-8.486901900e-005
	,-7.398969667e-005
	,-6.344199302e-005
	,-5.323374464e-005
	,-4.337837793e-005
	,-3.390220863e-005
	,-2.482715333e-005
	,-1.615773959e-005
	,-7.886325858e-006
	,8.268982573e-016
	,7.515718761e-006
	,1.467506804e-005
	,2.149101300e-005
	,2.797443884e-005
	,3.413328130e-005
	,3.997155410e-005
	,4.548884769e-005
	,5.068200874e-005
	,5.555003381e-005
	,6.009816060e-005
	,6.433611597e-005
	,6.827226334e-005
	,7.190722021e-005
	,7.522765997e-005
	,7.822077441e-005
	,8.091724712e-005
	,8.336766915e-005
	,8.560776374e-005
	,8.766126676e-005
	,8.954626278e-005
	,9.127797112e-005
	,9.286986110e-005
	,9.433413966e-005
	,9.568198821e-005
	,9.692368729e-005
	,9.806868538e-005
	,9.912563400e-005
	,1.001023916e-004
	,1.010059715e-004
	,1.018423599e-004
	,1.026160765e-004
	,1.033297905e-004
	,1.039867453e-004
	,1.045954552e-004
	,1.051657806e-004
	,1.057041434e-004
	,1.062143705e-004
	,1.066990320e-004
	,1.071600205e-004
	,1.075987420e-004
	,1.080161701e-004
	,1.084129125e-004
	,1.087893497e-004
	,1.091455580e-004
	,1.094807212e-004
	,1.097933926e-004
	,1.100848188e-004
	,1.103596536e-004
	,1.106218607e-004
	,1.108740390e-004
	,1.111182484e-004
	,1.113558310e-004
	,1.115874178e-004
	,1.118131611e-004
	,1.120332196e-004
	,1.122483420e-004
	,1.124595088e-004
	,1.126673802e-004
	,1.128722311e-004
	,1.130737369e-004
	,1.132717725e-004
	,1.134674503e-004
	,1.136613037e-004
	,1.138535193e-004
	,1.140441120e-004
	,1.142326699e-004
	,1.144169318e-004
	,1.145910593e-004
	,1.147572006e-004
	,1.149209195e-004
	,1.150841639e-004
	,1.152474070e-004
	,1.154106649e-004
	,1.155738541e-004
	,1.157368847e-004
	,1.158996817e-004
	,1.160621847e-004
	,1.162243419e-004
	,1.163860941e-004
	,1.165473304e-004
	,1.167077603e-004
	,1.168666521e-004
	,1.170231344e-004
	,1.171775026e-004
	,1.173305060e-004
	,1.174823227e-004
	,1.176326718e-004
	,1.177818746e-004
	,1.179306696e-004
	,1.180792929e-004
	,1.182277413e-004
	,1.183759745e-004
	,1.185239574e-004
	,1.186716640e-004
	,1.188190782e-004
	,1.189661879e-004
	,1.191130365e-004
	,1.192597213e-004
	,1.194062308e-004
	,1.195524870e-004
	,1.196984340e-004
	,1.198440256e-004
	,1.199891729e-004
	,1.201338076e-004
	,1.202778834e-004
	,1.204212618e-004
	,1.205640278e-004
	,1.207065288e-004
	,1.208490406e-004
	,1.209916304e-004
	,1.211342341e-004
	,1.212768227e-004
	,1.214194137e-004
	,1.215620163e-004
	,1.217045754e-004
	,1.218469881e-004
	,1.219891724e-004
	,1.221311333e-004
	,1.222729445e-004
	,1.224146822e-004
	,1.225563985e-004
	,1.226981133e-004
	,1.228397572e-004
	,1.229812169e-004
	,1.231223854e-004
	,1.232631433e-004
	,1.234033159e-004
	,1.235426296e-004
	,1.236807310e-004
	,1.238173987e-004
	,1.239528402e-004
	,1.240875793e-004
	,1.242220662e-004
	,1.243565952e-004
	,1.244913790e-004
	,1.246265703e-004
	,1.247622754e-004
	,1.248985899e-004
	,1.250356168e-004
	,1.251733490e-004
	,1.253115572e-004
	,1.254509710e-004
	,1.255923168e-004
	,1.257361479e-004
	,1.258831357e-004
	,1.260341920e-004
	,1.261905486e-004
	,1.263538396e-004
	,1.265262097e-004
	,1.267104538e-004
	,1.269101913e-004
	,1.271300785e-004
	,1.273760490e-004
	,1.276555509e-004
	,1.279778190e-004
	,1.283542086e-004
	,1.287985333e-004
	,1.293273502e-004
	,1.299601510e-004
	,1.307193960e-004
	,-5.426700086e-004
	,-5.253149900e-004
	,-5.082789818e-004
	,-4.915914779e-004
	,-4.752091314e-004
	,-4.591372453e-004
	,-4.433955779e-004
	,-4.279486068e-004
	,-4.127119399e-004
	,-3.976013195e-004
	,-3.825902154e-004
	,-3.676460719e-004
	,-3.526812465e-004
	,-3.376431097e-004
	,-3.225883656e-004
	,-3.076231658e-004
	,-2.928035349e-004
	,-2.781136141e-004
	,-2.635310712e-004
	,-2.490626277e-004
	,-2.347081538e-004
	,-2.204604804e-004
	,-2.063226403e-004
	,-1.923405600e-004
	,-1.785868125e-004
	,-1.651115758e-004
	,-1.519365304e-004
	,-1.390645624e-004
	,-1.264842341e-004
	,-1.141694685e-004
	,-1.020852873e-004
	,-9.022377182e-005
	,-7.863091739e-005
	,-6.736924511e-005
	,-5.648610495e-005
	,-4.601455551e-005
	,-3.597267218e-005
	,-2.636083403e-005
	,-1.716979173e-005
	,-8.387108086e-006
	,2.895918154e-016
	,8.003372748e-006
	,1.563313767e-005
	,2.289709284e-005
	,2.980025757e-005
	,3.634493741e-005
	,4.253174879e-005
	,4.836112550e-005
	,5.383391330e-005
	,5.895063043e-005
	,6.370762860e-005
	,6.808937803e-005
	,7.207972422e-005
	,7.570227629e-005
	,7.900005303e-005
	,8.200565772e-005
	,8.474382816e-005
	,8.723585256e-005
	,8.950125832e-005
	,9.155838567e-005
	,9.342449738e-005
	,9.511553466e-005
	,9.664540359e-005
	,9.802555490e-005
	,9.926904460e-005
	,1.003935568e-004
	,1.014140409e-004
	,1.023391464e-004
	,1.031757700e-004
	,1.039392825e-004
	,1.046459058e-004
	,1.053051956e-004
	,1.059228332e-004
	,1.065025681e-004
	,1.070464364e-004
	,1.075536037e-004
	,1.080180270e-004
	,1.084363735e-004
	,1.088221213e-004
	,1.091877682e-004
	,1.095388203e-004
	,1.098778997e-004
	,1.102065637e-004
	,1.105258941e-004
	,1.108367137e-004
	,1.111396783e-004
	,1.114353188e-004
	,1.117240567e-004
	,1.120061975e-004
	,1.122818999e-004
	,1.125511306e-004
	,1.128137165e-004
	,1.130696950e-004
	,1.133196215e-004
	,1.135642378e-004
	,1.138040766e-004
	,1.140394305e-004
	,1.142704469e-004
	,1.144972160e-004
	,1.147198541e-004
	,1.149385637e-004
	,1.151536125e-004
	,1.153652679e-004
	,1.155737589e-004
	,1.157792661e-004
	,1.159819128e-004
	,1.161817430e-004
	,1.163787126e-004
	,1.165728407e-004
	,1.167644999e-004
	,1.169541947e-004
	,1.171418977e-004
	,1.173268618e-004
	,1.175096167e-004
	,1.176892173e-004
	,1.178604706e-004
	,1.180245426e-004
	,1.181871974e-004
	,1.183497092e-004
	,1.185120547e-004
	,1.186740110e-004
	,1.188352590e-004
	,1.189953630e-004
	,1.191542622e-004
	,1.193125487e-004
	,1.194706194e-004
	,1.196284799e-004
	,1.197857687e-004
	,1.199417648e-004
	,1.200961587e-004
	,1.202493432e-004
	,1.204016402e-004
	,1.205531519e-004
	,1.207038621e-004
	,1.208536727e-004
	,1.210023877e-004
	,1.211496771e-004
	,1.212951216e-004
	,1.214384814e-004
	,1.215799406e-004
	,1.217198537e-004
	,1.218584636e-004
	,1.219962676e-004
	,1.221337697e-004
	,1.222712079e-004
	,1.224086510e-004
	,1.225460789e-004
	,1.226834566e-004
	,1.228207392e-004
	,1.229578966e-004
	,1.230949252e-004
	,1.232317137e-004
	,1.233680507e-004
	,1.235039187e-004
	,1.236395948e-004
	,1.237752216e-004
	,1.239107874e-004
	,1.240462676e-004
	,1.241816817e-004
	,1.243170610e-004
	,1.244523976e-004
	,1.245876604e-004
	,1.247227994e-004
	,1.248577850e-004
	,1.249927004e-004
	,1.251277351e-004
	,1.252630302e-004
	,1.253985470e-004
	,1.255342086e-004
	,1.256700009e-004
	,1.258059559e-004
	,1.259421075e-004
	,1.260784433e-004
	,1.262149172e-004
	,1.263514913e-004
	,1.264881532e-004
	,1.266249208e-004
	,1.267618279e-004
	,1.268988961e-004
	,1.270361815e-004
	,1.271737541e-004
	,1.273116173e-004
	,1.274497285e-004
	,1.275880750e-004
	,1.277266913e-004
	,1.278656510e-004
	,1.280050566e-004
	,1.281449995e-004
	,1.282853366e-004
	,1.284256983e-004
	,1.285669308e-004
	,1.287097329e-004
	,1.288545674e-004
	,1.290018946e-004
	,1.291523204e-004
	,1.293066680e-004
	,1.294660423e-004
	,1.296319209e-004
	,1.298062595e-004
	,1.299916199e-004
	,1.301913302e-004
	,-5.576091755e-004
	,-5.401575297e-004
	,-5.230780556e-004
	,-5.063279310e-004
	,-4.898537929e-004
	,-4.736680599e-004
	,-4.577430195e-004
	,-4.419874717e-004
	,-4.263195432e-004
	,-4.107193392e-004
	,-3.951519515e-004
	,-3.795265021e-004
	,-3.637845231e-004
	,-3.480040271e-004
	,-3.323066450e-004
	,-3.167584775e-004
	,-3.013917940e-004
	,-2.862395920e-004
	,-2.713103339e-004
	,-2.565779470e-004
	,-2.420156992e-004
	,-2.276155076e-004
	,-2.133809318e-004
	,-1.993256824e-004
	,-1.854593830e-004
	,-1.717852879e-004
	,-1.583048712e-004
	,-1.450154915e-004
	,-1.319085847e-004
	,-1.189850924e-004
	,-1.062911052e-004
	,-9.390379773e-005
	,-8.187401799e-005
	,-7.022319760e-005
	,-5.896656519e-005
	,-4.811782888e-005
	,-3.767988005e-005
	,-2.765067158e-005
	,-1.802901961e-005
	,-8.813339944e-006
	,1.981609524e-016
	,8.415658296e-006
	,1.643793757e-005
	,2.407035958e-005
	,3.131590130e-005
	,3.817689993e-005
	,4.465378329e-005
	,5.074288470e-005
	,5.643288234e-005
	,6.169804656e-005
	,6.651934314e-005
	,7.092189002e-005
	,7.494044950e-005
	,7.860154168e-005
	,8.192860589e-005
	,8.494442145e-005
	,8.767148138e-005
	,9.013199838e-005
	,9.234785889e-005
	,9.434051124e-005
	,9.613076213e-005
	,9.773845887e-005
	,9.918195278e-005
	,1.004769103e-004
	,1.016339368e-004
	,1.026635701e-004
	,1.035909149e-004
	,1.044383140e-004
	,1.052175193e-004
	,1.059341468e-004
	,1.065850527e-004
	,1.071568775e-004
	,1.076635085e-004
	,1.081287665e-004
	,1.085644399e-004
	,1.089778562e-004
	,1.093735443e-004
	,1.097543174e-004
	,1.101221243e-004
	,1.104784482e-004
	,1.108244833e-004
	,1.111612228e-004
	,1.114895088e-004
	,1.118100629e-004
	,1.121235082e-004
	,1.124303835e-004
	,1.127311542e-004
	,1.130262181e-004
	,1.133159068e-004
	,1.136004797e-004
	,1.138801065e-004
	,1.141548334e-004
	,1.144245486e-004
	,1.146890343e-004
	,1.149482409e-004
	,1.152025559e-004
	,1.154526102e-004
	,1.156989380e-004
	,1.159418882e-004
	,1.161816771e-004
	,1.164184445e-004
	,1.166522884e-004
	,1.168832824e-004
	,1.171114842e-004
	,1.173369397e-004
	,1.175596839e-004
	,1.177797386e-004
	,1.179971081e-004
	,1.182117684e-004
	,1.184236474e-004
	,1.186325790e-004
	,1.188381881e-004
	,1.190396215e-004
	,1.192354513e-004
	,1.194253733e-004
	,1.196112032e-004
	,1.197945666e-004
	,1.199762456e-004
	,1.201565796e-004
	,1.203356441e-004
	,1.205131101e-004
	,1.206872789e-004
	,1.208530177e-004
	,1.210098026e-004
	,1.211634661e-004
	,1.213168453e-004
	,1.214704596e-004
	,1.216242719e-004
	,1.217781694e-004
	,1.219320462e-004
	,1.220858078e-004
	,1.222393476e-004
	,1.223924857e-004
	,1.225449044e-004
	,1.226963558e-004
	,1.228468384e-004
	,1.229963324e-004
	,1.231449816e-004
	,1.232930713e-004
	,1.234407526e-004
	,1.235880766e-004
	,1.237350571e-004
	,1.238816952e-004
	,1.240279871e-004
	,1.241739276e-004
	,1.243195113e-004
	,1.244647338e-004
	,1.246095929e-004
	,1.247540906e-004
	,1.248982357e-004
	,1.250420453e-004
	,1.251855435e-004
	,1.253287578e-004
	,1.254717028e-004
	,1.256143442e-004
	,1.257566352e-004
	,1.258986597e-004
	,1.260404325e-004
	,1.261818189e-004
	,1.263228218e-004
	,1.264636210e-004
	,1.266042536e-004
	,1.267447788e-004
	,1.268852227e-004
	,1.270255854e-004
	,1.271658615e-004
	,1.273060369e-004
	,1.274460774e-004
	,1.275859209e-004
	,1.277255292e-004
	,1.278649909e-004
	,1.280044252e-004
	,1.281438661e-004
	,1.282832801e-004
	,1.284226458e-004
	,1.285619617e-004
	,1.287012360e-004
	,1.288404865e-004
	,1.289797422e-004
	,1.291190455e-004
	,1.292584566e-004
	,1.293980663e-004
	,1.295379979e-004
	,1.296782881e-004
	,1.298188271e-004
	,1.299595337e-004
	,1.301004013e-004
	,1.302414719e-004
	,1.303828022e-004
	,1.305244135e-004
	,1.306662876e-004
	,1.308084108e-004
	,1.309507994e-004
	,1.310935073e-004
	,1.312366073e-004
	,1.313800749e-004
	,1.315234870e-004
	,1.316663759e-004
	,1.318097675e-004
	,1.319542571e-004
	,1.321001172e-004
	,-5.712656268e-004
	,-5.538021213e-004
	,-5.367061805e-004
	,-5.198866444e-004
	,-5.033037289e-004
	,-4.869378938e-004
	,-4.706979266e-004
	,-4.544932926e-004
	,-4.382897379e-004
	,-4.220591896e-004
	,-4.057561416e-004
	,-3.893428587e-004
	,-3.728967858e-004
	,-3.565619023e-004
	,-3.404162451e-004
	,-3.244901722e-004
	,-3.087926164e-004
	,-2.933194956e-004
	,-2.780766896e-004
	,-2.630681019e-004
	,-2.482792787e-004
	,-2.336848109e-004
	,-2.192704114e-004
	,-2.050262402e-004
	,-1.909288653e-004
	,-1.769487311e-004
	,-1.630753977e-004
	,-1.493293799e-004
	,-1.357459657e-004
	,-1.223859748e-004
	,-1.093278871e-004
	,-9.661999899e-005
	,-8.428192776e-005
	,-7.232811895e-005
	,-6.077756076e-005
	,-4.963883148e-005
	,-3.890993492e-005
	,-2.858573785e-005
	,-1.866143708e-005
	,-9.133554727e-006
	,2.681308875e-016
	,8.739995105e-006
	,1.708560866e-005
	,2.503425740e-005
	,3.258212351e-005
	,3.972347647e-005
	,4.644615595e-005
	,5.272359891e-005
	,5.852557608e-005
	,6.386207344e-005
	,6.876020046e-005
	,7.323889629e-005
	,7.731557637e-005
	,8.101042523e-005
	,8.434620421e-005
	,8.734713464e-005
	,9.003817787e-005
	,9.244464252e-005
	,9.459183691e-005
	,9.650459488e-005
	,9.820649949e-005
	,9.971828205e-005
	,1.010545025e-004
	,1.022312684e-004
	,1.032821400e-004
	,1.042324772e-004
	,1.050926649e-004
	,1.058546732e-004
	,1.065136299e-004
	,1.071053904e-004
	,1.076512811e-004
	,1.081623565e-004
	,1.086456384e-004
	,1.091057025e-004
	,1.095458325e-004
	,1.099685682e-004
	,1.103759559e-004
	,1.107696771e-004
	,1.111511202e-004
	,1.115214137e-004
	,1.118814131e-004
	,1.122316062e-004
	,1.125719170e-004
	,1.129019026e-004
	,1.132221761e-004
	,1.135345663e-004
	,1.138405912e-004
	,1.141411629e-004
	,1.144368587e-004
	,1.147280850e-004
	,1.150151430e-004
	,1.152982483e-004
	,1.155775258e-004
	,1.158529867e-004
	,1.161245047e-004
	,1.163918600e-004
	,1.166549430e-004
	,1.169139599e-004
	,1.171693051e-004
	,1.174212351e-004
	,1.176695376e-004
	,1.179127344e-004
	,1.181473170e-004
	,1.183737014e-004
	,1.185960900e-004
	,1.188163383e-004
	,1.190349877e-004
	,1.192522100e-004
	,1.194680613e-004
	,1.196825554e-004
	,1.198956899e-004
	,1.201074560e-004
	,1.203178432e-004
	,1.205268420e-004
	,1.207344450e-004
	,1.209406479e-004
	,1.211454499e-004
	,1.213488542e-004
	,1.215508677e-004
	,1.217515015e-004
	,1.219507704e-004
	,1.221486913e-004
	,1.223452818e-004
	,1.225405561e-004
	,1.227345153e-004
	,1.229271194e-004
	,1.231181845e-004
	,1.233069461e-004
	,1.234903600e-004
	,1.236633885e-004
	,1.238301735e-004
	,1.239957773e-004
	,1.241611347e-004
	,1.243260627e-004
	,1.244898962e-004
	,1.246514260e-004
	,1.248110678e-004
	,1.249699794e-004
	,1.251284279e-004
	,1.252863588e-004
	,1.254437662e-004
	,1.256006901e-004
	,1.257571492e-004
	,1.259131443e-004
	,1.260686689e-004
	,1.262237136e-004
	,1.263782650e-004
	,1.265323009e-004
	,1.266857735e-004
	,1.268385786e-004
	,1.269906130e-004
	,1.271419986e-004
	,1.272929382e-004
	,1.274435274e-004
	,1.275937972e-004
	,1.277437568e-004
	,1.278934075e-004
	,1.280427480e-004
	,1.281917750e-004
	,1.283404834e-004
	,1.284888630e-004
	,1.286368926e-004
	,1.287845219e-004
	,1.289316352e-004
	,1.290780648e-004
	,1.292238360e-004
	,1.293692208e-004
	,1.295144339e-004
	,1.296595791e-004
	,1.298047044e-004
	,1.299498423e-004
	,1.300949901e-004
	,1.302400163e-004
	,1.303845401e-004
	,1.305285952e-004
	,1.306722132e-004
	,1.308153593e-004
	,1.309581768e-004
	,1.311008593e-004
	,1.312435130e-004
	,1.313861763e-004
	,1.315288608e-004
	,1.316715732e-004
	,1.318143285e-004
	,1.319571673e-004
	,1.321001846e-004
	,1.322435038e-004
	,1.323870950e-004
	,1.325308220e-004
	,1.326745986e-004
	,1.328183900e-004
	,1.329621877e-004
	,1.331059976e-004
	,1.332498372e-004
	,1.333937362e-004
	,1.335377373e-004
	,1.336818982e-004
	,1.338263027e-004
	,1.339710846e-004
	,1.341164055e-004
	,1.342622726e-004
	,-5.839233551e-004
	,-5.664136563e-004
	,-5.491797563e-004
	,-5.320877216e-004
	,-5.151086951e-004
	,-4.982298443e-004
	,-4.814199172e-004
	,-4.646736843e-004
	,-4.479738041e-004
	,-4.312661627e-004
	,-4.144733624e-004
	,-3.975905081e-004
	,-3.807437817e-004
	,-3.640455817e-004
	,-3.475539912e-004
	,-3.313090338e-004
	,-3.153410154e-004
	,-2.996596004e-004
	,-2.842529795e-004
	,-2.690917085e-004
	,-2.541306084e-004
	,-2.393199757e-004
	,-2.246157788e-004
	,-2.099726530e-004
	,-1.953742410e-004
	,-1.808617221e-004
	,-1.664974491e-004
	,-1.523242094e-004
	,-1.383945621e-004
	,-1.247805017e-004
	,-1.115217634e-004
	,-9.862609171e-005
	,-8.609456909e-005
	,-7.394136970e-005
	,-6.218088190e-005
	,-5.081821899e-005
	,-3.985487119e-005
	,-2.929164888e-005
	,-1.912878784e-005
	,-9.365512108e-006
	,3.760621232e-016
	,8.970007973e-006
	,1.754604331e-005
	,2.572710160e-005
	,3.350629623e-005
	,4.086367743e-005
	,4.775982209e-005
	,5.416904465e-005
	,6.010329391e-005
	,6.557390476e-005
	,7.058604296e-005
	,7.514824611e-005
	,7.927659878e-005
	,8.299345131e-005
	,8.632471090e-005
	,8.929810361e-005
	,9.194236582e-005
	,9.428670322e-005
	,9.636007008e-005
	,9.818980261e-005
	,9.979830972e-005
	,1.012023272e-004
	,1.024357915e-004
	,1.035348257e-004
	,1.045102198e-004
	,1.053478667e-004
	,1.060791123e-004
	,1.067409735e-004
	,1.073484717e-004
	,1.079134414e-004
	,1.084443956e-004
	,1.089470866e-004
	,1.094257420e-004
	,1.098836621e-004
	,1.103235142e-004
	,1.107474960e-004
	,1.111574396e-004
	,1.115548868e-004
	,1.119411444e-004
	,1.123173278e-004
	,1.126843948e-004
	,1.130431720e-004
	,1.133943767e-004
	,1.137386333e-004
	,1.140764866e-004
	,1.144084118e-004
	,1.147348210e-004
	,1.150560660e-004
	,1.153724345e-004
	,1.156841344e-004
	,1.159912509e-004
	,1.162936362e-004
	,1.165906523e-004
	,1.168807930e-004
	,1.171611844e-004
	,1.174268757e-004
	,1.176814889e-004
	,1.179314131e-004
	,1.181784170e-004
	,1.184230652e-004
	,1.186657720e-004
	,1.189068723e-004
	,1.191465891e-004
	,1.193850521e-004
	,1.196223304e-004
	,1.198584571e-004
	,1.200934447e-004
	,1.203272933e-004
	,1.205599960e-004
	,1.207915415e-004
	,1.210219164e-004
	,1.212511062e-004
	,1.214790964e-004
	,1.217058727e-004
	,1.219314221e-004
	,1.221557330e-004
	,1.223787954e-004
	,1.226006016e-004
	,1.228211463e-004
	,1.230404265e-004
	,1.232584426e-004
	,1.234751978e-004
	,1.236906990e-004
	,1.239049566e-004
	,1.241179847e-004
	,1.243298014e-004
	,1.245404277e-004
	,1.247498870e-004
	,1.249582021e-004
	,1.251653895e-004
	,1.253714460e-004
	,1.255763159e-004
	,1.257797976e-004
	,1.259812329e-004
	,1.261783381e-004
	,1.263652443e-004
	,1.265416399e-004
	,1.267151472e-004
	,1.268884803e-004
	,1.270618112e-004
	,1.272348965e-004
	,1.274074965e-004
	,1.275794256e-004
	,1.277505413e-004
	,1.279207717e-004
	,1.280900025e-004
	,1.282575586e-004
	,1.284222832e-004
	,1.285849998e-004
	,1.287466612e-004
	,1.289075760e-004
	,1.290679155e-004
	,1.292277675e-004
	,1.293871659e-004
	,1.295461215e-004
	,1.297046374e-004
	,1.298627143e-004
	,1.300203526e-004
	,1.301775527e-004
	,1.303343147e-004
	,1.304906370e-004
	,1.306465129e-004
	,1.308019218e-004
	,1.309568162e-004
	,1.311111653e-004
	,1.312650664e-004
	,1.314186330e-004
	,1.315718942e-004
	,1.317248067e-004
	,1.318772358e-004
	,1.320289602e-004
	,1.321799351e-004
	,1.323304370e-004
	,1.324807120e-004
	,1.326308616e-004
	,1.327809146e-004
	,1.329308734e-004
	,1.330807279e-004
	,1.332304545e-004
	,1.333800011e-004
	,1.335292520e-004
	,1.336779926e-004
	,1.338260110e-004
	,1.339733537e-004
	,1.341201651e-004
	,1.342663151e-004
	,1.344121354e-004
	,1.345579550e-004
	,1.347038371e-004
	,1.348498157e-004
	,1.349959486e-004
	,1.351423004e-004
	,1.352888707e-004
	,1.354355988e-004
	,1.355824305e-004
	,1.357293360e-004
	,1.358763010e-004
	,1.360233221e-004
	,1.361704061e-004
	,1.363175790e-004
	,1.364649074e-004
	,-5.950658849e-004
	,-5.772238860e-004
	,-5.596449947e-004
	,-5.422485328e-004
	,-5.250001758e-004
	,-5.078438996e-004
	,-4.907545876e-004
	,-4.737157339e-004
	,-4.566805033e-004
	,-4.395637283e-004
	,-4.222866569e-004
	,-4.049281246e-004
	,-3.876670267e-004
	,-3.706364961e-004
	,-3.539067233e-004
	,-3.375028083e-004
	,-3.214219180e-004
	,-3.056428024e-004
	,-2.901277425e-004
	,-2.748177397e-004
	,-2.596281025e-004
	,-2.444688053e-004
	,-2.292845120e-004
	,-2.140945918e-004
	,-1.989824603e-004
	,-1.840278944e-004
	,-1.692714001e-004
	,-1.547563944e-004
	,-1.405579848e-004
	,-1.267238667e-004
	,-1.132643431e-004
	,-1.001754046e-004
	,-8.746371380e-005
	,-7.514414019e-005
	,-6.322186274e-005
	,-5.169623279e-005
	,-4.056630384e-005
	,-2.983181568e-005
	,-1.949272458e-005
	,-9.548855406e-006
	,3.732424393e-016
	,9.153486747e-006
	,1.790929013e-005
	,2.625977425e-005
	,3.418381445e-005
	,4.164306158e-005
	,4.861984382e-005
	,5.512549842e-005
	,6.116718816e-005
	,6.674374284e-005
	,7.185235913e-005
	,7.649596131e-005
	,8.068658222e-005
	,8.444394321e-005
	,8.779284676e-005
	,9.076153066e-005
	,9.338070945e-005
	,9.568249696e-005
	,9.769830069e-005
	,9.945394233e-005
	,1.009725635e-004
	,1.022985699e-004
	,1.034607321e-004
	,1.044497904e-004
	,1.053051575e-004
	,1.060725417e-004
	,1.067684337e-004
	,1.074068466e-004
	,1.080001948e-004
	,1.085569754e-004
	,1.090832270e-004
	,1.095835763e-004
	,1.100617103e-004
	,1.105206258e-004
	,1.109627873e-004
	,1.113902380e-004
	,1.118046840e-004
	,1.122075586e-004
	,1.126000730e-004
	,1.129832561e-004
	,1.133579820e-004
	,1.137250042e-004
	,1.140849842e-004
	,1.144384893e-004
	,1.147860087e-004
	,1.151279611e-004
	,1.154646924e-004
	,1.157964480e-004
	,1.161232525e-004
	,1.164442734e-004
	,1.167542003e-004
	,1.170470312e-004
	,1.173326373e-004
	,1.176155936e-004
	,1.178967116e-004
	,1.181761500e-004
	,1.184538983e-004
	,1.187298719e-004
	,1.190039488e-004
	,1.192760132e-004
	,1.195460028e-004
	,1.198138704e-004
	,1.200793700e-004
	,1.203417253e-004
	,1.205997744e-004
	,1.208534222e-004
	,1.211038797e-004
	,1.213521992e-004
	,1.215989235e-004
	,1.218443121e-004
	,1.220884959e-004
	,1.223315447e-004
	,1.225734967e-004
	,1.228143727e-004
	,1.230541829e-004
	,1.232929308e-004
	,1.235306158e-004
	,1.237672346e-004
	,1.240027826e-004
	,1.242372544e-004
	,1.244706450e-004
	,1.247029498e-004
	,1.249341653e-004
	,1.251642896e-004
	,1.253933222e-004
	,1.256212650e-004
	,1.258481218e-004
	,1.260738992e-004
	,1.262986060e-004
	,1.265222539e-004
	,1.267448570e-004
	,1.269664316e-004
	,1.271869957e-004
	,1.274065671e-004
	,1.276251605e-004
	,1.278427814e-004
	,1.280594120e-004
	,1.282749804e-004
	,1.284892779e-004
	,1.287017041e-004
	,1.289103546e-004
	,1.291095573e-004
	,1.292949120e-004
	,1.294746947e-004
	,1.296542643e-004
	,1.298343136e-004
	,1.300145395e-004
	,1.301945112e-004
	,1.303738890e-004
	,1.305526132e-004
	,1.307307984e-004
	,1.309084764e-004
	,1.310855781e-004
	,1.312620002e-004
	,1.314376439e-004
	,1.316124255e-004
	,1.317862397e-004
	,1.319587885e-004
	,1.321290298e-004
	,1.322959535e-004
	,1.324609694e-004
	,1.326250669e-004
	,1.327884777e-004
	,1.329512542e-004
	,1.331134649e-004
	,1.332751993e-004
	,1.334365134e-004
	,1.335974329e-004
	,1.337579699e-004
	,1.339181308e-004
	,1.340779186e-004
	,1.342373329e-004
	,1.343963659e-004
	,1.345549931e-004
	,1.347131514e-004
	,1.348706937e-004
	,1.350273725e-004
	,1.351830993e-004
	,1.353381920e-004
	,1.354930149e-004
	,1.356477504e-004
	,1.358024578e-004
	,1.359571467e-004
	,1.361118068e-004
	,1.362664123e-004
	,1.364209134e-004
	,1.365752112e-004
	,1.367291232e-004
	,1.368824120e-004
	,1.370349635e-004
	,1.371868797e-004
	,1.373383244e-004
	,1.374894151e-004
	,1.376402229e-004
	,1.377907947e-004
	,1.379411662e-004
	,1.380913482e-004
	,1.382412354e-004
	,1.383909766e-004
	,1.385408132e-004
	,1.386907813e-004
	,-6.047346839e-004
	,-5.868704199e-004
	,-5.692220276e-004
	,-5.516966664e-004
	,-5.342485363e-004
	,-5.168525261e-004
	,-4.994952137e-004
	,-4.821297764e-004
	,-4.646652163e-004
	,-4.469993995e-004
	,-4.291767315e-004
	,-4.114214921e-004
	,-3.939173216e-004
	,-3.767460002e-004
	,-3.599311069e-004
	,-3.434669013e-004
	,-3.273287645e-004
	,-3.114727807e-004
	,-2.958263300e-004
	,-2.802745451e-004
	,-2.646808697e-004
	,-2.489837468e-004
	,-2.332462795e-004
	,-2.175808756e-004
	,-2.020729381e-004
	,-1.867606773e-004
	,-1.716760489e-004
	,-1.568950789e-004
	,-1.424787566e-004
	,-1.284450382e-004
	,-1.147898034e-004
	,-1.015123343e-004
	,-8.862852139e-005
	,-7.614939013e-005
	,-6.407569846e-005
	,-5.240501675e-005
	,-4.113444893e-005
	,-3.026102104e-005
	,-1.978193026e-005
	,-9.695100902e-006
	,2.296996396e-016
	,9.301101604e-006
	,1.820024083e-005
	,2.667620214e-005
	,3.469186172e-005
	,4.222827654e-005
	,4.929108026e-005
	,5.588502465e-005
	,6.200790884e-005
	,6.765266575e-005
	,7.281337291e-005
	,7.749231414e-005
	,8.170238652e-005
	,8.546476681e-005
	,8.880603556e-005
	,9.175643694e-005
	,9.434857990e-005
	,9.661541877e-005
	,9.858542381e-005
	,1.002822449e-004
	,1.017497446e-004
	,1.030084196e-004
	,1.040694330e-004
	,1.050011176e-004
	,1.058355750e-004
	,1.065876115e-004
	,1.072734447e-004
	,1.079074294e-004
	,1.084993968e-004
	,1.090564703e-004
	,1.095841818e-004
	,1.100869680e-004
	,1.105684381e-004
	,1.110315490e-004
	,1.114787341e-004
	,1.119120046e-004
	,1.123330297e-004
	,1.127432010e-004
	,1.131436840e-004
	,1.135354590e-004
	,1.139193533e-004
	,1.142960655e-004
	,1.146661819e-004
	,1.150301799e-004
	,1.153884005e-004
	,1.157408923e-004
	,1.160864109e-004
	,1.164166401e-004
	,1.167286090e-004
	,1.170350212e-004
	,1.173391248e-004
	,1.176414366e-004
	,1.179420719e-004
	,1.182410424e-004
	,1.185383225e-004
	,1.188338659e-004
	,1.191276060e-004
	,1.194194503e-004
	,1.197092795e-004
	,1.199969645e-004
	,1.202824201e-004
	,1.205656871e-004
	,1.208469669e-004
	,1.211265539e-004
	,1.214047258e-004
	,1.216816841e-004
	,1.219575494e-004
	,1.222323790e-004
	,1.225061824e-004
	,1.227789276e-004
	,1.230505339e-004
	,1.233208406e-004
	,1.235895270e-004
	,1.238559284e-004
	,1.241187935e-004
	,1.243767907e-004
	,1.246301897e-004
	,1.248804864e-004
	,1.251287990e-004
	,1.253756804e-004
	,1.256213898e-004
	,1.258660539e-004
	,1.261097381e-004
	,1.263524777e-004
	,1.265942917e-004
	,1.268351907e-004
	,1.270751807e-004
	,1.273142652e-004
	,1.275524468e-004
	,1.277897283e-004
	,1.280261127e-004
	,1.282616042e-004
	,1.284962084e-004
	,1.287299323e-004
	,1.289627844e-004
	,1.291947750e-004
	,1.294259153e-004
	,1.296562174e-004
	,1.298856932e-004
	,1.301143523e-004
	,1.303421987e-004
	,1.305692248e-004
	,1.307953975e-004
	,1.310206297e-004
	,1.312447080e-004
	,1.314670852e-004
	,1.316861778e-004
	,1.318970800e-004
	,1.320922286e-004
	,1.322776112e-004
	,1.324619684e-004
	,1.326469360e-004
	,1.328321159e-004
	,1.330171007e-004
	,1.332019432e-004
	,1.333868012e-004
	,1.335716610e-004
	,1.337563985e-004
	,1.339408652e-004
	,1.341249240e-004
	,1.343084591e-004
	,1.344913749e-004
	,1.346735943e-004
	,1.348550543e-004
	,1.350357024e-004
	,1.352154921e-004
	,1.353943758e-004
	,1.355722901e-004
	,1.357491069e-004
	,1.359244265e-004
	,1.360969540e-004
	,1.362659135e-004
	,1.364330341e-004
	,1.365993110e-004
	,1.367650123e-004
	,1.369302173e-004
	,1.370949491e-004
	,1.372592161e-004
	,1.374230399e-004
	,1.375864362e-004
	,1.377493597e-004
	,1.379116563e-004
	,1.380730379e-004
	,1.382333268e-004
	,1.383928387e-004
	,1.385520288e-004
	,1.387111286e-004
	,1.388702101e-004
	,1.390292820e-004
	,1.391883289e-004
	,1.393473234e-004
	,1.395062251e-004
	,1.396649729e-004
	,1.398234594e-004
	,1.399815063e-004
	,1.401389669e-004
	,1.402958641e-004
	,1.404523246e-004
	,1.406084597e-004
	,1.407643399e-004
	,1.409200077e-004
	,-1.800366669e-006
	,-1.448035627e-006
	,-1.156330092e-006
	,-9.181194315e-007
	,-7.275416330e-007
	,-5.762480546e-007
	,-4.556899397e-007
	,-3.593106060e-007
	,-2.821876862e-007
	,-2.205308425e-007
	,-1.714660719e-007
	,-1.328215858e-007
	,-1.027379403e-007
	,-7.950565920e-008
	,-6.160574905e-008
	,-4.778137795e-008
	,-3.705124376e-008
	,-2.868596066e-008
	,-2.215656307e-008
	,-1.707108610e-008
	,-1.311484076e-008
	,-1.004207827e-008
	,-7.659905959e-009
	,-5.818406499e-009
	,-4.405402793e-009
	,-3.330347881e-009
	,-2.516725898e-009
	,-1.901955391e-009
	,-1.437029057e-009
	,-1.084639193e-009
	,-8.167748074e-010
	,-6.124940852e-010
	,-4.564406975e-010
	,-3.372714565e-010
	,-2.461803666e-010
	,-1.763300856e-010
	,-1.225007052e-010
	,-8.067278404e-011
	,-4.775998374e-011
	,-2.143803348e-011
	,-2.976502795e-018
	,1.781238345e-011
	,3.297027225e-011
	,4.622392822e-011
	,5.813812508e-011
	,6.916354335e-011
	,7.971216758e-011
	,9.016464007e-011
	,1.008444687e-010
	,1.120109569e-010
	,1.238622307e-010
	,1.365459515e-010
	,1.502029207e-010
	,1.650093392e-010
	,1.811577460e-010
	,1.988442646e-010
	,2.182887959e-010
	,2.397371646e-010
	,2.634557778e-010
	,2.897347713e-010
	,3.188964535e-010
	,3.513007334e-010
	,3.873348942e-010
	,4.273835353e-010
	,4.717752060e-010
	,5.207713300e-010
	,5.747293884e-010
	,6.343743733e-010
	,7.007210245e-010
	,7.750808783e-010
	,8.590580858e-010
	,9.544774650e-010
	,1.063354223e-009
	,1.187800301e-009
	,1.329769959e-009
	,1.491840475e-009
	,1.678781358e-009
	,1.899426800e-009
	,2.164021339e-009
	,2.482641899e-009
	,2.872480822e-009
	,3.353203188e-009
	,3.948022960e-009
	,4.686856613e-009
	,5.609643989e-009
	,6.765494341e-009
	,8.215746736e-009
	,1.003802577e-008
	,1.232488123e-008
	,1.519536520e-008
	,1.881252272e-008
	,2.337530624e-008
	,2.913235570e-008
	,3.633363039e-008
	,4.537440700e-008
	,5.677919550e-008
	,7.118700705e-008
	,8.938767913e-008
	,1.123647177e-007
	,1.406872398e-007
	,1.751896072e-007
	,2.168970693e-007
	,2.670893155e-007
	,3.262507802e-007
	,3.989650352e-007
	,4.884794413e-007
	,5.987001216e-007
	,7.344007734e-007
	,9.014401660e-007
	,1.107019808e-006
	,1.359996258e-006
	,1.671253528e-006
	,2.054091026e-006
	,2.515305237e-006
	,3.066747073e-006
	,3.736326777e-006
	,4.548686432e-006
	,5.532938357e-006
	,6.723283163e-006
	,8.157474654e-006
	,9.714691263e-006
	,1.146840015e-005
	,1.335008067e-005
	,1.546032901e-005
	,1.790191642e-005
	,2.071921883e-005
	,2.395946156e-005
	,2.767488396e-005
	,3.192361015e-005
	,3.677004415e-005
	,4.228425073e-005
	,4.853776911e-005
	,5.543490406e-005
	,6.312753039e-005
	,7.160290034e-005
	,8.094608682e-005
	,9.124986596e-005
	,1.025304362e-004
	,1.145280751e-004
	,1.269117348e-004
	,1.400255048e-004
	,1.527275786e-004
	,1.655255027e-004
	,1.793175829e-004
	,1.941614440e-004
	,2.100237270e-004
	,2.268105148e-004
	,2.444400560e-004
	,2.628879258e-004
	,2.820847070e-004
	,3.019586076e-004
	,3.224368093e-004
	,3.434459857e-004
	,3.649123613e-004
	,3.867618973e-004
	,4.089213395e-004
	,4.313145141e-004
	,4.536848756e-004
	,4.758940334e-004
	,4.981013101e-004
	,5.202510702e-004
	,5.422832434e-004
	,5.641359877e-004
	,5.857491282e-004
	,6.070673371e-004
	,6.280384987e-004
	,6.486299631e-004
	,6.688235653e-004
	,6.886170615e-004
	,7.080164900e-004
	,7.257951926e-004
	,7.431389810e-004
	,7.601144120e-004
	,7.767541612e-004
	,7.930898645e-004
	,8.091709639e-004
	,8.250399926e-004
	,8.407785655e-004
	,8.564290118e-004
	,8.720320900e-004
	,8.877088753e-004
	,9.035221053e-004
	,9.195299188e-004
	,9.357843722e-004
	,9.519592429e-004
	,9.674058595e-004
	,9.832634438e-004
	,9.994767138e-004
	,1.016115831e-003
	,1.033184937e-003
	,1.050713471e-003
	,1.068591249e-003
	,1.086965107e-003
	,1.105776941e-003
	,1.125319814e-003
	,1.142992700e-003
	,1.161329140e-003
	,1.180252030e-003
	,1.199700503e-003
	,1.219682462e-003
	,1.240237656e-003
	,-4.978234033e-006
	,-4.038686014e-006
	,-3.252930805e-006
	,-2.609594228e-006
	,-2.090379575e-006
	,-1.671644810e-006
	,-1.331108127e-006
	,-1.053072070e-006
	,-8.279279640e-007
	,-6.475211014e-007
	,-5.049621739e-007
	,-3.937064018e-007
	,-3.072176754e-007
	,-2.398470290e-007
	,-1.870720176e-007
	,-1.454906013e-007
	,-1.127398704e-007
	,-8.703389657e-008
	,-6.687477740e-008
	,-5.113272047e-008
	,-3.899179749e-008
	,-2.972218456e-008
	,-2.267306040e-008
	,-1.731559507e-008
	,-1.323888404e-008
	,-1.012992428e-008
	,-7.751155920e-009
	,-5.922812607e-009
	,-4.513187045e-009
	,-3.428287897e-009
	,-2.595731955e-009
	,-1.956368512e-009
	,-1.463504161e-009
	,-1.082272880e-009
	,-7.871515951e-010
	,-5.594244149e-010
	,-3.844360577e-010
	,-2.499827146e-010
	,-1.460933183e-010
	,-6.482619793e-011
	,-2.537732530e-017
	,5.309990089e-011
	,9.803578448e-011
	,1.374940581e-010
	,1.734883391e-010
	,2.075039846e-010
	,2.406572635e-010
	,2.739043814e-010
	,3.081255207e-010
	,3.440776369e-010
	,3.823847326e-010
	,4.236070805e-010
	,4.683084913e-010
	,5.170295126e-010
	,5.702466842e-010
	,6.283222842e-010
	,6.914171597e-010
	,7.595549647e-010
	,8.330035700e-010
	,9.124354670e-010
	,9.985678732e-010
	,1.091791960e-009
	,1.191929575e-009
	,1.298186752e-009
	,1.409756752e-009
	,1.527039889e-009
	,1.651855798e-009
	,1.786499814e-009
	,1.933093363e-009
	,2.093484626e-009
	,2.269304422e-009
	,2.462040260e-009
	,2.673267585e-009
	,2.905264677e-009
	,3.161111981e-009
	,3.444497850e-009
	,3.759770012e-009
	,4.112181854e-009
	,4.508292097e-009
	,4.956381952e-009
	,5.466295764e-009
	,6.051856460e-009
	,6.731201141e-009
	,7.527485279e-009
	,8.470445349e-009
	,9.595398732e-009
	,1.094552440e-008
	,1.258440702e-008
	,1.458594524e-008
	,1.703215647e-008
	,2.001662436e-008
	,2.371260094e-008
	,2.831548081e-008
	,3.407013052e-008
	,4.125455051e-008
	,5.009269254e-008
	,6.108971546e-008
	,7.462583080e-008
	,9.109250068e-008
	,1.109945213e-007
	,1.348780251e-007
	,1.643808870e-007
	,2.009813306e-007
	,2.464510846e-007
	,3.029672052e-007
	,3.732280636e-007
	,4.605884604e-007
	,5.692243513e-007
	,7.043332094e-007
	,8.723732318e-007
	,1.081107007e-006
	,1.336910635e-006
	,1.650547490e-006
	,2.032752163e-006
	,2.502554932e-006
	,3.079763059e-006
	,3.788105755e-006
	,4.654926581e-006
	,5.688413264e-006
	,6.825276663e-006
	,8.146878022e-006
	,9.560737711e-006
	,1.121360230e-005
	,1.314695136e-005
	,1.540176460e-005
	,1.802232096e-005
	,2.105757389e-005
	,2.456179905e-005
	,2.859491716e-005
	,3.322197262e-005
	,3.850940541e-005
	,4.440028215e-005
	,5.100413660e-005
	,5.829541635e-005
	,6.642802431e-005
	,7.545217003e-005
	,8.538927385e-005
	,9.605448179e-005
	,1.071106342e-004
	,1.185682010e-004
	,1.297500171e-004
	,1.413305050e-004
	,1.538649908e-004
	,1.673948859e-004
	,1.818993715e-004
	,1.973412777e-004
	,2.136755331e-004
	,2.308512396e-004
	,2.488126340e-004
	,2.673624115e-004
	,2.865008567e-004
	,3.062060443e-004
	,3.264209028e-004
	,3.470790577e-004
	,3.681134646e-004
	,3.894573170e-004
	,4.110053302e-004
	,4.324424711e-004
	,4.539632860e-004
	,4.755180714e-004
	,4.970526768e-004
	,5.185093414e-004
	,5.398292936e-004
	,5.609558799e-004
	,5.818373791e-004
	,6.024301399e-004
	,6.227019146e-004
	,6.426344945e-004
	,6.618822958e-004
	,6.801187471e-004
	,6.978351014e-004
	,7.151556545e-004
	,7.320992780e-004
	,7.486881153e-004
	,7.649618339e-004
	,7.809644073e-004
	,7.967474850e-004
	,8.123690201e-004
	,8.278919919e-004
	,8.433731511e-004
	,8.588797400e-004
	,8.744258647e-004
	,8.889938249e-004
	,9.038369176e-004
	,9.190008933e-004
	,9.345089441e-004
	,9.503620085e-004
	,9.665650839e-004
	,9.830388670e-004
	,9.998208060e-004
	,1.017009327e-003
	,1.034547189e-003
	,1.052509221e-003
	,1.071033291e-003
	,1.090294275e-003
	,1.108020660e-003
	,1.126252142e-003
	,1.144993089e-003
	,1.164033473e-003
	,1.183585655e-003
	,1.203701370e-003
	,-1.268481026e-005
	,-1.055727262e-005
	,-8.692321321e-006
	,-7.090265778e-006
	,-5.747229858e-006
	,-4.641351118e-006
	,-3.741848604e-006
	,-3.009786839e-006
	,-2.406126938e-006
	,-1.909718791e-006
	,-1.510008819e-006
	,-1.191208405e-006
	,-9.359353018e-007
	,-7.314300505e-007
	,-5.693981013e-007
	,-4.423956148e-007
	,-3.430774860e-007
	,-2.651227071e-007
	,-2.041999257e-007
	,-1.571088315e-007
	,-1.209353200e-007
	,-9.317556554e-008
	,-7.182620472e-008
	,-5.532441631e-008
	,-4.250472786e-008
	,-3.256069163e-008
	,-2.488728920e-008
	,-1.896745632e-008
	,-1.438042888e-008
	,-1.082414612e-008
	,-8.091443030e-009
	,-6.016551400e-009
	,-4.451607089e-009
	,-3.272073139e-009
	,-2.380249509e-009
	,-1.702073650e-009
	,-1.182099496e-009
	,-7.789653105e-010
	,-4.618455815e-010
	,-2.078245889e-010
	,-1.462075319e-017
	,1.740706857e-010
	,3.239764195e-010
	,4.574600321e-010
	,5.806882276e-010
	,6.983712903e-010
	,8.138723161e-010
	,9.294683053e-010
	,1.046559316e-009
	,1.165958435e-009
	,1.288784314e-009
	,1.416537963e-009
	,1.550206033e-009
	,1.690084094e-009
	,1.836654334e-009
	,1.991529974e-009
	,2.157146563e-009
	,2.335965806e-009
	,2.530184683e-009
	,2.741793678e-009
	,2.972678457e-009
	,3.224647115e-009
	,3.499346791e-009
	,3.798140931e-009
	,4.122447892e-009
	,4.474612849e-009
	,4.857961500e-009
	,5.276121088e-009
	,5.732686168e-009
	,6.231363471e-009
	,6.776426856e-009
	,7.372895800e-009
	,8.026365568e-009
	,8.742935722e-009
	,9.529196429e-009
	,1.039211718e-008
	,1.133866046e-008
	,1.237497889e-008
	,1.350539954e-008
	,1.473283084e-008
	,1.606259884e-008
	,1.750622069e-008
	,1.907945652e-008
	,2.079985039e-008
	,2.268831856e-008
	,2.476946023e-008
	,2.707096109e-008
	,2.962126594e-008
	,3.244646003e-008
	,3.557082793e-008
	,3.902276722e-008
	,4.287508279e-008
	,4.721919201e-008
	,5.225078188e-008
	,5.818588732e-008
	,6.528343631e-008
	,7.381953037e-008
	,8.410050399e-008
	,9.666005124e-008
	,1.120986229e-007
	,1.311645621e-007
	,1.546798221e-007
	,1.838256538e-007
	,2.200890249e-007
	,2.652951560e-007
	,3.217309737e-007
	,3.921681638e-007
	,4.795774311e-007
	,5.885637751e-007
	,7.245684188e-007
	,8.929908763e-007
	,1.100817126e-006
	,1.359170679e-006
	,1.680503706e-006
	,2.079883602e-006
	,2.574459913e-006
	,3.168350284e-006
	,3.853205148e-006
	,4.658536930e-006
	,5.551364008e-006
	,6.600523768e-006
	,7.846877499e-006
	,9.324731877e-006
	,1.107107907e-005
	,1.312699438e-005
	,1.553824074e-005
	,1.835563803e-005
	,2.163514238e-005
	,2.543680570e-005
	,2.980472054e-005
	,3.473320598e-005
	,4.025339609e-005
	,4.645937378e-005
	,5.343319051e-005
	,6.122239742e-005
	,6.984323398e-005
	,7.907272703e-005
	,8.865720231e-005
	,9.848576476e-005
	,1.081186292e-004
	,1.185042595e-004
	,1.297895506e-004
	,1.419938090e-004
	,1.551065046e-004
	,1.691016688e-004
	,1.839161837e-004
	,1.995530604e-004
	,2.159713777e-004
	,2.331250777e-004
	,2.509636848e-004
	,2.694331939e-004
	,2.883707044e-004
	,3.077217658e-004
	,3.275051147e-004
	,3.476592987e-004
	,3.681241058e-004
	,3.886076285e-004
	,4.092330918e-004
	,4.299768646e-004
	,4.507910098e-004
	,4.716228536e-004
	,4.924168283e-004
	,5.131174311e-004
	,5.336736848e-004
	,5.540389462e-004
	,5.741749876e-004
	,5.940541478e-004
	,6.130259150e-004
	,6.315123899e-004
	,6.495460810e-004
	,6.671583395e-004
	,6.843957897e-004
	,7.012784398e-004
	,7.178321846e-004
	,7.340928054e-004
	,7.501048416e-004
	,7.659193759e-004
	,7.815909479e-004
	,7.966376175e-004
	,8.111726671e-004
	,8.257943831e-004
	,8.405295064e-004
	,8.553926505e-004
	,8.703877718e-004
	,8.855406919e-004
	,9.008902737e-004
	,9.164739942e-004
	,9.323354675e-004
	,9.484768512e-004
	,9.649381160e-004
	,9.816385751e-004
	,9.987236786e-004
	,1.016205218e-003
	,1.034232910e-003
	,1.052959568e-003
	,1.070447623e-003
	,1.088303964e-003
	,1.106708361e-003
	,1.125596222e-003
	,1.144988906e-003
	,1.164957959e-003
	,-2.926733345e-005
	,-2.500695941e-005
	,-2.115207186e-005
	,-1.771824462e-005
	,-1.475686783e-005
	,-1.225279729e-005
	,-1.013350241e-005
	,-8.328659637e-006
	,-6.782478435e-006
	,-5.463873004e-006
	,-4.362085927e-006
	,-3.464533098e-006
	,-2.747674915e-006
	,-2.180219657e-006
	,-1.729765440e-006
	,-1.368737215e-006
	,-1.077479283e-006
	,-8.431823695e-007
	,-6.570243878e-007
	,-5.106667181e-007
	,-3.956009884e-007
	,-3.048731201e-007
	,-2.337856805e-007
	,-1.787043213e-007
	,-1.364039310e-007
	,-1.040697062e-007
	,-7.932417180e-008
	,-6.030257962e-008
	,-4.567931372e-008
	,-3.450826936e-008
	,-2.601895052e-008
	,-1.957266869e-008
	,-1.466697400e-008
	,-1.091754042e-008
	,-8.033122586e-009
	,-5.796271100e-009
	,-4.050615473e-009
	,-2.680703339e-009
	,-1.594398879e-009
	,-7.189018431e-010
	,-6.579432294e-018
	,5.999281755e-010
	,1.106819093e-009
	,1.542277762e-009
	,1.927148784e-009
	,2.280617414e-009
	,2.618868409e-009
	,2.954795447e-009
	,3.298528910e-009
	,3.658121551e-009
	,4.040087134e-009
	,4.449843762e-009
	,4.892206732e-009
	,5.371758012e-009
	,5.892608174e-009
	,6.457727031e-009
	,7.069462842e-009
	,7.732035575e-009
	,8.452109788e-009
	,9.236941098e-009
	,1.009359798e-008
	,1.102890329e-008
	,1.204936934e-008
	,1.316142281e-008
	,1.437157748e-008
	,1.568512288e-008
	,1.710441709e-008
	,1.862837502e-008
	,2.025618248e-008
	,2.199439298e-008
	,2.385642029e-008
	,2.585468166e-008
	,2.799423299e-008
	,3.026814394e-008
	,3.265449595e-008
	,3.512330732e-008
	,3.766090595e-008
	,4.028946284e-008
	,4.305447420e-008
	,4.600283780e-008
	,4.917429854e-008
	,5.260222686e-008
	,5.631610964e-008
	,6.034303371e-008
	,6.470802293e-008
	,6.943478047e-008
	,7.455015867e-008
	,8.009180073e-008
	,8.610942830e-008
	,9.266117530e-008
	,9.981285783e-008
	,1.076412916e-007
	,1.162371841e-007
	,1.257075236e-007
	,1.361804779e-007
	,1.478148894e-007
	,1.608035262e-007
	,1.754257874e-007
	,1.920435846e-007
	,2.111231248e-007
	,2.332589774e-007
	,2.592089510e-007
	,2.898888687e-007
	,3.263838678e-007
	,3.702722723e-007
	,4.233345838e-007
	,4.875661608e-007
	,5.660214404e-007
	,6.618505440e-007
	,7.801924532e-007
	,9.266107310e-007
	,1.107498738e-006
	,1.327406877e-006
	,1.593366760e-006
	,1.906306096e-006
	,2.279148454e-006
	,2.707618063e-006
	,3.220459411e-006
	,3.840634268e-006
	,4.591052513e-006
	,5.497064749e-006
	,6.586817376e-006
	,7.893485893e-006
	,9.454662561e-006
	,1.131251875e-005
	,1.351409930e-005
	,1.611062761e-005
	,1.915126635e-005
	,2.264799349e-005
	,2.662988294e-005
	,3.116912392e-005
	,3.634282606e-005
	,4.220441743e-005
	,4.878872258e-005
	,5.607920923e-005
	,6.369900168e-005
	,7.158960221e-005
	,7.956703845e-005
	,8.797768299e-005
	,9.715089827e-005
	,1.071295669e-004
	,1.179185464e-004
	,1.295403716e-004
	,1.419875310e-004
	,1.552457264e-004
	,1.692941223e-004
	,1.841056725e-004
	,1.996475291e-004
	,2.158820296e-004
	,2.327669751e-004
	,2.502563610e-004
	,2.683006522e-004
	,2.868469234e-004
	,3.058047310e-004
	,3.249188532e-004
	,3.442096940e-004
	,3.636955778e-004
	,3.833769392e-004
	,4.032123914e-004
	,4.231552307e-004
	,4.431552132e-004
	,4.631613944e-004
	,4.831239087e-004
	,5.029964305e-004
	,5.227387694e-004
	,5.421403602e-004
	,5.608921131e-004
	,5.793697633e-004
	,5.975621702e-004
	,6.153422627e-004
	,6.328013102e-004
	,6.499463953e-004
	,6.667953272e-004
	,6.833753089e-004
	,6.995107184e-004
	,7.147461376e-004
	,7.298763693e-004
	,7.449340077e-004
	,7.599354106e-004
	,7.748952901e-004
	,7.898334025e-004
	,8.047747909e-004
	,8.197481597e-004
	,8.347844113e-004
	,8.499157894e-004
	,8.651755764e-004
	,8.805981441e-004
	,8.962090167e-004
	,9.120425251e-004
	,9.281511671e-004
	,9.445553273e-004
	,9.611160567e-004
	,9.780038768e-004
	,9.953891749e-004
	,1.013438404e-003
	,1.030700058e-003
	,1.048130496e-003
	,1.065488523e-003
	,1.083396884e-003
	,1.101865301e-003
	,1.120970173e-003
	,-5.943539917e-005
	,-5.236117576e-005
	,-4.579251274e-005
	,-3.972917877e-005
	,-3.418876014e-005
	,-2.922799723e-005
	,-2.485972102e-005
	,-2.101559216e-005
	,-1.762318057e-005
	,-1.463377180e-005
	,-1.202868804e-005
	,-9.817952070e-006
	,-7.990452060e-006
	,-6.494623708e-006
	,-5.263434713e-006
	,-4.237111813e-006
	,-3.383458527e-006
	,-2.678948108e-006
	,-2.098486987e-006
	,-1.630753253e-006
	,-1.263310435e-006
	,-9.786776547e-007
	,-7.591525511e-007
	,-5.895628927e-007
	,-4.577817128e-007
	,-3.546810088e-007
	,-2.740844649e-007
	,-2.113107516e-007
	,-1.623269408e-007
	,-1.240081077e-007
	,-9.401413992e-008
	,-7.063346167e-008
	,-5.258092536e-008
	,-3.873572275e-008
	,-2.814006356e-008
	,-2.004052678e-008
	,-1.384044696e-008
	,-9.063337649e-009
	,-5.336732298e-009
	,-2.384056816e-009
	,-6.161701340e-018
	,1.971665337e-009
	,3.652746206e-009
	,5.139569171e-009
	,6.507432245e-009
	,7.815822710e-009
	,9.110680581e-009
	,1.042521990e-008
	,1.178145765e-008
	,1.319800564e-008
	,1.469929557e-008
	,1.631273133e-008
	,1.806207359e-008
	,1.996383872e-008
	,2.202283017e-008
	,2.422522389e-008
	,2.653761847e-008
	,2.892928850e-008
	,3.140135288e-008
	,3.397791157e-008
	,3.668026324e-008
	,3.952228979e-008
	,4.252246321e-008
	,4.571269459e-008
	,4.913083994e-008
	,5.281126263e-008
	,5.678502779e-008
	,6.108360985e-008
	,6.574003029e-008
	,7.078530645e-008
	,7.624570300e-008
	,8.214136316e-008
	,8.848602828e-008
	,9.528968433e-008
	,1.025672169e-007
	,1.103518969e-007
	,1.186975942e-007
	,1.276662813e-007
	,1.373191319e-007
	,1.477161673e-007
	,1.589208750e-007
	,1.710067954e-007
	,1.840594121e-007
	,1.981725330e-007
	,2.134455663e-007
	,2.299826813e-007
	,2.478913194e-007
	,2.672776904e-007
	,2.882375711e-007
	,3.108411223e-007
	,3.351203695e-007
	,3.610904229e-007
	,3.888188354e-007
	,4.184686754e-007
	,4.502573169e-007
	,4.844008721e-007
	,5.210928328e-007
	,5.605120071e-007
	,6.028482851e-007
	,6.483156226e-007
	,6.971101162e-007
	,7.493457665e-007
	,8.050286941e-007
	,8.641629631e-007
	,9.270715351e-007
	,9.946885253e-007
	,1.068295900e-006
	,1.149830942e-006
	,1.241846737e-006
	,1.347657507e-006
	,1.471114099e-006
	,1.616714910e-006
	,1.790097175e-006
	,1.997715584e-006
	,2.246652527e-006
	,2.548133540e-006
	,2.914395819e-006
	,3.360121620e-006
	,3.902838066e-006
	,4.560833001e-006
	,5.358657691e-006
	,6.325704528e-006
	,7.494572743e-006
	,8.901699687e-006
	,1.058285054e-005
	,1.257168435e-005
	,1.489696842e-005
	,1.760025705e-005
	,2.074913880e-005
	,2.439713404e-005
	,2.859100211e-005
	,3.335429886e-005
	,3.863428901e-005
	,4.416957663e-005
	,5.006646835e-005
	,5.608680831e-005
	,6.261394373e-005
	,6.977548756e-005
	,7.763849158e-005
	,8.622753611e-005
	,9.555702431e-005
	,1.056350854e-004
	,1.164642709e-004
	,1.280415384e-004
	,1.403581856e-004
	,1.533998784e-004
	,1.671469131e-004
	,1.815745228e-004
	,1.966531942e-004
	,2.123488785e-004
	,2.286235353e-004
	,2.454346254e-004
	,2.627350777e-004
	,2.804747553e-004
	,2.985291032e-004
	,3.168761799e-004
	,3.353272156e-004
	,3.538717437e-004
	,3.726091370e-004
	,3.914949376e-004
	,4.104826571e-004
	,4.295257387e-004
	,4.485800227e-004
	,4.676067554e-004
	,4.862069163e-004
	,5.045891549e-004
	,5.228037704e-004
	,5.408397500e-004
	,5.586530602e-004
	,5.761994030e-004
	,5.935010723e-004
	,6.098517429e-004
	,6.260076272e-004
	,6.419924775e-004
	,6.578128870e-004
	,6.734714864e-004
	,6.889763856e-004
	,7.043434754e-004
	,7.195953955e-004
	,7.347596721e-004
	,7.498669299e-004
	,7.649494306e-004
	,7.800399793e-004
	,7.951711746e-004
	,8.103749635e-004
	,8.256676456e-004
	,8.407191234e-004
	,8.559582150e-004
	,8.714137217e-004
	,8.871146601e-004
	,9.030931821e-004
	,9.193038421e-004
	,9.355595431e-004
	,9.521760884e-004
	,9.693023742e-004
	,9.860746336e-004
	,1.002596073e-003
	,1.019679456e-003
	,1.037232728e-003
	,1.055313493e-003
	,1.074058067e-003
	,-1.083947787e-004
	,-9.791207543e-005
	,-8.809905188e-005
	,-7.877938086e-005
	,-6.993700317e-005
	,-6.168703010e-005
	,-5.414063837e-005
	,-4.735367530e-005
	,-4.129661610e-005
	,-3.583720631e-005
	,-3.080576666e-005
	,-2.613409261e-005
	,-2.188216276e-005
	,-1.813510107e-005
	,-1.490530886e-005
	,-1.217737131e-005
	,-9.919004729e-006
	,-8.064533722e-006
	,-6.531701388e-006
	,-5.260640056e-006
	,-4.217127974e-006
	,-3.364133588e-006
	,-2.669458176e-006
	,-2.102459299e-006
	,-1.642599535e-006
	,-1.273833556e-006
	,-9.809648764e-007
	,-7.506659779e-007
	,-5.713668257e-007
	,-4.336346223e-007
	,-3.286399444e-007
	,-2.484593652e-007
	,-1.868850684e-007
	,-1.394651314e-007
	,-1.027766577e-007
	,-7.422363847e-008
	,-5.193691772e-008
	,-3.444445089e-008
	,-2.054093704e-008
	,-9.288352672e-009
	,1.106970059e-017
	,7.818843877e-009
	,1.454618046e-008
	,2.049599122e-008
	,2.592963363e-008
	,3.102694707e-008
	,3.586101794e-008
	,4.051424354e-008
	,4.511411539e-008
	,4.977063789e-008
	,5.457124251e-008
	,5.959706446e-008
	,6.492917030e-008
	,7.063783934e-008
	,7.679262452e-008
	,8.347085039e-008
	,9.074676600e-008
	,9.868716108e-008
	,1.073568705e-007
	,1.168221320e-007
	,1.271434551e-007
	,1.383636032e-007
	,1.505052491e-007
	,1.635970333e-007
	,1.777226234e-007
	,1.930178514e-007
	,2.096244332e-007
	,2.276619015e-007
	,2.472171913e-007
	,2.683459222e-007
	,2.910955160e-007
	,3.155372948e-007
	,3.417529644e-007
	,3.697829442e-007
	,3.996023198e-007
	,4.311963941e-007
	,4.647037171e-007
	,5.003786227e-007
	,5.384137972e-007
	,5.788519286e-007
	,6.215767992e-007
	,6.662583600e-007
	,7.122839221e-007
	,7.588900978e-007
	,8.056020143e-007
	,8.525910353e-007
	,9.005414229e-007
	,9.502723025e-007
	,1.002495396e-006
	,1.057760329e-006
	,1.116487001e-006
	,1.179010739e-006
	,1.245609737e-006
	,1.316513971e-006
	,1.391928335e-006
	,1.472091771e-006
	,1.557334346e-006
	,1.648074605e-006
	,1.744787935e-006
	,1.847986528e-006
	,1.958213849e-006
	,2.076049341e-006
	,2.202119032e-006
	,2.337107848e-006
	,2.481788519e-006
	,2.637033770e-006
	,2.803846281e-006
	,2.983392950e-006
	,3.177051946e-006
	,3.386481078e-006
	,3.613722284e-006
	,3.861314685e-006
	,4.132573502e-006
	,4.431806797e-006
	,4.764538332e-006
	,5.137936901e-006
	,5.560942650e-006
	,6.044494227e-006
	,6.601755880e-006
	,7.245895419e-006
	,7.998500497e-006
	,8.885542496e-006
	,9.936889269e-006
	,1.118561334e-005
	,1.266726055e-005
	,1.441066470e-005
	,1.645122320e-005
	,1.880851421e-005
	,2.145299240e-005
	,2.434895208e-005
	,2.753367950e-005
	,3.094658844e-005
	,3.469527369e-005
	,3.889390514e-005
	,4.360349714e-005
	,4.886268563e-005
	,5.470106249e-005
	,6.114332543e-005
	,6.821040984e-005
	,7.591714721e-005
	,8.427761389e-005
	,9.330374733e-005
	,1.030009493e-004
	,1.133701656e-004
	,1.244077826e-004
	,1.361056003e-004
	,1.484508634e-004
	,1.614263146e-004
	,1.750101546e-004
	,1.891759482e-004
	,2.038914760e-004
	,2.191203584e-004
	,2.348148154e-004
	,2.509123710e-004
	,2.673906490e-004
	,2.842279563e-004
	,3.013951451e-004
	,3.188572926e-004
	,3.365746840e-004
	,3.542165593e-004
	,3.718937701e-004
	,3.896852398e-004
	,4.074314428e-004
	,4.250317506e-004
	,4.426011961e-004
	,4.601387407e-004
	,4.776113322e-004
	,4.945359245e-004
	,5.113213062e-004
	,5.280107725e-004
	,5.446261838e-004
	,5.611550604e-004
	,5.771210452e-004
	,5.929835471e-004
	,6.087460241e-004
	,6.243940204e-004
	,6.399210073e-004
	,6.553287995e-004
	,6.706273651e-004
	,6.858284800e-004
	,7.009553996e-004
	,7.160370898e-004
	,7.311012097e-004
	,7.461765259e-004
	,7.612921541e-004
	,7.764770685e-004
	,7.917598458e-004
	,8.071686224e-004
	,8.227312758e-004
	,8.384738329e-004
	,8.544275067e-004
	,8.706266304e-004
	,8.868936554e-004
	,9.032066870e-004
	,9.198860158e-004
	,9.370054359e-004
	,9.530833596e-004
	,9.696748652e-004
	,9.866934615e-004
	,1.004175670e-003
	,1.022263446e-003
	,-1.760028604e-004
	,-1.626088298e-004
	,-1.497692979e-004
	,-1.375201712e-004
	,-1.258243065e-004
	,-1.146036721e-004
	,-1.038387599e-004
	,-9.364327728e-005
	,-8.412928594e-005
	,-7.527282542e-005
	,-6.695827661e-005
	,-5.912307780e-005
	,-5.181548721e-005
	,-4.504842729e-005
	,-3.876059601e-005
	,-3.300312517e-005
	,-2.792567750e-005
	,-2.354119480e-005
	,-1.973057002e-005
	,-1.637041368e-005
	,-1.343680671e-005
	,-1.092724630e-005
	,-8.818289657e-006
	,-7.061685666e-006
	,-5.613924275e-006
	,-4.448712072e-006
	,-3.521121303e-006
	,-2.779064335e-006
	,-2.182977976e-006
	,-1.708050470e-006
	,-1.328053764e-006
	,-1.021042890e-006
	,-7.753825779e-007
	,-5.812521189e-007
	,-4.279007085e-007
	,-3.069979659e-007
	,-2.126493335e-007
	,-1.392398789e-007
	,-8.181360135e-008
	,-3.645586451e-008
	,2.396714385e-017
	,3.014392297e-008
	,5.597224695e-008
	,7.895067325e-008
	,1.001286735e-007
	,1.203438128e-007
	,1.403898497e-007
	,1.609328141e-007
	,1.823913021e-007
	,2.050243153e-007
	,2.286294855e-007
	,2.523798626e-007
	,2.763502419e-007
	,3.014520520e-007
	,3.285684656e-007
	,3.583398439e-007
	,3.911725838e-007
	,4.272031464e-007
	,4.661804035e-007
	,5.074166396e-007
	,5.501073817e-007
	,5.938165675e-007
	,6.384977834e-007
	,6.841944601e-007
	,7.310180807e-007
	,7.793625288e-007
	,8.299322295e-007
	,8.835128803e-007
	,9.408044876e-007
	,1.002385366e-006
	,1.068713453e-006
	,1.140131487e-006
	,1.216872486e-006
	,1.299087520e-006
	,1.386912592e-006
	,1.480502999e-006
	,1.579999901e-006
	,1.685565451e-006
	,1.797562247e-006
	,1.916712105e-006
	,2.043827646e-006
	,2.179560397e-006
	,2.324381637e-006
	,2.478630146e-006
	,2.642621362e-006
	,2.816813575e-006
	,3.001866716e-006
	,3.198514946e-006
	,3.407419348e-006
	,3.629074928e-006
	,3.863741166e-006
	,4.111437107e-006
	,4.372047001e-006
	,4.645402137e-006
	,4.931241965e-006
	,5.229330532e-006
	,5.539833282e-006
	,5.863492648e-006
	,6.201406123e-006
	,6.554750813e-006
	,6.924629081e-006
	,7.311894913e-006
	,7.717011437e-006
	,8.139949884e-006
	,8.580024702e-006
	,9.035612138e-006
	,9.503819015e-006
	,9.980398268e-006
	,1.046044667e-005
	,1.094016632e-005
	,1.141869213e-005
	,1.189789894e-005
	,1.238072290e-005
	,1.286994201e-005
	,1.336840280e-005
	,1.388006568e-005
	,1.441041004e-005
	,1.496581956e-005
	,1.555319519e-005
	,1.617991797e-005
	,1.685436780e-005
	,1.758621046e-005
	,1.838701082e-005
	,1.927090864e-005
	,2.025519464e-005
	,2.136056701e-005
	,2.261266192e-005
	,2.404080798e-005
	,2.567789704e-005
	,2.755966670e-005
	,2.972322613e-005
	,3.220506976e-005
	,3.504203520e-005
	,3.827557796e-005
	,4.194191664e-005
	,4.607442760e-005
	,5.070308618e-005
	,5.585418260e-005
	,6.154769499e-005
	,6.780369261e-005
	,7.463909725e-005
	,8.206475171e-005
	,9.008698514e-005
	,9.870722302e-005
	,1.079217285e-004
	,1.177220540e-004
	,1.280927197e-004
	,1.390167428e-004
	,1.504868231e-004
	,1.624838550e-004
	,1.749830549e-004
	,1.879694865e-004
	,2.014165980e-004
	,2.152971109e-004
	,2.295918706e-004
	,2.442758649e-004
	,2.593170388e-004
	,2.746767555e-004
	,2.903096125e-004
	,3.061678757e-004
	,3.220921476e-004
	,3.379306334e-004
	,3.533962456e-004
	,3.685358964e-004
	,3.839370602e-004
	,3.996673328e-004
	,4.156855855e-004
	,4.319220714e-004
	,4.482972770e-004
	,4.647543420e-004
	,4.812391527e-004
	,4.977046351e-004
	,5.141106901e-004
	,5.304245366e-004
	,5.466214078e-004
	,5.626850610e-004
	,5.786078437e-004
	,5.943900609e-004
	,6.100394281e-004
	,6.255709423e-004
	,6.410041877e-004
	,6.563620164e-004
	,6.716712447e-004
	,6.869596647e-004
	,7.022558367e-004
	,7.175884600e-004
	,7.329859599e-004
	,7.484762732e-004
	,7.640868246e-004
	,7.798447138e-004
	,7.957772102e-004
	,8.119128655e-004
	,8.282841931e-004
	,8.445301899e-004
	,8.608214809e-004
	,8.774711780e-004
	,8.940501093e-004
	,9.103027088e-004
	,9.270068293e-004
	,9.441498170e-004
	,9.617454335e-004
	,-2.568049590e-004
	,-2.431729814e-004
	,-2.297701297e-004
	,-2.162466821e-004
	,-2.024639403e-004
	,-1.884960065e-004
	,-1.744947491e-004
	,-1.606896640e-004
	,-1.473333168e-004
	,-1.345865816e-004
	,-1.225202112e-004
	,-1.111652750e-004
	,-1.006133522e-004
	,-9.084636311e-005
	,-8.176172089e-005
	,-7.322334722e-005
	,-6.506370974e-005
	,-5.729592602e-005
	,-4.999744753e-005
	,-4.319792864e-005
	,-3.699089326e-005
	,-3.150750162e-005
	,-2.675146108e-005
	,-2.262424891e-005
	,-1.901422637e-005
	,-1.581979883e-005
	,-1.294313436e-005
	,-1.038163581e-005
	,-8.187214325e-006
	,-6.393484620e-006
	,-4.973864050e-006
	,-3.864731891e-006
	,-2.999593373e-006
	,-2.321883048e-006
	,-1.784892234e-006
	,-1.346349458e-006
	,-9.727173526e-007
	,-6.531763242e-007
	,-3.886862185e-007
	,-1.742214447e-007
	,-1.357795352e-018
	,1.436552841e-007
	,2.649725594e-007
	,3.705830840e-007
	,4.657347721e-007
	,5.545301798e-007
	,6.403150613e-007
	,7.257058320e-007
	,8.122207920e-007
	,9.004804876e-007
	,9.906459628e-007
	,1.083481841e-006
	,1.180637723e-006
	,1.284016174e-006
	,1.395491407e-006
	,1.516393397e-006
	,1.646774456e-006
	,1.784273843e-006
	,1.926957528e-006
	,2.076896022e-006
	,2.234819681e-006
	,2.401226585e-006
	,2.578433832e-006
	,2.769130443e-006
	,2.975169936e-006
	,3.197988315e-006
	,3.439092269e-006
	,3.699042268e-006
	,3.976586686e-006
	,4.268718349e-006
	,4.571750572e-006
	,4.882920808e-006
	,5.201696171e-006
	,5.529619547e-006
	,5.868675096e-006
	,6.220066799e-006
	,6.584200440e-006
	,6.960904959e-006
	,7.349046327e-006
	,7.745980517e-006
	,8.148127708e-006
	,8.552847045e-006
	,8.959636998e-006
	,9.369300767e-006
	,9.783433892e-006
	,1.020446424e-005
	,1.063502871e-005
	,1.107783694e-005
	,1.153536305e-005
	,1.200970605e-005
	,1.250268184e-005
	,1.301595840e-005
	,1.355106458e-005
	,1.410924886e-005
	,1.469133772e-005
	,1.529762218e-005
	,1.592771597e-005
	,1.658043690e-005
	,1.725399965e-005
	,1.794685033e-005
	,1.865865608e-005
	,1.939026991e-005
	,2.014276274e-005
	,2.091661890e-005
	,2.171156335e-005
	,2.252713886e-005
	,2.336343158e-005
	,2.422113327e-005
	,2.510121678e-005
	,2.600452046e-005
	,2.693160322e-005
	,2.788288690e-005
	,2.885883302e-005
	,2.985993789e-005
	,3.088651530e-005
	,3.193875974e-005
	,3.301663733e-005
	,3.411992768e-005
	,3.524837095e-005
	,3.640188048e-005
	,3.758083082e-005
	,3.878635564e-005
	,4.002051477e-005
	,4.128628395e-005
	,4.258747337e-005
	,4.392852655e-005
	,4.531418533e-005
	,4.675182003e-005
	,4.825067913e-005
	,4.982169024e-005
	,5.147835021e-005
	,5.323732603e-005
	,5.511896935e-005
	,5.714772029e-005
	,5.935232244e-005
	,6.176575300e-005
	,6.442466447e-005
	,6.736847784e-005
	,7.063793123e-005
	,7.427325625e-005
	,7.831212897e-005
	,8.278763432e-005
	,8.772950209e-005
	,9.315647442e-005
	,9.908037786e-005
	,1.055239396e-004
	,1.124836262e-004
	,1.199599093e-004
	,1.279464519e-004
	,1.364376549e-004
	,1.454155101e-004
	,1.548393343e-004
	,1.646572175e-004
	,1.748316663e-004
	,1.852612623e-004
	,1.959505825e-004
	,2.069348274e-004
	,2.183514170e-004
	,2.302873732e-004
	,2.427670298e-004
	,2.557811129e-004
	,2.693056090e-004
	,2.833096767e-004
	,2.977594804e-004
	,3.126197199e-004
	,3.278464278e-004
	,3.433964916e-004
	,3.587984476e-004
	,3.742931064e-004
	,3.899673646e-004
	,4.057789655e-004
	,4.216872236e-004
	,4.376535619e-004
	,4.536425283e-004
	,4.696229516e-004
	,4.855686105e-004
	,5.014586396e-004
	,5.172810113e-004
	,5.330297388e-004
	,5.487053748e-004
	,5.643144463e-004
	,5.798686545e-004
	,5.953839062e-004
	,6.108790718e-004
	,6.263750666e-004
	,6.418953215e-004
	,6.574634225e-004
	,6.731027850e-004
	,6.888373462e-004
	,7.046743709e-004
	,7.206214354e-004
	,7.367343827e-004
	,7.530388523e-004
	,7.695638816e-004
	,7.861609254e-004
	,8.023157840e-004
	,8.187904296e-004
	,8.350558169e-004
	,8.513779439e-004
	,8.681117852e-004
	,8.850387950e-004
	,-3.335525915e-004
	,-3.183873330e-004
	,-3.037109298e-004
	,-2.894377119e-004
	,-2.753869128e-004
	,-2.613537047e-004
	,-2.472357811e-004
	,-2.330965860e-004
	,-2.190953754e-004
	,-2.053887919e-004
	,-1.920946040e-004
	,-1.792922034e-004
	,-1.670259290e-004
	,-1.553027257e-004
	,-1.440711252e-004
	,-1.331977955e-004
	,-1.224975383e-004
	,-1.118603378e-004
	,-1.014113725e-004
	,-9.139978190e-005
	,-8.197870654e-005
	,-7.313731983e-005
	,-6.486752140e-005
	,-5.707664666e-005
	,-4.967907952e-005
	,-4.276653201e-005
	,-3.647701213e-005
	,-3.081594196e-005
	,-2.572969498e-005
	,-2.123936653e-005
	,-1.738039010e-005
	,-1.411004516e-005
	,-1.135771781e-005
	,-9.043150199e-006
	,-7.089375738e-006
	,-5.425472836e-006
	,-3.996710900e-006
	,-2.772210435e-006
	,-1.721410719e-006
	,-8.038456300e-007
	,1.091305147e-017
	,6.935889034e-007
	,1.294539760e-006
	,1.827683116e-006
	,2.311157016e-006
	,2.759380594e-006
	,3.186306342e-006
	,3.607911517e-006
	,4.038193396e-006
	,4.486620471e-006
	,4.959558146e-006
	,5.457677392e-006
	,5.969129141e-006
	,6.473519582e-006
	,6.957454703e-006
	,7.425293671e-006
	,7.889684026e-006
	,8.363427860e-006
	,8.857590934e-006
	,9.380121581e-006
	,9.934862894e-006
	,1.051902207e-005
	,1.112142126e-005
	,1.173997077e-005
	,1.237675050e-005
	,1.301954297e-005
	,1.366998356e-005
	,1.433928982e-005
	,1.503169891e-005
	,1.575025753e-005
	,1.649709990e-005
	,1.727298250e-005
	,1.807830804e-005
	,1.891329391e-005
	,1.977733326e-005
	,2.066889915e-005
	,2.158565288e-005
	,2.252450198e-005
	,2.348204535e-005
	,2.445531957e-005
	,2.544238741e-005
	,2.644397990e-005
	,2.746360886e-005
	,2.850470708e-005
	,2.956863057e-005
	,3.065439364e-005
	,3.175957372e-005
	,3.288204849e-005
	,3.402028384e-005
	,3.517428064e-005
	,3.634631161e-005
	,3.753688409e-005
	,3.874523010e-005
	,3.997050302e-005
	,4.121147768e-005
	,4.246619115e-005
	,4.373243817e-005
	,4.500876226e-005
	,4.629514390e-005
	,4.759299412e-005
	,4.890466629e-005
	,5.023285157e-005
	,5.158006700e-005
	,5.294825808e-005
	,5.433845435e-005
	,5.575042818e-005
	,5.718232903e-005
	,5.863034602e-005
	,6.008870383e-005
	,6.155066508e-005
	,6.301127202e-005
	,6.446929658e-005
	,6.592509024e-005
	,6.737811746e-005
	,6.882576457e-005
	,7.026310731e-005
	,7.168362197e-005
	,7.308096672e-005
	,7.445118527e-005
	,7.579368371e-005
	,7.711047627e-005
	,7.840473646e-005
	,7.967980072e-005
	,8.093920437e-005
	,8.218689949e-005
	,8.342687667e-005
	,8.466244351e-005
	,8.589598506e-005
	,8.712942250e-005
	,8.836493622e-005
	,8.960554024e-005
	,9.085528140e-005
	,9.211873983e-005
	,9.339991238e-005
	,9.470686812e-005
	,9.604876028e-005
	,9.743429598e-005
	,9.887305754e-005
	,1.003761851e-004
	,1.019569685e-004
	,1.036314302e-004
	,1.054188494e-004
	,1.073421927e-004
	,1.094283889e-004
	,1.117083627e-004
	,1.142167692e-004
	,1.169913788e-004
	,1.200720969e-004
	,1.234996792e-004
	,1.273142510e-004
	,1.315537890e-004
	,1.362527286e-004
	,1.414408386e-004
	,1.471424527e-004
	,1.533760724e-004
	,1.601543012e-004
	,1.674850899e-004
	,1.753695112e-004
	,1.838042066e-004
	,1.927815892e-004
	,2.023019383e-004
	,2.123603104e-004
	,2.229258338e-004
	,2.339797689e-004
	,2.455013489e-004
	,2.574735931e-004
	,2.698912431e-004
	,2.827121464e-004
	,2.959096511e-004
	,3.094571650e-004
	,3.233268320e-004
	,3.374901689e-004
	,3.517864891e-004
	,3.658429431e-004
	,3.800943397e-004
	,3.945111481e-004
	,4.090669827e-004
	,4.237390837e-004
	,4.385087061e-004
	,4.533613747e-004
	,4.682869676e-004
	,4.832796176e-004
	,4.983359077e-004
	,5.134557472e-004
	,5.286452232e-004
	,5.439118880e-004
	,5.592654491e-004
	,5.747172762e-004
	,5.902800779e-004
	,6.059676176e-004
	,6.217944153e-004
	,6.377751139e-004
	,6.539269365e-004
	,6.702676637e-004
	,6.868173815e-004
	,7.036016372e-004
	,7.206414635e-004
	,7.373869590e-004
	,7.533572324e-004
	,7.695557465e-004
	,7.858774444e-004
	,-4.059440014e-004
	,-3.901810897e-004
	,-3.746359488e-004
	,-3.593278783e-004
	,-3.442689365e-004
	,-3.294302611e-004
	,-3.147482120e-004
	,-3.001643829e-004
	,-2.856594449e-004
	,-2.712395031e-004
	,-2.568701047e-004
	,-2.425826603e-004
	,-2.284748693e-004
	,-2.146122500e-004
	,-2.010478867e-004
	,-1.878416591e-004
	,-1.750489677e-004
	,-1.627182601e-004
	,-1.509009418e-004
	,-1.396468479e-004
	,-1.289914822e-004
	,-1.189489568e-004
	,-1.095119599e-004
	,-1.006588921e-004
	,-9.236228177e-005
	,-8.456808369e-005
	,-7.710878716e-005
	,-6.958671273e-005
	,-6.171349281e-005
	,-5.374656701e-005
	,-4.602442713e-005
	,-3.880297888e-005
	,-3.222774000e-005
	,-2.632068422e-005
	,-2.103658655e-005
	,-1.632864178e-005
	,-1.218751515e-005
	,-8.565746691e-006
	,-5.382970948e-006
	,-2.553725010e-006
	,1.044157642e-018
	,2.336389270e-006
	,4.495446505e-006
	,6.512959804e-006
	,8.407846037e-006
	,1.016780172e-005
	,1.180037282e-005
	,1.338213289e-005
	,1.496123979e-005
	,1.655372386e-005
	,1.815380789e-005
	,1.974387172e-005
	,2.131277052e-005
	,2.285319092e-005
	,2.435251392e-005
	,2.582266351e-005
	,2.729320761e-005
	,2.877313158e-005
	,3.025064184e-005
	,3.170048275e-005
	,3.310795161e-005
	,3.451350882e-005
	,3.595699374e-005
	,3.745388194e-005
	,3.900548976e-005
	,4.059671577e-005
	,4.217242499e-005
	,4.365645707e-005
	,4.507669080e-005
	,4.648866568e-005
	,4.790578034e-005
	,4.930931670e-005
	,5.066108693e-005
	,5.199293435e-005
	,5.333217760e-005
	,5.468503601e-005
	,5.605611568e-005
	,5.745403597e-005
	,5.888351777e-005
	,6.034552893e-005
	,6.184277250e-005
	,6.337869615e-005
	,6.495293604e-005
	,6.655676500e-005
	,6.816830092e-005
	,6.975513580e-005
	,7.129402426e-005
	,7.278451121e-005
	,7.424075933e-005
	,7.567909954e-005
	,7.711192410e-005
	,7.854627628e-005
	,7.998463358e-005
	,8.142539113e-005
	,8.286933257e-005
	,8.432203550e-005
	,8.578390564e-005
	,8.725043978e-005
	,8.871753979e-005
	,9.018476095e-005
	,9.165250967e-005
	,9.311854846e-005
	,9.457840071e-005
	,9.602894220e-005
	,9.747029648e-005
	,9.890351092e-005
	,1.003287686e-004
	,1.017466382e-004
	,1.031592130e-004
	,1.045691738e-004
	,1.059789859e-004
	,1.073912919e-004
	,1.088090277e-004
	,1.102347204e-004
	,1.116698183e-004
	,1.131154545e-004
	,1.145742460e-004
	,1.160487125e-004
	,1.175399540e-004
	,1.190478441e-004
	,1.205711255e-004
	,1.221072742e-004
	,1.236524185e-004
	,1.252017440e-004
	,1.267506665e-004
	,1.282963027e-004
	,1.298379157e-004
	,1.313756504e-004
	,1.329090992e-004
	,1.344364756e-004
	,1.359544947e-004
	,1.374591109e-004
	,1.389470877e-004
	,1.404173607e-004
	,1.418708094e-004
	,1.433087289e-004
	,1.447316826e-004
	,1.461397122e-004
	,1.475334076e-004
	,1.489136015e-004
	,1.502795991e-004
	,1.516380082e-004
	,1.529962104e-004
	,1.543602115e-004
	,1.557370229e-004
	,1.571349733e-004
	,1.585638121e-004
	,1.600350622e-004
	,1.615625023e-004
	,1.631625361e-004
	,1.648545002e-004
	,1.666609513e-004
	,1.686078278e-004
	,1.707244897e-004
	,1.730433921e-004
	,1.755994828e-004
	,1.784291705e-004
	,1.815692318e-004
	,1.850554238e-004
	,1.889211275e-004
	,1.931961011e-004
	,1.979055027e-004
	,2.030693000e-004
	,2.087019944e-004
	,2.148126784e-004
	,2.214053679e-004
	,2.284794818e-004
	,2.360304429e-004
	,2.440503035e-004
	,2.525283864e-004
	,2.614518809e-004
	,2.708064023e-004
	,2.805765316e-004
	,2.907483354e-004
	,3.013047489e-004
	,3.122292334e-004
	,3.235072249e-004
	,3.351314342e-004
	,3.471047041e-004
	,3.592505558e-004
	,3.712785245e-004
	,3.835945263e-004
	,3.961891940e-004
	,4.090593148e-004
	,4.221954062e-004
	,4.355774892e-004
	,4.491938205e-004
	,4.630589090e-004
	,4.771576459e-004
	,4.914840804e-004
	,5.060542580e-004
	,5.208667254e-004
	,5.359261807e-004
	,5.512364074e-004
	,5.668028831e-004
	,5.826334995e-004
	,5.987406630e-004
	,6.151374792e-004
	,6.317749633e-004
	,6.483362379e-004
	,6.647834647e-004
	,-4.618078582e-004
	,-4.459378313e-004
	,-4.302266580e-004
	,-4.146885576e-004
	,-3.992590510e-004
	,-3.838926123e-004
	,-3.685333616e-004
	,-3.530909372e-004
	,-3.374856618e-004
	,-3.217635997e-004
	,-3.060992361e-004
	,-2.906686103e-004
	,-2.755725743e-004
	,-2.608498815e-004
	,-2.465096005e-004
	,-2.325467666e-004
	,-2.189487007e-004
	,-2.057059145e-004
	,-1.928219122e-004
	,-1.802971335e-004
	,-1.680955331e-004
	,-1.562113314e-004
	,-1.447490796e-004
	,-1.337684044e-004
	,-1.232872069e-004
	,-1.132902189e-004
	,-1.037122364e-004
	,-9.442084491e-005
	,-8.526052617e-005
	,-7.617698496e-005
	,-6.728619800e-005
	,-5.873361109e-005
	,-5.056208770e-005
	,-4.276933889e-005
	,-3.542496762e-005
	,-2.856334941e-005
	,-2.215409594e-005
	,-1.614215246e-005
	,-1.046984718e-005
	,-5.093225035e-006
	,-7.937057909e-018
	,4.783248954e-006
	,9.236432291e-006
	,1.339705492e-005
	,1.732956128e-005
	,2.107982895e-005
	,2.464128910e-005
	,2.798432597e-005
	,3.107744263e-005
	,3.384899171e-005
	,3.639458876e-005
	,3.884146989e-005
	,4.123908568e-005
	,4.360104978e-005
	,4.593005272e-005
	,4.823423302e-005
	,5.051042383e-005
	,5.272352956e-005
	,5.487895981e-005
	,5.701327521e-005
	,5.913939860e-005
	,6.125644307e-005
	,6.335871846e-005
	,6.543883112e-005
	,6.748955604e-005
	,6.950673057e-005
	,7.149278103e-005
	,7.345407497e-005
	,7.539328113e-005
	,7.730654105e-005
	,7.918154310e-005
	,8.098286927e-005
	,8.269482139e-005
	,8.434845275e-005
	,8.598512145e-005
	,8.762407333e-005
	,8.926397260e-005
	,9.089509402e-005
	,9.247440176e-005
	,9.400043944e-005
	,9.553448406e-005
	,9.708782151e-005
	,9.866026915e-005
	,1.002491092e-004
	,1.018487346e-004
	,1.034512932e-004
	,1.050508278e-004
	,1.066459242e-004
	,1.082349251e-004
	,1.098197097e-004
	,1.114063780e-004
	,1.129970206e-004
	,1.145912658e-004
	,1.161891695e-004
	,1.177915638e-004
	,1.193985045e-004
	,1.210081359e-004
	,1.226146992e-004
	,1.242087741e-004
	,1.257910320e-004
	,1.273702233e-004
	,1.289499695e-004
	,1.305302443e-004
	,1.321095198e-004
	,1.336853663e-004
	,1.352546230e-004
	,1.368135536e-004
	,1.383587485e-004
	,1.398887481e-004
	,1.414051256e-004
	,1.429114105e-004
	,1.444115319e-004
	,1.459097460e-004
	,1.474097525e-004
	,1.489136595e-004
	,1.504223323e-004
	,1.519361500e-004
	,1.534550568e-004
	,1.549782034e-004
	,1.565035727e-004
	,1.580283811e-004
	,1.595511873e-004
	,1.610705258e-004
	,1.625822843e-004
	,1.640793800e-004
	,1.655531604e-004
	,1.669972668e-004
	,1.684108000e-004
	,1.697970554e-004
	,1.711608752e-004
	,1.725072271e-004
	,1.738408262e-004
	,1.751658070e-004
	,1.764853619e-004
	,1.778017761e-004
	,1.791165857e-004
	,1.804306922e-004
	,1.817444811e-004
	,1.830579246e-004
	,1.843706268e-004
	,1.856818161e-004
	,1.869903353e-004
	,1.882946905e-004
	,1.895931968e-004
	,1.908841259e-004
	,1.921655755e-004
	,1.934343625e-004
	,1.946832842e-004
	,1.959107706e-004
	,1.971199721e-004
	,1.983118447e-004
	,1.994879407e-004
	,2.006505862e-004
	,2.018028014e-004
	,2.029490273e-004
	,2.040960495e-004
	,2.052533783e-004
	,2.064328930e-004
	,2.076490641e-004
	,2.089192852e-004
	,2.102644700e-004
	,2.117086103e-004
	,2.132783729e-004
	,2.150020421e-004
	,2.169090833e-004
	,2.190288774e-004
	,2.213892611e-004
	,2.240157575e-004
	,2.269322771e-004
	,2.301640867e-004
	,2.337433751e-004
	,2.376995376e-004
	,2.420599127e-004
	,2.468449747e-004
	,2.520688522e-004
	,2.577408335e-004
	,2.638663974e-004
	,2.704480412e-004
	,2.774859177e-004
	,2.849783536e-004
	,2.929223021e-004
	,3.013136976e-004
	,3.101477568e-004
	,3.194192277e-004
	,3.291225951e-004
	,3.392523036e-004
	,3.498032892e-004
	,3.604968409e-004
	,3.712785312e-004
	,3.824302486e-004
	,3.939423189e-004
	,4.058101080e-004
	,4.180324487e-004
	,4.306043514e-004
	,4.435188493e-004
	,4.567576347e-004
	,4.703024603e-004
	,4.841698052e-004
	,4.983657597e-004
	,5.128882139e-004
	,5.277327939e-004
	,-5.042800303e-004
	,-4.888972183e-004
	,-4.734695406e-004
	,-4.578562079e-004
	,-4.420257625e-004
	,-4.259654713e-004
	,-4.096490393e-004
	,-3.930952086e-004
	,-3.764277441e-004
	,-3.598233541e-004
	,-3.434483480e-004
	,-3.273887150e-004
	,-3.116561275e-004
	,-2.962372335e-004
	,-2.811285920e-004
	,-2.663334164e-004
	,-2.518507726e-004
	,-2.376708598e-004
	,-2.237698765e-004
	,-2.101530812e-004
	,-1.968888892e-004
	,-1.840276675e-004
	,-1.715737509e-004
	,-1.595115074e-004
	,-1.478044133e-004
	,-1.363965073e-004
	,-1.252207436e-004
	,-1.142247417e-004
	,-1.034185431e-004
	,-9.285997904e-005
	,-8.259855393e-005
	,-7.269847275e-005
	,-6.319896150e-005
	,-5.409658568e-005
	,-4.536634009e-005
	,-3.695966686e-005
	,-2.885038614e-005
	,-2.108612761e-005
	,-1.369742188e-005
	,-6.675755846e-006
	,1.905880511e-017
	,6.358205687e-006
	,1.243363945e-005
	,1.826310329e-005
	,2.388100419e-005
	,2.931596114e-005
	,3.458816579e-005
	,3.970714312e-005
	,4.466608887e-005
	,4.942434865e-005
	,5.389620178e-005
	,5.804704225e-005
	,6.193947815e-005
	,6.561903826e-005
	,6.909672351e-005
	,7.238460095e-005
	,7.549539969e-005
	,7.841336094e-005
	,8.114156888e-005
	,8.376427283e-005
	,8.635437325e-005
	,8.893861742e-005
	,9.152265179e-005
	,9.410508375e-005
	,9.668198785e-005
	,9.924744724e-005
	,1.017916060e-004
	,1.043068854e-004
	,1.067840113e-004
	,1.091980097e-004
	,1.115052091e-004
	,1.136806162e-004
	,1.157811980e-004
	,1.178557978e-004
	,1.198933490e-004
	,1.218408039e-004
	,1.236993999e-004
	,1.255268804e-004
	,1.273477684e-004
	,1.291636961e-004
	,1.309705509e-004
	,1.327638321e-004
	,1.345399249e-004
	,1.362901616e-004
	,1.379641177e-004
	,1.395102204e-004
	,1.410169653e-004
	,1.425117957e-004
	,1.439811974e-004
	,1.454291328e-004
	,1.468731025e-004
	,1.483187289e-004
	,1.497654212e-004
	,1.512108748e-004
	,1.526533692e-004
	,1.540930012e-004
	,1.555299667e-004
	,1.569636510e-004
	,1.583929321e-004
	,1.598163337e-004
	,1.612318170e-004
	,1.626358749e-004
	,1.640209436e-004
	,1.653758541e-004
	,1.667020803e-004
	,1.680108384e-004
	,1.693099627e-004
	,1.706022528e-004
	,1.718881927e-004
	,1.731675834e-004
	,1.744400122e-004
	,1.757050396e-004
	,1.769622860e-004
	,1.782113948e-004
	,1.794519368e-004
	,1.806834184e-004
	,1.819053313e-004
	,1.831171821e-004
	,1.843185200e-004
	,1.855089777e-004
	,1.866882311e-004
	,1.878556804e-004
	,1.890103098e-004
	,1.901508987e-004
	,1.912758950e-004
	,1.923833418e-004
	,1.934726985e-004
	,1.945458406e-004
	,1.956045403e-004
	,1.966496706e-004
	,1.976817095e-004
	,1.987009924e-004
	,1.997076571e-004
	,2.007016311e-004
	,2.016826761e-004
	,2.026504226e-004
	,2.036044515e-004
	,2.045444287e-004
	,2.054700210e-004
	,2.063807826e-004
	,2.072761535e-004
	,2.081554880e-004
	,2.090180630e-004
	,2.098630065e-004
	,2.106892727e-004
	,2.114958169e-004
	,2.122817744e-004
	,2.130466924e-004
	,2.137908185e-004
	,2.145152405e-004
	,2.152217714e-004
	,2.159126187e-004
	,2.165899175e-004
	,2.172553104e-004
	,2.179089939e-004
	,2.185496761e-004
	,2.191810972e-004
	,2.198064287e-004
	,2.204275945e-004
	,2.210465916e-004
	,2.216658274e-004
	,2.222883070e-004
	,2.229178166e-004
	,2.235591352e-004
	,2.242182767e-004
	,2.249027633e-004
	,2.256219212e-004
	,2.263871898e-004
	,2.272124364e-004
	,2.281142696e-004
	,2.291123294e-004
	,2.302294866e-004
	,2.314917484e-004
	,2.329280368e-004
	,2.345693759e-004
	,2.364480766e-004
	,2.385969420e-004
	,2.410476576e-004
	,2.438299562e-004
	,2.469710072e-004
	,2.504941359e-004
	,2.544185461e-004
	,2.587595298e-004
	,2.635282469e-004
	,2.687319283e-004
	,2.743766929e-004
	,2.804660142e-004
	,2.870043182e-004
	,2.939961482e-004
	,3.014445464e-004
	,3.093508959e-004
	,3.177150887e-004
	,3.265363557e-004
	,3.358140882e-004
	,3.455491937e-004
	,3.555109528e-004
	,3.655716937e-004
	,3.760593138e-004
	,3.869678483e-004
	,3.982911193e-004
	,4.100170281e-004
	,-5.325391762e-004
	,-5.171615124e-004
	,-5.015947093e-004
	,-4.858006387e-004
	,-4.697646942e-004
	,-4.534517881e-004
	,-4.369095080e-004
	,-4.203202840e-004
	,-4.038336636e-004
	,-3.875271303e-004
	,-3.714349129e-004
	,-3.555656007e-004
	,-3.399286893e-004
	,-3.245231175e-004
	,-3.093153939e-004
	,-2.942380312e-004
	,-2.792378319e-004
	,-2.643213340e-004
	,-2.495711166e-004
	,-2.350905834e-004
	,-2.209178080e-004
	,-2.070631998e-004
	,-1.935298289e-004
	,-1.802874677e-004
	,-1.672896965e-004
	,-1.545141019e-004
	,-1.419751434e-004
	,-1.297008361e-004
	,-1.177162355e-004
	,-1.060495852e-004
	,-9.474026760e-005
	,-8.381510648e-005
	,-7.327491280e-005
	,-6.310179188e-005
	,-5.326520282e-005
	,-4.372376156e-005
	,-3.442969383e-005
	,-2.536176337e-005
	,-1.656460852e-005
	,-8.100656270e-006
	,-1.420302225e-017
	,7.740497507e-006
	,1.513732169e-005
	,2.221561779e-005
	,2.900591946e-005
	,3.553965399e-005
	,4.184464677e-005
	,4.793770391e-005
	,5.381166457e-005
	,5.942030050e-005
	,6.471302043e-005
	,6.972264656e-005
	,7.452375551e-005
	,7.916513147e-005
	,8.367042558e-005
	,8.804765675e-005
	,9.229614376e-005
	,9.641253737e-005
	,1.003933075e-004
	,1.042347337e-004
	,1.079368740e-004
	,1.115095333e-004
	,1.149684969e-004
	,1.183269368e-004
	,1.215919991e-004
	,1.247646393e-004
	,1.278389605e-004
	,1.308001337e-004
	,1.336265601e-004
	,1.363137089e-004
	,1.388956493e-004
	,1.414134597e-004
	,1.438904429e-004
	,1.463359441e-004
	,1.487517256e-004
	,1.511341059e-004
	,1.534719517e-004
	,1.557408290e-004
	,1.579063190e-004
	,1.599581644e-004
	,1.619229358e-004
	,1.638209266e-004
	,1.656529228e-004
	,1.674041690e-004
	,1.690577777e-004
	,1.706372916e-004
	,1.721814658e-004
	,1.737062542e-004
	,1.752127692e-004
	,1.766907421e-004
	,1.780947563e-004
	,1.793584430e-004
	,1.805633618e-004
	,1.817576649e-004
	,1.829418593e-004
	,1.841115064e-004
	,1.852631311e-004
	,1.863944511e-004
	,1.875041740e-004
	,1.885917938e-004
	,1.896573977e-004
	,1.907011943e-004
	,1.917215696e-004
	,1.927126013e-004
	,1.936741144e-004
	,1.946155206e-004
	,1.955404827e-004
	,1.964459607e-004
	,1.973236662e-004
	,1.981728589e-004
	,1.990049460e-004
	,1.998267669e-004
	,2.006400220e-004
	,2.014448073e-004
	,2.022408399e-004
	,2.030276995e-004
	,2.038051560e-004
	,2.045732634e-004
	,2.053319681e-004
	,2.060810607e-004
	,2.068200345e-004
	,2.075492679e-004
	,2.082698153e-004
	,2.089820394e-004
	,2.096857969e-004
	,2.103808368e-004
	,2.110669523e-004
	,2.117440006e-004
	,2.124118583e-004
	,2.130703045e-004
	,2.137187594e-004
	,2.143563145e-004
	,2.149831979e-004
	,2.156006874e-004
	,2.162094650e-004
	,2.168097580e-004
	,2.174016835e-004
	,2.179853450e-004
	,2.185608734e-004
	,2.191284585e-004
	,2.196883253e-004
	,2.202404979e-004
	,2.207847670e-004
	,2.213211781e-004
	,2.218500044e-004
	,2.223714744e-004
	,2.228857249e-004
	,2.233928675e-004
	,2.238930539e-004
	,2.243864701e-004
	,2.248731491e-004
	,2.253528528e-004
	,2.258252735e-004
	,2.262901464e-004
	,2.267472501e-004
	,2.271964098e-004
	,2.276375469e-004
	,2.280707540e-004
	,2.284962938e-004
	,2.289145387e-004
	,2.293260347e-004
	,2.297313843e-004
	,2.301302539e-004
	,2.305223688e-004
	,2.309109842e-004
	,2.312982303e-004
	,2.316856134e-004
	,2.320747070e-004
	,2.324672599e-004
	,2.328653434e-004
	,2.332715810e-004
	,2.336893627e-004
	,2.341230608e-004
	,2.345782266e-004
	,2.350617902e-004
	,2.355823742e-004
	,2.361506922e-004
	,2.367799032e-004
	,2.374858959e-004
	,2.382874973e-004
	,2.392065700e-004
	,2.402679451e-004
	,2.414991175e-004
	,2.429296683e-004
	,2.445905416e-004
	,2.465131724e-004
	,2.487284750e-004
	,2.512658599e-004
	,2.541524087e-004
	,2.574123002e-004
	,2.610667231e-004
	,2.651342056e-004
	,2.696291465e-004
	,2.745635212e-004
	,2.799457423e-004
	,2.857827257e-004
	,2.920783727e-004
	,2.988352457e-004
	,3.060552551e-004
	,3.137387367e-004
	,3.218857604e-004
	,-5.552268852e-004
	,-5.389517104e-004
	,-5.225042562e-004
	,-5.059444557e-004
	,-4.892963931e-004
	,-4.726410776e-004
	,-4.561317905e-004
	,-4.398403728e-004
	,-4.237789493e-004
	,-4.079620908e-004
	,-3.923660450e-004
	,-3.769299473e-004
	,-3.615960070e-004
	,-3.463408264e-004
	,-3.311497250e-004
	,-3.159903914e-004
	,-3.008550768e-004
	,-2.857741369e-004
	,-2.707935146e-004
	,-2.559275629e-004
	,-2.411754547e-004
	,-2.265350235e-004
	,-2.120317775e-004
	,-1.977252385e-004
	,-1.836576746e-004
	,-1.698334556e-004
	,-1.562493736e-004
	,-1.429507352e-004
	,-1.299984690e-004
	,-1.174205613e-004
	,-1.052180875e-004
	,-9.337827070e-005
	,-8.188089324e-005
	,-7.070106709e-005
	,-5.980966655e-005
	,-4.917391207e-005
	,-3.876706690e-005
	,-2.859482704e-005
	,-1.871110374e-005
	,-9.172283062e-006
	,-4.062450521e-017
	,8.810235369e-006
	,1.727294542e-005
	,2.540534286e-005
	,3.322430266e-005
	,4.074094164e-005
	,4.795073386e-005
	,5.484224835e-005
	,6.139549737e-005
	,6.758833556e-005
	,7.344952482e-005
	,7.904217495e-005
	,8.441884469e-005
	,8.961436164e-005
	,9.465196842e-005
	,9.954793425e-005
	,1.043139768e-004
	,1.089585300e-004
	,1.134874556e-004
	,1.179044677e-004
	,1.222113921e-004
	,1.264083329e-004
	,1.304938301e-004
	,1.344651128e-004
	,1.383185221e-004
	,1.420500455e-004
	,1.456557733e-004
	,1.491321117e-004
	,1.524759350e-004
	,1.556853801e-004
	,1.587609739e-004
	,1.617045480e-004
	,1.645155919e-004
	,1.671893941e-004
	,1.697214937e-004
	,1.721162809e-004
	,1.743877518e-004
	,1.765500775e-004
	,1.786095648e-004
	,1.805635629e-004
	,1.824105343e-004
	,1.841635690e-004
	,1.858426294e-004
	,1.874619556e-004
	,1.890293984e-004
	,1.905492856e-004
	,1.920242314e-004
	,1.934559511e-004
	,1.948455507e-004
	,1.961932787e-004
	,1.974963227e-004
	,1.987481024e-004
	,1.999559460e-004
	,2.011271384e-004
	,2.022618877e-004
	,2.033545042e-004
	,2.043832633e-004
	,2.052929816e-004
	,2.061032186e-004
	,2.068927243e-004
	,2.076789322e-004
	,2.084614457e-004
	,2.092378404e-004
	,2.100059402e-004
	,2.107640826e-004
	,2.115110792e-004
	,2.122461337e-004
	,2.129687532e-004
	,2.136786771e-004
	,2.143757720e-004
	,2.150597889e-004
	,2.157299458e-004
	,2.163840927e-004
	,2.170173432e-004
	,2.176244140e-004
	,2.182077551e-004
	,2.187727265e-004
	,2.193200618e-004
	,2.198499482e-004
	,2.203674649e-004
	,2.208758051e-004
	,2.213755413e-004
	,2.218665247e-004
	,2.223485641e-004
	,2.228216571e-004
	,2.232860820e-004
	,2.237423427e-004
	,2.241908893e-004
	,2.246320214e-004
	,2.250663600e-004
	,2.254944548e-004
	,2.259167201e-004
	,2.263334959e-004
	,2.267450091e-004
	,2.271511883e-004
	,2.275516975e-004
	,2.279464678e-004
	,2.283350397e-004
	,2.287178029e-004
	,2.290962832e-004
	,2.294712958e-004
	,2.298429422e-004
	,2.302111433e-004
	,2.305758084e-004
	,2.309368698e-004
	,2.312942680e-004
	,2.316479231e-004
	,2.319977294e-004
	,2.323436764e-004
	,2.326859913e-004
	,2.330248786e-004
	,2.333602743e-004
	,2.336920832e-004
	,2.340202948e-004
	,2.343449637e-004
	,2.346662009e-004
	,2.349841734e-004
	,2.352991083e-004
	,2.356113051e-004
	,2.359211265e-004
	,2.362288444e-004
	,2.365345041e-004
	,2.368380962e-004
	,2.371396473e-004
	,2.374392100e-004
	,2.377368743e-004
	,2.380327851e-004
	,2.383271476e-004
	,2.386201943e-004
	,2.389119618e-004
	,2.392013173e-004
	,2.394872625e-004
	,2.397718974e-004
	,2.400563398e-004
	,2.403412456e-004
	,2.406273543e-004
	,2.409156189e-004
	,2.412072861e-004
	,2.415039764e-004
	,2.418077362e-004
	,2.421210919e-004
	,2.424473059e-004
	,2.427908240e-004
	,2.431577728e-004
	,2.435564098e-004
	,2.439974126e-004
	,2.444939741e-004
	,2.450618504e-004
	,2.457194394e-004
	,2.464879243e-004
	,2.473913520e-004
	,2.484564618e-004
	,2.497123026e-004
	,2.511896506e-004
	,2.529201707e-004
	,2.549353979e-004
	,2.572655755e-004
	,2.599387963e-004
	,2.629804450e-004
	,2.664127878e-004
	,2.702547627e-004
	,-5.759871587e-004
	,-5.588551116e-004
	,-5.415719241e-004
	,-5.241822849e-004
	,-5.067795740e-004
	,-4.895384477e-004
	,-4.725602145e-004
	,-4.558696267e-004
	,-4.395113774e-004
	,-4.235199056e-004
	,-4.078907789e-004
	,-3.925908123e-004
	,-3.775549073e-004
	,-3.626770972e-004
	,-3.478389007e-004
	,-3.329396845e-004
	,-3.178762456e-004
	,-3.026091184e-004
	,-2.871904266e-004
	,-2.717480931e-004
	,-2.564213847e-004
	,-2.412955788e-004
	,-2.263957655e-004
	,-2.116994977e-004
	,-1.971836792e-004
	,-1.828679281e-004
	,-1.687725339e-004
	,-1.549051758e-004
	,-1.412882830e-004
	,-1.279504388e-004
	,-1.148990008e-004
	,-1.021257893e-004
	,-8.963073758e-005
	,-7.741828371e-005
	,-6.547496356e-005
	,-5.377684282e-005
	,-4.232809340e-005
	,-3.118254760e-005
	,-2.039875573e-005
	,-1.000351806e-005
	,-2.490737799e-017
	,9.620641049e-006
	,1.887445285e-005
	,2.777923746e-005
	,3.634916922e-005
	,4.458977253e-005
	,5.249362700e-005
	,6.004551193e-005
	,6.724577084e-005
	,7.412321632e-005
	,8.071650769e-005
	,8.705611027e-005
	,9.315667756e-005
	,9.901020700e-005
	,1.046130976e-004
	,1.100006234e-004
	,1.152049992e-004
	,1.202440641e-004
	,1.251283979e-004
	,1.298646633e-004
	,1.344570369e-004
	,1.389078592e-004
	,1.432174595e-004
	,1.473830180e-004
	,1.513962959e-004
	,1.552405661e-004
	,1.588926372e-004
	,1.623422250e-004
	,1.656083384e-004
	,1.687206721e-004
	,1.717009399e-004
	,1.745619842e-004
	,1.773113940e-004
	,1.799539576e-004
	,1.824929225e-004
	,1.849306079e-004
	,1.872686598e-004
	,1.895080606e-004
	,1.916489775e-004
	,1.936907164e-004
	,1.956326423e-004
	,1.974769389e-004
	,1.992302734e-004
	,2.009009344e-004
	,2.024957365e-004
	,2.040195857e-004
	,2.054760766e-004
	,2.068679806e-004
	,2.081974646e-004
	,2.094661036e-004
	,2.106748146e-004
	,2.118241567e-004
	,2.129158018e-004
	,2.139540096e-004
	,2.149440264e-004
	,2.158896063e-004
	,2.167928704e-004
	,2.176556541e-004
	,2.184807727e-004
	,2.192719234e-004
	,2.200321857e-004
	,2.207613879e-004
	,2.214506541e-004
	,2.220826302e-004
	,2.226393834e-004
	,2.231611113e-004
	,2.236747452e-004
	,2.241824681e-004
	,2.246821368e-004
	,2.251707321e-004
	,2.256459238e-004
	,2.261094323e-004
	,2.265648691e-004
	,2.270141113e-004
	,2.274576720e-004
	,2.278954833e-004
	,2.283271077e-004
	,2.287515379e-004
	,2.291667085e-004
	,2.295700794e-004
	,2.299616323e-004
	,2.303435314e-004
	,2.307174040e-004
	,2.310840681e-004
	,2.314439643e-004
	,2.317973860e-004
	,2.321445703e-004
	,2.324857280e-004
	,2.328210404e-004
	,2.331506087e-004
	,2.334742529e-004
	,2.337912491e-004
	,2.341017157e-004
	,2.344071589e-004
	,2.347082282e-004
	,2.350048332e-004
	,2.352966071e-004
	,2.355830705e-004
	,2.358637530e-004
	,2.361383394e-004
	,2.364068091e-004
	,2.366697023e-004
	,2.369275221e-004
	,2.371802468e-004
	,2.374279970e-004
	,2.376717867e-004
	,2.379127131e-004
	,2.381514611e-004
	,2.383884464e-004
	,2.386240129e-004
	,2.388584946e-004
	,2.390920215e-004
	,2.393245777e-004
	,2.395560763e-004
	,2.397864931e-004
	,2.400160327e-004
	,2.402449042e-004
	,2.404731668e-004
	,2.407007960e-004
	,2.409277331e-004
	,2.411539364e-004
	,2.413793959e-004
	,2.416041309e-004
	,2.418281899e-004
	,2.420516603e-004
	,2.422746872e-004
	,2.424974699e-004
	,2.427201153e-004
	,2.429425110e-004
	,2.431645313e-004
	,2.433861441e-004
	,2.436073936e-004
	,2.438283765e-004
	,2.440492249e-004
	,2.442700925e-004
	,2.444911404e-004
	,2.447125147e-004
	,2.449341946e-004
	,2.451551754e-004
	,2.453750093e-004
	,2.455955198e-004
	,2.458173984e-004
	,2.460410048e-004
	,2.462668158e-004
	,2.464955237e-004
	,2.467280940e-004
	,2.469658353e-004
	,2.472104838e-004
	,2.474642953e-004
	,2.477301437e-004
	,2.480116595e-004
	,2.483134184e-004
	,2.486412645e-004
	,2.490026580e-004
	,2.494069712e-004
	,2.498658003e-004
	,2.503932798e-004
	,2.510063627e-004
	,2.517250269e-004
	,2.525723139e-004
	,2.535742343e-004
	,-5.948621296e-004
	,-5.769932976e-004
	,-5.590278764e-004
	,-5.410490763e-004
	,-5.232245225e-004
	,-5.056825551e-004
	,-4.884440358e-004
	,-4.715197737e-004
	,-4.549491954e-004
	,-4.387351040e-004
	,-4.228400875e-004
	,-4.071901877e-004
	,-3.916860385e-004
	,-3.762628599e-004
	,-3.608866924e-004
	,-3.454833112e-004
	,-3.299930112e-004
	,-3.144323190e-004
	,-2.988933452e-004
	,-2.834680902e-004
	,-2.681801019e-004
	,-2.529915978e-004
	,-2.378672691e-004
	,-2.228410774e-004
	,-2.079704554e-004
	,-1.932889503e-004
	,-1.788126338e-004
	,-1.645385200e-004
	,-1.504553974e-004
	,-1.365731398e-004
	,-1.229055752e-004
	,-1.094413227e-004
	,-9.615439729e-005
	,-8.304074063e-005
	,-7.013365293e-005
	,-5.749644894e-005
	,-4.520134208e-005
	,-3.329427034e-005
	,-2.179137672e-005
	,-1.069488782e-005
	,-4.020830201e-018
	,1.030441217e-005
	,2.023086954e-005
	,2.978790876e-005
	,3.897687178e-005
	,4.779355281e-005
	,5.623781527e-005
	,6.432274129e-005
	,7.207187420e-005
	,7.951110325e-005
	,8.666415487e-005
	,9.355151658e-005
	,1.001905158e-004
	,1.065955164e-004
	,1.127779678e-004
	,1.187462911e-004
	,1.245056710e-004
	,1.300576204e-004
	,1.353980800e-004
	,1.405108864e-004
	,1.453565668e-004
	,1.498905717e-004
	,1.541250240e-004
	,1.581156379e-004
	,1.619115503e-004
	,1.655422579e-004
	,1.690244566e-004
	,1.723683592e-004
	,1.755808558e-004
	,1.786669866e-004
	,1.816306750e-004
	,1.844751321e-004
	,1.872031009e-004
	,1.898170143e-004
	,1.923190950e-004
	,1.947114085e-004
	,1.969958670e-004
	,1.991741802e-004
	,2.012477662e-004
	,2.032177309e-004
	,2.050852346e-004
	,2.068525025e-004
	,2.085235952e-004
	,2.101034997e-004
	,2.115963107e-004
	,2.130040841e-004
	,2.143269726e-004
	,2.155663173e-004
	,2.167295093e-004
	,2.178279080e-004
	,2.188708156e-004
	,2.198642351e-004
	,2.208122217e-004
	,2.217179602e-004
	,2.225842223e-004
	,2.234134786e-004
	,2.242078966e-004
	,2.249693197e-004
	,2.256992363e-004
	,2.263987148e-004
	,2.270682782e-004
	,2.277076858e-004
	,2.283156075e-004
	,2.288894028e-004
	,2.294261877e-004
	,2.299266091e-004
	,2.303969784e-004
	,2.308449373e-004
	,2.312747583e-004
	,2.316840717e-004
	,2.320585247e-004
	,2.323974767e-004
	,2.327245520e-004
	,2.330459862e-004
	,2.333604897e-004
	,2.336708543e-004
	,2.339787950e-004
	,2.342844124e-004
	,2.345875049e-004
	,2.348878497e-004
