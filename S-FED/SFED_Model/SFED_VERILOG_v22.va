	,9.580659455e-014
	,9.745929486e-014
	,9.916964204e-014
	,1.008822345e-013
	,1.025667868e-013
	,1.043568684e-013
	,1.060714451e-013
	,1.078939531e-013
	,1.096760977e-013
	,1.115471147e-013
	,1.133293116e-013
	,1.152046103e-013
	,1.170794913e-013
	,1.190311825e-013
	,1.209277333e-013
	,1.228544129e-013
	,1.248234399e-013
	,1.267623904e-013
	,1.286893833e-013
	,1.306742841e-013
	,1.326802804e-013
	,1.346882087e-013
	,1.367102354e-013
	,1.387155528e-013
	,1.407669773e-013
	,1.427765765e-013
	,1.447780822e-013
	,1.468541528e-013
	,1.488730987e-013
	,1.508890683e-013
	,1.529585075e-013
	,1.549804298e-013
	,1.570145184e-013
	,1.590265718e-013
	,1.610260410e-013
	,1.630272856e-013
	,1.650314021e-013
	,1.669303026e-013
	,1.689374998e-013
	,1.708418308e-013
	,1.728030254e-013
	,1.747143012e-013
	,1.765425007e-013
	,1.783702303e-013
	,1.801398431e-013
	,1.819468427e-013
	,1.836906084e-013
	,1.854138008e-013
	,1.871137047e-013
	,1.888096924e-013
	,1.904228127e-013
	,1.920617279e-013
	,1.937104075e-013
	,1.953618547e-013
	,1.969881857e-013
	,1.985485675e-013
	,2.001980826e-013
	,2.018041015e-013
	,2.034522589e-013
	,2.050939938e-013
	,2.067962475e-013
	,2.084418463e-013
	,2.100951733e-013
	,2.117771147e-013
	,2.134543045e-013
	,2.151532163e-013
	,2.168909771e-013
	,2.186722863e-013
	,2.203799182e-013
	,2.221528206e-013
	,2.239185694e-013
	,2.257219139e-013
	,2.274825977e-013
	,2.292901718e-013
	,2.311128886e-013
	,2.329389472e-013
	,2.347743526e-013
	,2.366402001e-013
	,2.385488129e-013
	,2.404264613e-013
	,2.423719388e-013
	,2.442849377e-013
	,2.462472289e-013
	,2.482379257e-013
	,2.502450708e-013
	,2.522832845e-013
	,2.543602429e-013
	,2.564980332e-013
	,2.586789021e-013
	,2.609545959e-013
	,2.632492443e-013
	,2.657104629e-013
	,2.682667675e-013
	,2.709811832e-013
	,2.738247300e-013
	,2.769215263e-013
	,2.803555880e-013
	,2.840963687e-013
	,2.883704352e-013
	,2.932486973e-013
	,2.989319270e-013
	,3.056151001e-013
	,3.136276498e-013
	,3.234159215e-013
	,3.353433935e-013
	,3.498303553e-013
	,3.677985824e-013
	,3.902753797e-013
	,4.186119503e-013
	,4.543705555e-013
	,4.998502823e-013
	,5.577729089e-013
	,6.318781716e-013
	,7.268719663e-013
	,8.489014651e-013
	,1.005911598e-012
	,1.207644163e-012
	,1.467457831e-012
	,1.803050036e-012
	,2.237014173e-012
	,2.798616474e-012
	,3.526305731e-012
	,4.469811509e-012
	,5.694256811e-012
	,7.284523419e-012
	,9.351435302e-012
	,1.203888271e-011
	,1.553642688e-011
	,2.009148892e-011
	,2.602783936e-011
	,3.376941893e-011
	,4.387191872e-011
	,5.706371161e-011
	,7.424321182e-011
	,9.667799664e-011
	,1.260178723e-010
	,1.644177224e-010
	,2.147150866e-010
	,-1.095411459e-007
	,-7.730538406e-008
	,-5.453112960e-008
	,-3.844972014e-008
	,-2.709892584e-008
	,-1.908964887e-008
	,-1.343942785e-008
	,-9.453994183e-009
	,-6.643269329e-009
	,-4.661874791e-009
	,-3.266685999e-009
	,-2.286130206e-009
	,-1.598434576e-009
	,-1.116960269e-009
	,-7.802576615e-010
	,-5.449597001e-010
	,-3.805894582e-010
	,-2.657886069e-010
	,-1.856143598e-010
	,-1.296226179e-010
	,-9.051878339e-011
	,-6.320811692e-011
	,-4.413260017e-011
	,-3.080789365e-011
	,-2.149961366e-011
	,-1.499645975e-011
	,-1.045280589e-011
	,-7.278022690e-012
	,-5.059659420e-012
	,-3.509856635e-012
	,-2.427388530e-012
	,-1.671700855e-012
	,-1.144515303e-012
	,-7.770952895e-013
	,-5.211509585e-013
	,-3.429434864e-013
	,-2.187979192e-013
	,-1.322643774e-013
	,-7.188664155e-014
	,-2.963482629e-014
	,3.916057951e-018
	,2.095531658e-014
	,3.585040149e-014
	,4.659062988e-014
	,5.441008342e-014
	,6.029069096e-014
	,6.477545050e-014
	,6.828804567e-014
	,7.118349558e-014
	,7.363233887e-014
	,7.575879830e-014
	,7.766433027e-014
	,7.950730704e-014
	,8.122642657e-014
	,8.286816144e-014
	,8.455360141e-014
	,8.613664509e-014
	,8.777550806e-014
	,8.944481318e-014
	,9.107939441e-014
	,9.272467999e-014
	,9.442030216e-014
	,9.611404454e-014
	,9.782648037e-014
	,9.957886173e-014
	,1.013833028e-013
	,1.031596515e-013
	,1.049812718e-013
	,1.068082181e-013
	,1.086856054e-013
	,1.105859158e-013
	,1.125066427e-013
	,1.144554098e-013
	,1.164668888e-013
	,1.184519463e-013
	,1.204562194e-013
	,1.225388693e-013
	,1.245867954e-013
	,1.267040125e-013
	,1.288027972e-013
	,1.309613175e-013
	,1.331018232e-013
	,1.353564738e-013
	,1.375471593e-013
	,1.397972671e-013
	,1.420345819e-013
	,1.442906424e-013
	,1.465618456e-013
	,1.488527344e-013
	,1.511883726e-013
	,1.535205123e-013
	,1.558579781e-013
	,1.582107954e-013
	,1.605670591e-013
	,1.629645215e-013
	,1.653665267e-013
	,1.677600207e-013
	,1.701871420e-013
	,1.726214169e-013
	,1.750153286e-013
	,1.774819254e-013
	,1.799148949e-013
	,1.823311552e-013
	,1.847349358e-013
	,1.871716127e-013
	,1.896016581e-013
	,1.919960919e-013
	,1.943812835e-013
	,1.967722188e-013
	,1.991127653e-013
	,2.014143063e-013
	,2.037941195e-013
	,2.060713798e-013
	,2.083301555e-013
	,2.105715954e-013
	,2.127875537e-013
	,2.149359962e-013
	,2.170957697e-013
	,2.191996194e-013
	,2.212573099e-013
	,2.233147915e-013
	,2.253405778e-013
	,2.273432844e-013
	,2.293334069e-013
	,2.312872912e-013
	,2.332498957e-013
	,2.352319769e-013
	,2.371949991e-013
	,2.391354638e-013
	,2.411374916e-013
	,2.431291806e-013
	,2.451505285e-013
	,2.470885912e-013
	,2.491261784e-013
	,2.511901871e-013
	,2.531823982e-013
	,2.552661969e-013
	,2.573294223e-013
	,2.594313922e-013
	,2.614935733e-013
	,2.635925669e-013
	,2.657458134e-013
	,2.678711240e-013
	,2.700549692e-013
	,2.721926030e-013
	,2.743699212e-013
	,2.765917277e-013
	,2.787912900e-013
	,2.810861995e-013
	,2.833054996e-013
	,2.855386893e-013
	,2.878130255e-013
	,2.901498647e-013
	,2.925095224e-013
	,2.948424453e-013
	,2.972792267e-013
	,2.996787255e-013
	,3.021513272e-013
	,3.046776074e-013
	,3.072634142e-013
	,3.098562703e-013
	,3.125359621e-013
	,3.153105834e-013
	,3.182091140e-013
	,3.211764659e-013
	,3.243195780e-013
	,3.276779783e-013
	,3.312706211e-013
	,3.351436137e-013
	,3.393954882e-013
	,3.441364735e-013
	,3.495313121e-013
	,3.557622393e-013
	,3.630027700e-013
	,3.714631794e-013
	,3.816027629e-013
	,3.937734065e-013
	,4.087178881e-013
	,4.270848917e-013
	,4.499267336e-013
	,4.785121152e-013
	,5.144282572e-013
	,5.599082973e-013
	,6.176719772e-013
	,6.911905890e-013
	,7.852514861e-013
	,9.057842549e-013
	,1.060582397e-012
	,1.259634592e-012
	,1.516232254e-012
	,1.847323826e-012
	,2.274976153e-012
	,2.827865891e-012
	,3.542229374e-012
	,4.465854657e-012
	,5.662721309e-012
	,7.215103322e-012
	,9.230158345e-012
	,1.184785565e-011
	,1.525074872e-011
	,1.967766302e-011
	,-1.102408449e-007
	,-7.781960901e-008
	,-5.490792321e-008
	,-3.872490762e-008
	,-2.729910017e-008
	,-1.923447294e-008
	,-1.354340245e-008
	,-9.527836176e-009
	,-6.695018404e-009
	,-4.697740994e-009
	,-3.291495355e-009
	,-2.303428305e-009
	,-1.610634206e-009
	,-1.125647102e-009
	,-7.864829845e-010
	,-5.494377152e-010
	,-3.838169146e-010
	,-2.681166131e-010
	,-1.872933842e-010
	,-1.308332159e-010
	,-9.139112061e-011
	,-6.383595260e-011
	,-4.458372355e-011
	,-3.113134272e-011
	,-2.173065799e-011
	,-1.516086868e-011
	,-1.056907911e-011
	,-7.359616772e-012
	,-5.116451667e-012
	,-3.548983249e-012
	,-2.454141273e-012
	,-1.689835705e-012
	,-1.156801763e-012
	,-7.853870401e-013
	,-5.266716908e-013
	,-3.465451105e-013
	,-2.211309466e-013
	,-1.337294643e-013
	,-7.267427326e-014
	,-2.999323945e-014
	,-1.112225646e-017
	,2.119102127e-014
	,3.627528609e-014
	,4.716344345e-014
	,5.510800742e-014
	,6.105310217e-014
	,6.561388874e-014
	,6.921133552e-014
	,7.215163928e-014
	,7.463228235e-014
	,7.682249797e-014
	,7.879794766e-014
	,8.068640487e-014
	,8.245925505e-014
	,8.415419840e-014
	,8.586846181e-014
	,8.756471058e-014
	,8.926482335e-014
	,9.096253417e-014
	,9.263847077e-014
	,9.436709368e-014
	,9.611592432e-014
	,9.789994880e-014
	,9.966486209e-014
	,1.014885710e-013
	,1.033541052e-013
	,1.052280985e-013
	,1.071070002e-013
	,1.090549318e-013
	,1.109755543e-013
	,1.129771122e-013
	,1.149757460e-013
	,1.170499368e-013
	,1.191347276e-013
	,1.212499605e-013
	,1.233763155e-013
	,1.255721705e-013
	,1.277822805e-013
	,1.300370878e-013
	,1.322806685e-013
	,1.345991798e-013
	,1.369154979e-013
	,1.392612661e-013
	,1.416603994e-013
	,1.441026634e-013
	,1.464803358e-013
	,1.489716832e-013
	,1.514719597e-013
	,1.540340081e-013
	,1.565614370e-013
	,1.591808189e-013
	,1.617379068e-013
	,1.643787497e-013
	,1.670408968e-013
	,1.697270635e-013
	,1.724037268e-013
	,1.751315622e-013
	,1.778881688e-013
	,1.806756352e-013
	,1.834510397e-013
	,1.862588705e-013
	,1.890598610e-013
	,1.919051832e-013
	,1.947298277e-013
	,1.975996916e-013
	,2.005280900e-013
	,2.034017135e-013
	,2.063038471e-013
	,2.092205491e-013
	,2.121161034e-013
	,2.150143208e-013
	,2.179595851e-013
	,2.208398922e-013
	,2.237777941e-013
	,2.266365881e-013
	,2.295399749e-013
	,2.324322918e-013
	,2.352931745e-013
	,2.380948438e-013
	,2.409459620e-013
	,2.437428796e-013
	,2.464948911e-013
	,2.492187058e-013
	,2.518944815e-013
	,2.545839378e-013
	,2.572113088e-013
	,2.597699109e-013
	,2.623178609e-013
	,2.648365175e-013
	,2.673002425e-013
	,2.697216722e-013
	,2.721606988e-013
	,2.745797265e-013
	,2.769502453e-013
	,2.793675499e-013
	,2.816962955e-013
	,2.840995017e-013
	,2.864743544e-013
	,2.888597026e-013
	,2.912727255e-013
	,2.937004733e-013
	,2.961420064e-013
	,2.985910585e-013
	,3.010460633e-013
	,3.035421102e-013
	,3.060170617e-013
	,3.085522187e-013
	,3.110935372e-013
	,3.136733391e-013
	,3.162431155e-013
	,3.188136752e-013
	,3.214473644e-013
	,3.240922802e-013
	,3.267093646e-013
	,3.294026850e-013
	,3.321465507e-013
	,3.348612798e-013
	,3.375801861e-013
	,3.403447296e-013
	,3.431316739e-013
	,3.459643075e-013
	,3.488303596e-013
	,3.517083692e-013
	,3.546141580e-013
	,3.575350373e-013
	,3.605446321e-013
	,3.635326095e-013
	,3.666593779e-013
	,3.697770084e-013
	,3.729573508e-013
	,3.762453112e-013
	,3.795779688e-013
	,3.830500963e-013
	,3.866467598e-013
	,3.903549575e-013
	,3.943591698e-013
	,3.986079635e-013
	,4.030930364e-013
	,4.080423127e-013
	,4.134510932e-013
	,4.195268855e-013
	,4.262891142e-013
	,4.342055335e-013
	,4.432630894e-013
	,4.540842532e-013
	,4.669423775e-013
	,4.825259875e-013
	,5.015186998e-013
	,5.250157005e-013
	,5.540864854e-013
	,5.906046300e-013
	,6.364863706e-013
	,6.946618810e-013
	,7.684500860e-013
	,8.624781389e-013
	,9.824445168e-013
	,1.136180526e-012
	,1.333622681e-012
	,1.587303694e-012
	,1.914126316e-012
	,2.335555339e-012
	,-4.826188524e-009
	,-3.701872768e-009
	,-2.853851595e-009
	,-2.211779353e-009
	,-1.723543432e-009
	,-1.351123846e-009
	,-1.066385959e-009
	,-8.484243158e-010
	,-6.811245762e-010
	,-5.520919935e-010
	,-4.520433619e-010
	,-3.749587792e-010
	,-3.152327241e-010
	,-2.685101490e-010
	,-2.315669850e-010
	,-2.019405880e-010
	,-1.778397838e-010
	,-1.580479854e-010
	,-1.415839495e-010
	,-1.277009577e-010
	,-1.158498004e-010
	,-1.055959162e-010
	,-9.667178529e-011
	,-8.883312244e-011
	,-8.188951009e-011
	,-7.567369869e-011
	,-6.999494486e-011
	,-6.476684327e-011
	,-5.991780636e-011
	,-5.545218845e-011
	,-5.129344290e-011
	,-4.736382169e-011
	,-4.357507085e-011
	,-3.983755231e-011
	,-3.604399385e-011
	,-3.205542689e-011
	,-2.768519570e-011
	,-2.255096723e-011
	,-1.652662506e-011
	,-9.198929928e-012
	,3.968274340e-018
	,1.177877219e-011
	,2.714600090e-011
	,4.754041516e-011
	,7.484227498e-011
	,1.116492782e-010
	,1.616986074e-010
	,2.301713168e-010
	,3.234615639e-010
	,4.513739484e-010
	,6.273424867e-010
	,8.698332684e-010
	,1.204455129e-009
	,1.665700299e-009
	,2.300490440e-009
	,3.175577088e-009
	,4.383615465e-009
	,6.052877526e-009
	,8.360316954e-009
	,1.155061818e-008
	,1.596174068e-008
	,2.205969834e-008
	,3.047669857e-008
	,4.207933540e-008
	,5.806729534e-008
	,8.005923922e-008
	,1.102369541e-007
	,1.514734228e-007
	,2.068015490e-007
	,2.813392888e-007
	,3.811834524e-007
	,5.140125998e-007
	,6.894347466e-007
	,9.192761693e-007
	,1.217895086e-006
	,1.602440766e-006
	,2.078723381e-006
	,2.652785905e-006
	,3.348216805e-006
	,4.168615248e-006
	,5.147598129e-006
	,6.311574949e-006
	,7.684274031e-006
	,9.292083514e-006
	,1.116060962e-005
	,1.331505155e-005
	,1.578113859e-005
	,1.858428014e-005
	,2.174893014e-005
	,2.526470561e-005
	,2.906455326e-005
	,3.325408397e-005
	,3.785042406e-005
	,4.285439758e-005
	,4.821264791e-005
	,5.354240191e-005
	,5.925904164e-005
	,6.536345903e-005
	,7.185930277e-005
	,7.867466198e-005
	,8.555964759e-005
	,9.288711285e-005
	,1.006193222e-004
	,1.087463740e-004
	,1.168128892e-004
	,1.252503238e-004
	,1.337860726e-004
	,1.427141654e-004
	,1.520713347e-004
	,1.614325356e-004
	,1.705197768e-004
	,1.801387778e-004
	,1.901272203e-004
	,1.997472964e-004
	,2.098005157e-004
	,2.202638260e-004
	,2.310166229e-004
	,2.413878926e-004
	,2.514439169e-004
	,2.617741458e-004
	,2.723528488e-004
	,2.831743643e-004
	,2.932468505e-004
	,3.032894705e-004
	,3.135816922e-004
	,3.240755554e-004
	,3.348031422e-004
	,3.457525120e-004
	,3.569059395e-004
	,3.682508954e-004
	,3.797982329e-004
	,3.915442791e-004
	,4.034773850e-004
	,4.155874908e-004
	,4.278845499e-004
	,4.403643131e-004
	,4.530254762e-004
	,4.658702192e-004
	,4.788891665e-004
	,4.920799904e-004
	,5.054406134e-004
	,5.189733529e-004
	,5.326760103e-004
	,5.465469708e-004
	,5.605851002e-004
	,5.742460529e-004
	,5.876680028e-004
	,6.012230764e-004
	,6.149044908e-004
	,6.287101301e-004
	,6.425243677e-004
	,6.562843009e-004
	,6.701605258e-004
	,6.841511960e-004
	,6.982520490e-004
	,7.124655207e-004
	,7.267912973e-004
	,7.412300661e-004
	,7.557817192e-004
	,7.704430405e-004
	,7.852206794e-004
	,8.001101448e-004
	,8.151072056e-004
	,8.302113233e-004
	,8.454220054e-004
	,8.607388033e-004
	,8.761613095e-004
	,8.917004955e-004
	,9.073602681e-004
	,9.231255138e-004
	,9.389959903e-004
	,9.549714882e-004
	,9.710518292e-004
	,9.872358794e-004
	,1.003524051e-003
	,1.019916653e-003
	,1.036413615e-003
	,1.053015020e-003
	,1.069729985e-003
	,1.086561633e-003
	,1.103501967e-003
	,1.120547339e-003
	,1.137694720e-003
	,1.154930987e-003
	,1.172273184e-003
	,1.189721582e-003
	,1.207276447e-003
	,1.224938022e-003
	,1.242706531e-003
	,1.260582165e-003
	,1.278565080e-003
	,1.296655387e-003
	,1.314858217e-003
	,1.333173736e-003
	,1.351578144e-003
	,1.370089350e-003
	,1.388707182e-003
	,1.407431411e-003
	,1.425633505e-003
	,1.443465683e-003
	,1.461391734e-003
	,-1.446855998e-008
	,-1.071733307e-008
	,-7.947943913e-009
	,-5.894852039e-009
	,-4.371961048e-009
	,-3.243422226e-009
	,-2.409590197e-009
	,-1.794410202e-009
	,-1.340242206e-009
	,-1.004403258e-009
	,-7.555147474e-010
	,-5.706109875e-010
	,-4.328474004e-010
	,-3.299232080e-010
	,-2.529884362e-010
	,-1.953795286e-010
	,-1.519928407e-010
	,-1.192879006e-010
	,-9.452843032e-011
	,-7.570513284e-011
	,-6.134226865e-011
	,-5.042031649e-011
	,-4.207413225e-011
	,-3.563717126e-011
	,-3.061128011e-011
	,-2.663321433e-011
	,-2.343044284e-011
	,-2.079776378e-011
	,-1.858463133e-011
	,-1.670469823e-011
	,-1.507905571e-011
	,-1.363213332e-011
	,-1.231469072e-011
	,-1.108582285e-011
	,-9.889949613e-012
	,-8.682946615e-012
	,-7.413560877e-012
	,-6.013487435e-012
	,-4.395219016e-012
	,-2.442799669e-012
	,-2.945020213e-017
	,3.145811261e-012
	,7.278359903e-012
	,1.278120759e-011
	,2.020161554e-011
	,3.030019524e-011
	,4.412697756e-011
	,6.314260887e-011
	,8.937615289e-011
	,1.256262615e-010
	,1.758374412e-010
	,2.453095933e-010
	,3.413745110e-010
	,4.729795885e-010
	,6.533155573e-010
	,9.015253539e-010
	,1.242847604e-009
	,1.707457411e-009
	,2.343695576e-009
	,3.219876548e-009
	,4.427375372e-009
	,6.073433964e-009
	,8.313786346e-009
	,1.138500546e-008
	,1.559547268e-008
	,2.135947830e-008
	,2.925408841e-008
	,4.006352942e-008
	,5.483282557e-008
	,7.499172431e-008
	,1.024806707e-007
	,1.398801160e-007
	,1.906210668e-007
	,2.592309830e-007
	,3.515897871e-007
	,4.752346069e-007
	,6.396528515e-007
	,8.565766485e-007
	,1.140137214e-006
	,1.507070997e-006
	,1.976628018e-006
	,2.570268227e-006
	,3.311282458e-006
	,4.225125067e-006
	,5.322347706e-006
	,6.636160934e-006
	,8.191065832e-006
	,1.001101408e-005
	,1.211868547e-005
	,1.453555092e-005
	,1.718766059e-005
	,2.011228360e-005
	,2.335705001e-005
	,2.692956730e-005
	,3.070390467e-005
	,3.473184141e-005
	,3.909466061e-005
	,4.376736931e-005
	,4.871193398e-005
	,5.402681990e-005
	,5.970237464e-005
	,6.574775736e-005
	,7.196969003e-005
	,7.855996591e-005
	,8.552773254e-005
	,9.285649397e-005
	,1.004991547e-004
	,1.079899359e-004
	,1.158528999e-004
	,1.240688757e-004
	,1.326775013e-004
	,1.417358484e-004
	,1.508923782e-004
	,1.601630299e-004
	,1.698115565e-004
	,1.798212668e-004
	,1.892904879e-004
	,1.986379904e-004
	,2.078178348e-004
	,2.172723403e-004
	,2.268088471e-004
	,2.365285648e-004
	,2.464790074e-004
	,2.566423711e-004
	,2.670043422e-004
	,2.775819114e-004
	,2.883628493e-004
	,2.993226443e-004
	,3.104843931e-004
	,3.218432507e-004
	,3.333860971e-004
	,3.451089748e-004
	,3.570195061e-004
	,3.691164892e-004
	,3.813857961e-004
	,3.938297469e-004
	,4.064521410e-004
	,4.190791327e-004
	,4.313833497e-004
	,4.438505240e-004
	,4.564647880e-004
	,4.692235355e-004
	,4.821237550e-004
	,4.951658879e-004
	,5.083509522e-004
	,5.216780194e-004
	,5.351446287e-004
	,5.487280795e-004
	,5.623934744e-004
	,5.761880219e-004
	,5.901043003e-004
	,6.040376603e-004
	,6.177614537e-004
	,6.316139132e-004
	,6.455871534e-004
	,6.596728674e-004
	,6.738701454e-004
	,6.881781355e-004
	,7.025975961e-004
	,7.171267041e-004
	,7.317661015e-004
	,7.465148654e-004
	,7.613780016e-004
	,7.763512991e-004
	,7.914312329e-004
	,8.066173343e-004
	,8.219091709e-004
	,8.373063453e-004
	,8.528084936e-004
	,8.684186469e-004
	,8.841543643e-004
	,8.999949251e-004
	,9.159401063e-004
	,9.319897132e-004
	,9.481435785e-004
	,9.641184859e-004
	,9.797970049e-004
	,9.955686634e-004
	,1.011433419e-003
	,1.027391898e-003
	,1.043443221e-003
	,1.059603487e-003
	,1.075862216e-003
	,1.092215272e-003
	,1.108661498e-003
	,1.125194621e-003
	,1.141810933e-003
	,1.158520705e-003
	,1.175324059e-003
	,1.192221116e-003
	,1.209211986e-003
	,1.226296766e-003
	,1.243475535e-003
	,1.260748347e-003
	,1.278115235e-003
	,1.295590732e-003
	,1.313160361e-003
	,1.330822739e-003
	,1.348578817e-003
	,1.366428703e-003
	,1.384372187e-003
	,-5.477241233e-008
	,-4.022685339e-008
	,-2.950249322e-008
	,-2.160954465e-008
	,-1.580524974e-008
	,-1.154655281e-008
	,-8.431444819e-009
	,-6.156444392e-009
	,-4.495491281e-009
	,-3.282239412e-009
	,-2.393922817e-009
	,-1.743426074e-009
	,-1.269782010e-009
	,-9.254224126e-010
	,-6.749845732e-010
	,-4.927244802e-010
	,-3.599695704e-010
	,-2.632020474e-010
	,-1.926096260e-010
	,-1.410989223e-010
	,-1.035614910e-010
	,-7.621801267e-011
	,-5.629753392e-011
	,-4.176749616e-011
	,-3.116043189e-011
	,-2.339954542e-011
	,-1.772061908e-011
	,-1.355607496e-011
	,-1.048721470e-011
	,-8.218014985e-012
	,-6.522612545e-012
	,-5.239299031e-012
	,-4.259428363e-012
	,-3.496079555e-012
	,-2.883066218e-012
	,-2.369011725e-012
	,-1.909206594e-012
	,-1.470947034e-012
	,-1.028613970e-012
	,-5.505203166e-013
	,-3.655315609e-018
	,6.675545361e-013
	,1.509138608e-012
	,2.599879823e-012
	,4.041046556e-012
	,5.970127901e-012
	,8.575169574e-012
	,1.211445938e-011
	,1.694304126e-011
	,2.355023330e-011
	,3.261071946e-011
	,4.505555405e-011
	,6.217036090e-011
	,8.570263460e-011
	,1.180955873e-010
	,1.627348306e-010
	,2.242468947e-010
	,3.088285049e-010
	,4.243118779e-010
	,5.820845695e-010
	,7.989309660e-010
	,1.097219068e-009
	,1.507226972e-009
	,2.069192673e-009
	,2.841780741e-009
	,3.902069285e-009
	,5.360595761e-009
	,7.354876878e-009
	,9.968440336e-009
	,1.349864277e-008
	,1.827399330e-008
	,2.472961004e-008
	,3.339177097e-008
	,4.503274522e-008
	,6.062748376e-008
	,8.154035219e-008
	,1.095840971e-007
	,1.471235902e-007
	,1.972625524e-007
	,2.640106278e-007
	,3.525441548e-007
	,4.695698005e-007
	,6.234963476e-007
	,8.247790259e-007
	,1.086190156e-006
	,1.422987692e-006
	,1.853036183e-006
	,2.396684720e-006
	,3.076423589e-006
	,3.916357259e-006
	,4.941488767e-006
	,6.176867843e-006
	,7.646757667e-006
	,9.374219016e-006
	,1.137835416e-005
	,1.367889249e-005
	,1.629137945e-005
	,1.920977975e-005
	,2.245529318e-005
	,2.603882209e-005
	,2.996760433e-005
	,3.422093605e-005
	,3.875108804e-005
	,4.361318693e-005
	,4.881182379e-005
	,5.435011952e-005
	,6.023213001e-005
	,6.645795443e-005
	,7.303258420e-005
	,7.994828285e-005
	,8.707345164e-005
	,9.449559448e-005
	,1.021372760e-004
	,1.098971913e-004
	,1.177948006e-004
	,1.259341046e-004
	,1.343342157e-004
	,1.429924630e-004
	,1.519054560e-004
	,1.610765926e-004
	,1.705024620e-004
	,1.801797963e-004
	,1.901053465e-004
	,2.002735168e-004
	,2.105195346e-004
	,2.208415753e-004
	,2.313717216e-004
	,2.421221070e-004
	,2.530888604e-004
	,2.639783714e-004
	,2.749413588e-004
	,2.860828879e-004
	,2.973977347e-004
	,3.088780998e-004
	,3.205261733e-004
	,3.323396137e-004
	,3.443102475e-004
	,3.564376287e-004
	,3.687197371e-004
	,3.811572561e-004
	,3.937438556e-004
	,4.064835295e-004
	,4.193769994e-004
	,4.324154056e-004
	,4.455966568e-004
	,4.589188146e-004
	,4.720972293e-004
	,4.853570395e-004
	,4.987460312e-004
	,5.122579411e-004
	,5.258858966e-004
	,5.395972786e-004
	,5.534200650e-004
	,5.669806008e-004
	,5.804404804e-004
	,5.940054244e-004
	,6.076876377e-004
	,6.214797100e-004
	,6.353754649e-004
	,6.493739732e-004
	,6.634768248e-004
	,6.776810216e-004
	,6.919854277e-004
	,7.063901559e-004
	,7.208969936e-004
	,7.355097203e-004
	,7.502202749e-004
	,7.650281110e-004
	,7.799327034e-004
	,7.949335422e-004
	,8.100154446e-004
	,8.251639398e-004
	,8.404090183e-004
	,8.557657287e-004
	,8.712161576e-004
	,8.867599844e-004
	,9.023969144e-004
	,9.181266792e-004
	,9.339490347e-004
	,9.498642009e-004
	,9.658718846e-004
	,9.819715403e-004
	,9.981627055e-004
	,1.014446438e-003
	,1.030830732e-003
	,1.047315406e-003
	,1.063893285e-003
	,1.080564406e-003
	,1.097328714e-003
	,1.114169725e-003
	,1.131100781e-003
	,1.148124259e-003
	,1.165240288e-003
	,1.182448993e-003
	,1.199750483e-003
	,1.217144853e-003
	,1.234632173e-003
	,1.252217605e-003
	,1.269904462e-003
	,1.287684446e-003
	,1.305557483e-003
	,-2.138884092e-007
	,-1.548703012e-007
	,-1.120906808e-007
	,-8.112958145e-008
	,-5.871257945e-008
	,-4.245726768e-008
	,-3.065175111e-008
	,-2.207816928e-008
	,-1.586854543e-008
	,-1.138696364e-008
	,-8.161428593e-009
	,-5.844591781e-009
	,-4.182785013e-009
	,-2.991889919e-009
	,-2.138968855e-009
	,-1.528274091e-009
	,-1.090906957e-009
	,-7.777392662e-010
	,-5.536674594e-010
	,-3.935591347e-010
	,-2.793189603e-010
	,-1.978905901e-010
	,-1.399508646e-010
	,-9.880702950e-011
	,-6.965157947e-011
	,-4.903266819e-011
	,-3.447746862e-011
	,-2.421999523e-011
	,-1.700209917e-011
	,-1.192914787e-011
	,-8.367380223e-012
	,-5.867641528e-012
	,-4.112345502e-012
	,-2.875517872e-012
	,-2.002297154e-012
	,-1.381758289e-012
	,-9.357485144e-013
	,-6.090127282e-013
	,-3.619029369e-013
	,-1.658219060e-013
	,-1.080895823e-017
	,1.526378990e-013
	,3.070038989e-013
	,4.762413819e-013
	,6.755164881e-013
	,9.230709017e-013
	,1.241259077e-012
	,1.659081777e-012
	,2.214750523e-012
	,2.959806109e-012
	,3.963801888e-012
	,5.321227506e-012
	,7.160645878e-012
	,9.657252270e-012
	,1.304996106e-011
	,1.766486970e-011
	,2.394726146e-011
	,3.250544019e-011
	,4.417069473e-011
	,6.007931597e-011
	,8.178512837e-011
	,1.114135154e-010
	,1.518724313e-010
	,2.071416058e-010
	,2.818488431e-010
	,3.814565846e-010
	,5.169431297e-010
	,7.013749404e-010
	,9.525840117e-010
	,1.294806920e-009
	,1.760903523e-009
	,2.396080660e-009
	,3.260919175e-009
	,4.439780748e-009
	,5.975296848e-009
	,7.979654085e-009
	,1.065462492e-008
	,1.422598755e-008
	,1.899281126e-008
	,2.535287928e-008
	,3.382845167e-008
	,4.512292109e-008
	,6.016222530e-008
	,8.016825894e-008
	,1.067486062e-007
	,1.420101692e-007
	,1.887013962e-007
	,2.503362424e-007
	,3.314132970e-007
	,4.378513496e-007
	,5.770291939e-007
	,7.581661018e-007
	,9.926233735e-007
	,1.294177874e-006
	,1.679233492e-006
	,2.166742861e-006
	,2.778180168e-006
	,3.537859664e-006
	,4.471659273e-006
	,5.606563733e-006
	,6.969772732e-006
	,8.587740304e-006
	,1.048526228e-005
	,1.268473584e-005
	,1.520001176e-005
	,1.804983289e-005
	,2.124368729e-005
	,2.478649772e-005
	,2.868689228e-005
	,3.294748640e-005
	,3.756835347e-005
	,4.254782492e-005
	,4.788424684e-005
	,5.357449159e-005
	,5.961294762e-005
	,6.596656686e-005
	,7.264013108e-005
	,7.963509746e-005
	,8.693989318e-005
	,9.455292631e-005
	,1.024655114e-004
	,1.106728156e-004
	,1.191687982e-004
	,1.279470037e-004
	,1.370010186e-004
	,1.463244769e-004
	,1.559111384e-004
	,1.657548242e-004
	,1.758487668e-004
	,1.861664389e-004
	,1.963599463e-004
	,2.067755652e-004
	,2.174032944e-004
	,2.282379764e-004
	,2.392730086e-004
	,2.505019497e-004
	,2.619205034e-004
	,2.735220496e-004
	,2.853005951e-004
	,2.972517338e-004
	,3.093699204e-004
	,3.216500788e-004
	,3.340940610e-004
	,3.466929833e-004
	,3.594425190e-004
	,3.723468189e-004
	,3.853967716e-004
	,3.985882927e-004
	,4.119175659e-004
	,4.253822735e-004
	,4.389830471e-004
	,4.527191890e-004
	,4.665844938e-004
	,4.805770071e-004
	,4.947024801e-004
	,5.089078050e-004
	,5.228070629e-004
	,5.364357263e-004
	,5.501744037e-004
	,5.640216713e-004
	,5.779896251e-004
	,5.920667403e-004
	,6.062512944e-004
	,6.205420264e-004
	,6.349371212e-004
	,6.494355884e-004
	,6.640364356e-004
	,6.787395894e-004
	,6.935516616e-004
	,7.084640890e-004
	,7.234761338e-004
	,7.385870995e-004
	,7.537963282e-004
	,7.691031578e-004
	,7.845070202e-004
	,8.000073864e-004
	,8.156130463e-004
	,8.313228797e-004
	,8.471285347e-004
	,8.630296012e-004
	,8.790259536e-004
	,8.951172869e-004
	,9.113029680e-004
	,9.275826946e-004
	,9.439561889e-004
	,9.604231963e-004
	,9.769856209e-004
	,9.936417664e-004
	,1.010399036e-003
	,1.027254427e-003
	,1.044204150e-003
	,1.061248209e-003
	,1.078386628e-003
	,1.095604941e-003
	,1.112914009e-003
	,1.130315776e-003
	,1.147810898e-003
	,1.165399440e-003
	,1.183081462e-003
	,1.200857004e-003
	,1.218729939e-003
	,-6.050282851e-007
	,-4.323961146e-007
	,-3.076372568e-007
	,-2.182563879e-007
	,-1.545228055e-007
	,-1.091973948e-007
	,-7.703701956e-008
	,-5.426466436e-008
	,-3.815924968e-008
	,-2.678433838e-008
	,-1.876977518e-008
	,-1.313562321e-008
	,-9.181032597e-009
	,-6.408904491e-009
	,-4.468743825e-009
	,-3.112981865e-009
	,-2.166806780e-009
	,-1.507217373e-009
	,-1.047834778e-009
	,-7.281213110e-010
	,-5.057197546e-010
	,-3.510465110e-010
	,-2.434828891e-010
	,-1.687083056e-010
	,-1.167785013e-010
	,-8.075639388e-011
	,-5.578992063e-011
	,-3.849727522e-011
	,-2.652550914e-011
	,-1.824127320e-011
	,-1.251155970e-011
	,-8.550607516e-012
	,-5.813180115e-012
	,-3.921588870e-012
	,-2.614632880e-012
	,-1.711340494e-012
	,-1.086905975e-012
	,-6.548742610e-013
	,-3.553304103e-013
	,-1.466543211e-013
	,1.691793396e-017
	,1.046488623e-013
	,1.813117350e-013
	,2.398738033e-013
	,2.877164774e-013
	,3.303335984e-013
	,3.723499700e-013
	,4.178861427e-013
	,4.712426044e-013
	,5.362198713e-013
	,6.185525541e-013
	,7.258564101e-013
	,8.676237488e-013
	,1.056391616e-012
	,1.308879276e-012
	,1.647825442e-012
	,2.104107796e-012
	,2.719594205e-012
	,3.550900111e-012
	,4.674984611e-012
	,6.196298563e-012
	,8.256395217e-012
	,1.104841332e-011
	,1.483506261e-011
	,1.997355768e-011
	,2.695023876e-011
	,3.642740659e-011
	,4.930724594e-011
	,6.681906209e-011
	,9.063886272e-011
	,1.229397830e-010
	,1.651021974e-010
	,2.221297698e-010
	,2.993424880e-010
	,4.039821730e-010
	,5.459104197e-010
	,7.385590270e-010
	,1.000228036e-009
	,1.355841292e-009
	,1.839301837e-009
	,2.484807719e-009
	,3.307010895e-009
	,4.402024233e-009
	,5.860308223e-009
	,7.802495488e-009
	,1.038897445e-008
	,1.383275326e-008
	,1.841735544e-008
	,2.451883985e-008
	,3.263572829e-008
	,4.342783547e-008
	,5.776663215e-008
	,7.680116904e-008
	,1.020413369e-007
	,1.354645421e-007
	,1.796068557e-007
	,2.377122692e-007
	,3.141477702e-007
	,4.143863134e-007
	,5.453577802e-007
	,7.157411328e-007
	,9.362666130e-007
	,1.220003902e-006
	,1.582598309e-006
	,2.042411045e-006
	,2.620511310e-006
	,3.340476888e-006
	,4.227968113e-006
	,5.310072516e-006
	,6.614459048e-006
	,8.168435645e-006
	,9.997962639e-006
	,1.212679186e-005
	,1.457582393e-005
	,1.736261393e-005
	,2.050130002e-005
	,2.400265039e-005
	,2.787415922e-005
	,3.212078865e-005
	,3.674502332e-005
	,4.174592558e-005
	,4.712070221e-005
	,5.286902221e-005
	,5.898779239e-005
	,6.547328788e-005
	,7.232138328e-005
	,7.952769292e-005
	,8.708772111e-005
	,9.499684360e-005
	,1.032503061e-004
	,1.118433658e-004
	,1.207714366e-004
	,1.300296407e-004
	,1.396128718e-004
	,1.495163677e-004
	,1.597350871e-004
	,1.700844551e-004
	,1.804604689e-004
	,1.911150273e-004
	,2.020412088e-004
	,2.132303612e-004
	,2.246743678e-004
	,2.363658749e-004
	,2.482985481e-004
	,2.604652441e-004
	,2.728367214e-004
	,2.853817491e-004
	,2.981346038e-004
	,3.110893458e-004
	,3.242440736e-004
	,3.375926744e-004
	,3.511288504e-004
	,3.648478176e-004
	,3.787449434e-004
	,3.928192996e-004
	,4.070674632e-004
	,4.214840364e-004
	,4.360666796e-004
	,4.508174979e-004
	,4.657277507e-004
	,4.798201913e-004
	,4.938098484e-004
	,5.078026121e-004
	,5.219151948e-004
	,5.361492206e-004
	,5.505075725e-004
	,5.649817654e-004
	,5.795699034e-004
	,5.942704725e-004
	,6.090820059e-004
	,6.240031127e-004
	,6.390334079e-004
	,6.541754301e-004
	,6.694243572e-004
	,6.847784175e-004
	,7.002365640e-004
	,7.157978056e-004
	,7.314612039e-004
	,7.472258711e-004
	,7.630909670e-004
	,7.790592287e-004
	,7.951370465e-004
	,8.113140144e-004
	,8.275892398e-004
	,8.439621570e-004
	,8.604321900e-004
	,8.769987985e-004
	,8.936614766e-004
	,9.104197507e-004
	,9.272741877e-004
	,9.442245791e-004
	,9.612692691e-004
	,9.784099553e-004
	,9.956539467e-004
	,1.012992923e-003
	,1.030426744e-003
	,1.047955042e-003
	,1.065572159e-003
	,1.083275660e-003
	,1.101072348e-003
	,1.118959798e-003
	,-9.473302927e-007
	,-6.717778051e-007
	,-4.738572253e-007
	,-3.327729119e-007
	,-2.328361644e-007
	,-1.623979630e-007
	,-1.129673767e-007
	,-7.842573156e-008
	,-5.436933050e-008
	,-3.764952698e-008
	,-2.604710668e-008
	,-1.800660709e-008
	,-1.243993932e-008
	,-8.588897092e-009
	,-5.926579217e-009
	,-4.087163418e-009
	,-2.817002551e-009
	,-1.940487136e-009
	,-1.335990050e-009
	,-9.193475223e-010
	,-6.323573713e-010
	,-4.347814879e-010
	,-2.988234090e-010
	,-2.052998426e-010
	,-1.409855161e-010
	,-9.677007655e-011
	,-6.637950386e-011
	,-4.549508018e-011
	,-3.114575533e-011
	,-2.128793988e-011
	,-1.451665638e-011
	,-9.865656208e-012
	,-6.671084675e-012
	,-4.476729865e-012
	,-2.969270170e-012
	,-1.933367422e-012
	,-1.221157551e-012
	,-7.312138622e-013
	,-3.937505361e-013
	,-1.610140316e-013
	,-3.655315614e-018
	,1.117921661e-013
	,1.898499991e-013
	,2.448867836e-013
	,2.841756854e-013
	,3.128404358e-013
	,3.343706548e-013
	,3.512424948e-013
	,3.653191925e-013
	,3.779512722e-013
	,3.903893681e-013
	,4.035405829e-013
	,4.184952989e-013
	,4.363549160e-013
	,4.584235379e-013
	,4.858623524e-013
	,5.207699875e-013
	,5.662147815e-013
	,6.258513060e-013
	,7.047509713e-013
	,8.096159052e-013
	,9.495945199e-013
	,1.136986225e-012
	,1.388482818e-012
	,1.726677643e-012
	,2.182195392e-012
	,2.796817411e-012
	,3.626525497e-012
	,4.748146794e-012
	,6.265729103e-012
	,8.320615347e-012
	,1.110517235e-011
	,1.488080357e-011
	,2.000344116e-011
	,2.695754790e-011
	,3.640293701e-011
	,4.923851530e-011
	,6.592389614e-011
	,8.827257355e-011
	,1.184530923e-010
	,1.592564315e-010
	,2.144786383e-010
	,2.892858777e-010
	,3.907107669e-010
	,5.283302801e-010
	,7.151895213e-010
	,9.690605506e-010
	,1.291181829e-009
	,1.716619773e-009
	,2.282802165e-009
	,3.036368824e-009
	,4.039423748e-009
	,5.374626658e-009
	,7.151962800e-009
	,9.517698428e-009
	,1.266625351e-008
	,1.685586411e-008
	,2.242922159e-008
	,2.984058283e-008
	,3.969125097e-008
	,5.277580611e-008
	,7.014201292e-008
	,9.316793581e-008
	,1.236277155e-007
	,1.637811827e-007
	,2.167484412e-007
	,2.864530601e-007
	,3.779220816e-007
	,4.975408347e-007
	,6.533370535e-007
	,8.552820553e-007
	,1.115587493e-006
	,1.448966029e-006
	,1.872814145e-006
	,2.407268099e-006
	,3.075084282e-006
	,3.901307377e-006
	,4.912712082e-006
	,6.137042229e-006
	,7.602106148e-006
	,9.334817832e-006
	,1.136030434e-005
	,1.370116911e-005
	,1.637698497e-005
	,1.940404488e-005
	,2.279535754e-005
	,2.656085357e-005
	,3.070770513e-005
	,3.523884385e-005
	,4.015080733e-005
	,4.544901029e-005
	,5.113275728e-005
	,5.720052336e-005
	,6.365024714e-005
	,7.047920869e-005
	,7.768456048e-005
	,8.526341902e-005
	,9.321295974e-005
	,1.015303069e-004
	,1.102121550e-004
	,1.192554633e-004
	,1.286574263e-004
	,1.384158293e-004
	,1.485268715e-004
	,1.585638463e-004
	,1.688707688e-004
	,1.794917983e-004
	,1.904196402e-004
	,2.016469273e-004
	,2.131678473e-004
	,2.249753559e-004
	,2.370623592e-004
	,2.494225047e-004
	,2.620502474e-004
	,2.749415855e-004
	,2.880888643e-004
	,3.014865803e-004
	,3.151296184e-004
	,3.290143239e-004
	,3.431344695e-004
	,3.574863198e-004
	,3.720648073e-004
	,3.868659845e-004
	,4.018913419e-004
	,4.171332661e-004
	,4.322682663e-004
	,4.464374404e-004
	,4.607778907e-004
	,4.752892245e-004
	,4.899700289e-004
	,5.048238834e-004
	,5.198453625e-004
	,5.350338059e-004
	,5.501530725e-004
	,5.653701824e-004
	,5.806044066e-004
	,5.959714932e-004
	,6.114694188e-004
	,6.270968309e-004
	,6.428519796e-004
	,6.587337677e-004
	,6.747413024e-004
	,6.908737746e-004
	,7.071306630e-004
	,7.235113639e-004
	,7.400162933e-004
	,7.566525109e-004
	,7.734117763e-004
	,7.902938829e-004
	,8.072987209e-004
	,8.244262811e-004
	,8.416766578e-004
	,8.590500295e-004
	,8.765473027e-004
	,8.941693595e-004
	,9.119157298e-004
	,9.297871118e-004
	,9.475549175e-004
	,9.653545693e-004
	,9.832537833e-004
	,1.001251487e-003
	,-1.160273897e-006
	,-8.200851896e-007
	,-5.768347547e-007
	,-4.040888172e-007
	,-2.820954539e-007
	,-1.963498788e-007
	,-1.363305711e-007
	,-9.446348825e-008
	,-6.534164028e-008
	,-4.513316113e-008
	,-3.113758268e-008
	,-2.146044829e-008
	,-1.477831475e-008
	,-1.016974942e-008
	,-6.994142322e-009
	,-4.807343610e-009
	,-3.302235867e-009
	,-2.266913538e-009
	,-1.555372416e-009
	,-1.066800196e-009
	,-7.315321968e-010
	,-5.015437549e-010
	,-3.438057613e-010
	,-2.356332598e-010
	,-1.614567148e-010
	,-1.105943298e-010
	,-7.571921601e-011
	,-5.180626086e-011
	,-3.540965383e-011
	,-2.416656014e-011
	,-1.645688989e-011
	,-1.116979732e-011
	,-7.543740150e-012
	,-5.056539336e-012
	,-3.350050525e-012
	,-2.178883569e-012
	,-1.374799257e-012
	,-8.223381106e-013
	,-4.423179735e-013
	,-1.806056656e-013
	,1.571695746e-017
	,1.250477092e-013
	,2.120100520e-013
	,2.728386761e-013
	,3.158371332e-013
	,3.465763356e-013
	,3.689457760e-013
	,3.856339711e-013
	,3.984585203e-013
	,4.086656718e-013
	,4.171226350e-013
	,4.244922967e-013
	,4.312345265e-013
	,4.376286299e-013
	,4.439793414e-013
	,4.505536956e-013
	,4.575652575e-013
	,4.653113470e-013
	,4.740499653e-013
	,4.842664113e-013
	,4.964366894e-013
	,5.109441200e-013
	,5.285853682e-013
	,5.506693418e-013
	,5.787672835e-013
	,6.149168327e-013
	,6.618825329e-013
	,7.234553970e-013
	,8.046111750e-013
	,9.122372583e-013
	,1.055536834e-012
	,1.246987370e-012
	,1.503550882e-012
	,1.847996738e-012
	,2.311409393e-012
	,2.935723867e-012
	,3.778032128e-012
	,4.915528194e-012
	,6.453306646e-012
	,8.533920417e-012
	,1.135109945e-011
	,1.516854616e-011
	,2.034479147e-011
	,2.710424133e-011
	,3.600267900e-011
	,4.797670721e-011
	,6.411143849e-011
	,8.588040998e-011
	,1.152853435e-010
	,1.550471714e-010
	,2.088663303e-010
	,2.817772180e-010
	,3.806317225e-010
	,5.095516464e-010
	,6.759597159e-010
	,8.970766613e-010
	,1.190957453e-009
	,1.581626867e-009
	,2.101050978e-009
	,2.791768265e-009
	,3.710369795e-009
	,4.932128326e-009
	,6.557138871e-009
	,8.718453827e-009
	,1.159284781e-008
	,1.541503724e-008
	,2.049642460e-008
	,2.724974203e-008
	,3.622134978e-008
	,4.813340313e-008
	,6.393864787e-008
	,8.486652203e-008
	,1.124674406e-007
	,1.489449934e-007
	,1.970677383e-007
	,2.604152724e-007
	,3.435847618e-007
	,4.524327564e-007
	,5.943488197e-007
	,7.785514910e-007
	,1.016388738e-006
	,1.321615339e-006
	,1.710608628e-006
	,2.202475976e-006
	,2.819005811e-006
	,3.584418508e-006
	,4.524894621e-006
	,5.667888494e-006
	,7.041273518e-006
	,8.672401267e-006
	,1.058718170e-005
	,1.280928055e-005
	,1.535951500e-005
	,1.825551093e-005
	,2.151160030e-005
	,2.513894521e-005
	,2.914579555e-005
	,3.353789291e-005
	,3.831894707e-005
	,4.349101436e-005
	,4.905479566e-005
	,5.501016379e-005
	,6.135640899e-005
	,6.809252523e-005
	,7.521783661e-005
	,8.273076150e-005
	,9.063024074e-005
	,9.891555833e-005
	,1.075862068e-004
	,1.166418174e-004
	,1.260822698e-004
	,1.359009242e-004
	,1.456168542e-004
	,1.556889637e-004
	,1.661121469e-004
	,1.768821431e-004
	,1.879889337e-004
	,1.993089852e-004
	,2.109363022e-004
	,2.228630303e-004
	,2.350827227e-004
	,2.475901597e-004
	,2.603781708e-004
	,2.734405313e-004
	,2.867712225e-004
	,3.003646669e-004
	,3.142153602e-004
	,3.283189292e-004
	,3.426708231e-004
	,3.572641182e-004
	,3.720931422e-004
	,3.871460588e-004
	,4.023766508e-004
	,4.163168722e-004
	,4.304326170e-004
	,4.447259703e-004
	,4.591934686e-004
	,4.738317503e-004
	,4.886388716e-004
	,5.036130305e-004
	,5.187532997e-004
	,5.340587776e-004
	,5.495267641e-004
	,5.651559869e-004
	,5.809459840e-004
	,5.968954400e-004
	,6.130032096e-004
	,6.292685157e-004
	,6.456906949e-004
	,6.622691959e-004
	,6.790035775e-004
	,6.958968414e-004
	,7.129481325e-004
	,7.301549985e-004
	,7.475174421e-004
	,7.650355856e-004
	,7.827096591e-004
	,8.005401302e-004
	,8.185282861e-004
	,8.366737274e-004
	,8.549771603e-004
	,-1.258287295e-006
	,-8.930186917e-007
	,-6.308114073e-007
	,-4.437201914e-007
	,-3.107284955e-007
	,-2.163676698e-007
	,-1.501900313e-007
	,-1.040930073e-007
	,-7.205924107e-008
	,-4.983212975e-008
	,-3.442851533e-008
	,-2.376531589e-008
	,-1.639114855e-008
	,-1.129639269e-008
	,-7.779667203e-009
	,-5.354289575e-009
	,-3.682919177e-009
	,-2.531986492e-009
	,-1.739962760e-009
	,-1.195243333e-009
	,-8.207894894e-010
	,-5.634813931e-010
	,-3.867271277e-010
	,-2.653394845e-010
	,-1.819926838e-010
	,-1.247747103e-010
	,-8.549938896e-011
	,-5.854283008e-011
	,-4.004253779e-011
	,-2.734642326e-011
	,-1.863357844e-011
	,-1.265432703e-011
	,-8.550768342e-012
	,-5.734207974e-012
	,-3.800690900e-012
	,-2.472957338e-012
	,-1.560837357e-012
	,-9.338698217e-013
	,-5.024756695e-013
	,-2.052435418e-013
	,7.884502038e-018
	,1.420993824e-013
	,2.409126479e-013
	,3.100338059e-013
	,3.588076546e-013
	,3.936041733e-013
	,4.188185182e-013
	,4.375376167e-013
	,4.517124812e-013
	,4.628061622e-013
	,4.717891009e-013
	,4.793309200e-013
	,4.859009403e-013
	,4.917599303e-013
	,4.972128857e-013
	,5.023422563e-013
	,5.072734136e-013
	,5.121717790e-013
	,5.169839352e-013
	,5.218444960e-013
	,5.267788384e-013
	,5.318918653e-013
	,5.372397093e-013
	,5.429265418e-013
	,5.491019108e-013
	,5.559513408e-013
	,5.636269905e-013
	,5.723620059e-013
	,5.823424861e-013
	,5.942765895e-013
	,6.087800517e-013
	,6.267321961e-013
	,6.493549904e-013
	,6.780720617e-013
	,7.152019732e-013
	,7.633910508e-013
	,8.266098270e-013
	,9.100421865e-013
	,1.020597817e-012
	,1.167812889e-012
	,1.364345018e-012
	,1.627473172e-012
	,1.980569192e-012
	,2.455290399e-012
	,3.094363882e-012
	,3.955942228e-012
	,5.118863593e-012
	,6.690040365e-012
	,8.814731280e-012
	,1.161295211e-011
	,1.521456037e-011
	,2.004068819e-011
	,2.651839779e-011
	,3.522628300e-011
	,4.694878552e-011
	,6.275028191e-011
	,8.407555158e-011
	,1.128875927e-010
	,1.518538700e-010
	,2.040100671e-010
	,2.698332735e-010
	,3.571213523e-010
	,4.729120646e-010
	,6.265605094e-010
	,8.305041602e-010
	,1.101277723e-009
	,1.460865204e-009
	,1.938496429e-009
	,2.573034152e-009
	,3.416144303e-009
	,4.536503396e-009
	,6.025379005e-009
	,8.004022896e-009
	,1.063345565e-008
	,1.412739481e-008
	,1.876930799e-008
	,2.493485622e-008
	,3.312135396e-008
	,4.398632115e-008
	,5.837925347e-008
	,7.735307638e-008
	,1.024580147e-007
	,1.356311063e-007
	,1.793938924e-007
	,2.370118854e-007
	,3.126877681e-007
	,4.117899271e-007
	,5.411145909e-007
	,7.091744232e-007
	,9.264992671e-007
	,1.205925078e-006
	,1.562836780e-006
	,2.015321483e-006
	,2.584183369e-006
	,3.292774565e-006
	,4.166610789e-006
	,5.232767490e-006
	,6.519091496e-006
	,8.053283715e-006
	,9.861971254e-006
	,1.196985564e-005
	,1.439903533e-005
	,1.716856528e-005
	,2.029426692e-005
	,2.378872974e-005
	,2.766159524e-005
	,3.191980429e-005
	,3.656805767e-005
	,4.160922651e-005
	,4.704476083e-005
	,5.287516870e-005
	,5.910008390e-005
	,6.571879789e-005
	,7.273030100e-005
	,8.013366551e-005
	,8.792752172e-005
	,9.611079830e-005
	,1.046825705e-004
	,1.136420808e-004
	,1.229887015e-004
	,1.322741897e-004
	,1.418817359e-004
	,1.518412593e-004
	,1.621472529e-004
	,1.727944007e-004
	,1.837773952e-004
	,1.950915222e-004
	,2.067323481e-004
	,2.186957144e-004
	,2.309777457e-004
	,2.435750392e-004
	,2.564856011e-004
	,2.697067680e-004
	,2.832353009e-004
	,2.970691893e-004
	,3.112065537e-004
	,3.256465371e-004
	,3.403838980e-004
	,3.554144473e-004
	,3.704104665e-004
	,3.847647525e-004
	,3.985996248e-004
	,4.126208420e-004
	,4.268249159e-004
	,4.412103682e-004
	,4.557756894e-004
	,4.705173614e-004
	,4.854332342e-004
	,5.005212850e-004
	,5.157796140e-004
	,5.312067011e-004
	,5.468009779e-004
	,5.625606490e-004
	,5.784842755e-004
	,5.945705198e-004
	,6.108181408e-004
	,6.272262374e-004
	,6.437978785e-004
	,6.605279997e-004
	,6.774157162e-004
	,6.944602177e-004
	,-1.317795417e-006
	,-9.358584852e-007
	,-6.593332771e-007
	,-4.615696541e-007
	,-3.223520034e-007
	,-2.247720949e-007
	,-1.565440520e-007
	,-1.089221301e-007
	,-7.572625586e-008
	,-5.260988393e-008
	,-3.652589456e-008
	,-2.534294976e-008
	,-1.757268260e-008
	,-1.217698212e-008
	,-8.432459827e-009
	,-5.835418008e-009
	,-4.035356602e-009
	,-2.788519551e-009
	,-1.925477455e-009
	,-1.328525690e-009
	,-9.159362677e-010
	,-6.309930502e-010
	,-4.343602132e-010
	,-2.987742231e-010
	,-2.053524554e-010
	,-1.410276950e-010
	,-9.676547937e-011
	,-6.632520312e-011
	,-4.540047137e-011
	,-3.102241687e-011
	,-2.114584671e-011
	,-1.436308652e-011
	,-9.705774228e-012
	,-6.508093314e-012
	,-4.312627915e-012
	,-2.805158768e-012
	,-1.769730771e-012
	,-1.058266550e-012
	,-5.690256413e-013
	,-2.322292227e-013
	,1.514257739e-017
	,1.605024675e-013
	,2.719024888e-013
	,3.495089113e-013
	,4.040696914e-013
	,4.427400903e-013
	,4.705913096e-013
	,4.909720375e-013
	,5.062676219e-013
	,5.180691480e-013
	,5.274628729e-013
	,5.351906345e-013
	,5.418303114e-013
	,5.476875260e-013
	,5.530392339e-013
	,5.580250617e-013
	,5.627947138e-013
	,5.673937750e-013
	,5.719035984e-013
	,5.763460626e-013
	,5.807606434e-013
	,5.851292737e-013
	,5.895788916e-013
	,5.940303894e-013
	,5.985080475e-013
	,6.030589129e-013
	,6.077254377e-013
	,6.124609924e-013
	,6.173669292e-013
	,6.224551011e-013
	,6.277857136e-013
	,6.334565680e-013
	,6.395289140e-013
	,6.460505297e-013
	,6.531938857e-013
	,6.611649234e-013
	,6.703200717e-013
	,6.809643786e-013
	,6.936613110e-013
	,7.090381441e-013
	,7.280755536e-013
	,7.518155171e-013
	,7.820626846e-013
	,8.209049276e-013
	,8.713714743e-013
	,9.373826776e-013
	,1.024148217e-012
	,1.139058588e-012
	,1.291709437e-012
	,1.495328318e-012
	,1.767683210e-012
	,2.132714795e-012
	,2.623064570e-012
	,3.282771143e-012
	,4.171655518e-012
	,5.357443370e-012
	,6.840971729e-012
	,8.818962111e-012
	,1.146158265e-011
	,1.499884729e-011
	,1.974147471e-011
	,2.611042320e-011
	,3.467633247e-011
	,4.621253382e-011
	,6.176849516e-011
	,8.276874232e-011
	,1.094555424e-010
	,1.443072577e-010
	,1.904338409e-010
	,2.515080368e-010
	,3.324047533e-010
	,4.395964739e-010
	,5.816791704e-010
	,7.700644123e-010
	,1.019915936e-009
	,1.351380086e-009
	,1.791219187e-009
	,2.374988247e-009
	,3.149921572e-009
	,4.178763452e-009
	,5.544847268e-009
	,7.358824785e-009
	,9.767573541e-009
	,1.296597211e-008
	,1.721244489e-008
	,2.284944888e-008
	,3.033042183e-008
	,4.024155831e-008
	,5.329036688e-008
	,7.056604103e-008
	,9.341552033e-008
	,1.236009856e-007
	,1.634186531e-007
	,2.158464567e-007
	,2.847242166e-007
	,3.749687216e-007
	,4.928234324e-007
	,6.461379526e-007
	,8.446658404e-007
	,1.100360614e-006
	,1.427639683e-006
	,1.843576017e-006
	,2.367970433e-006
	,3.023257092e-006
	,3.834204761e-006
	,4.827399870e-006
	,6.030524925e-006
	,7.471492242e-006
	,9.177518087e-006
	,1.117423819e-005
	,1.348496277e-005
	,1.613014534e-005
	,1.912710194e-005
	,2.248994370e-005
	,2.622971984e-005
	,3.035469710e-005
	,3.487078119e-005
	,3.978185156e-005
	,4.509023330e-005
	,5.079705927e-005
	,5.690260557e-005
	,6.340656104e-005
	,7.030825438e-005
	,7.760709192e-005
	,8.530213166e-005
	,9.339269988e-005
	,1.018777926e-004
	,1.107567384e-004
	,1.196275639e-004
	,1.287877058e-004
	,1.383066285e-004
	,1.481780627e-004
	,1.583960625e-004
	,1.689549642e-004
	,1.798496107e-004
	,1.910762973e-004
	,2.026286693e-004
	,2.145017317e-004
	,2.266907832e-004
	,2.391912999e-004
	,2.519989492e-004
	,2.651096061e-004
	,2.785190195e-004
	,2.922181787e-004
	,3.062080668e-004
	,3.204860987e-004
	,3.350516945e-004
	,3.498998911e-004
	,3.644793218e-004
	,3.781776504e-004
	,3.920861014e-004
	,4.062038171e-004
	,4.205294750e-004
	,4.350621307e-004
	,4.498020499e-004
	,4.647492795e-004
	,4.799043778e-004
	,4.952683770e-004
	,5.108422903e-004
	,5.266279344e-004
	,5.423276117e-004
	,-1.357307506e-006
	,-9.583853376e-007
	,-6.733140200e-007
	,-4.718473997e-007
	,-3.300653746e-007
	,-2.305789087e-007
	,-1.609176932e-007
	,-1.122143735e-007
	,-7.820176699e-008
	,-5.446890224e-008
	,-3.792010386e-008
	,-2.638717735e-008
	,-1.835373718e-008
	,-1.276038504e-008
	,-8.867585961e-009
	,-6.159421205e-009
	,-4.276161148e-009
	,-2.967093155e-009
	,-2.057553533e-009
	,-1.425904458e-009
	,-9.874657225e-010
	,-6.833063101e-010
	,-4.724288370e-010
	,-3.263219868e-010
	,-2.251650773e-010
	,-1.551844824e-010
	,-1.068123643e-010
	,-7.340598641e-011
	,-5.035591773e-011
	,-3.446585282e-011
	,-2.352109741e-011
	,-1.598867839e-011
	,-1.080840375e-011
	,-7.247988408e-012
	,-4.802008815e-012
	,-3.122159909e-012
	,-1.968666836e-012
	,-1.176442010e-012
	,-6.320906403e-013
	,-2.577720086e-013
	,1.942431969e-017
	,1.779011706e-013
	,3.010823015e-013
	,3.868451298e-013
	,4.468763578e-013
	,4.893565674e-013
	,5.198387086e-013
	,5.420553117e-013
	,5.586623625e-013
	,5.713899459e-013
	,5.815146478e-013
	,5.898321932e-013
	,5.969607198e-013
	,6.032197916e-013
	,6.089228112e-013
	,6.142883565e-013
	,6.193552241e-013
	,6.243083645e-013
	,6.291491875e-013
	,6.338789462e-013
	,6.386052587e-013
	,6.432987270e-013
	,6.480463438e-013
	,6.527189256e-013
	,6.574497287e-013
	,6.622069532e-013
	,6.669394272e-013
	,6.717851585e-013
	,6.766447794e-013
	,6.814988131e-013
	,6.863950899e-013
	,6.913913610e-013
	,6.964138969e-013
	,7.015252007e-013
	,7.067354544e-013
	,7.120324918e-013
	,7.175018432e-013
	,7.231049207e-013
	,7.289216154e-013
	,7.350139081e-013
	,7.413191914e-013
	,7.480661729e-013
	,7.553500432e-013
	,7.632816575e-013
	,7.721738963e-013
	,7.822686782e-013
	,7.939546495e-013
	,8.077642083e-013
	,8.244057741e-013
	,8.448132889e-013
	,8.702709621e-013
	,9.024492998e-013
	,9.436398696e-013
	,9.968784267e-013
	,1.066301395e-012
	,1.157521826e-012
	,1.277883169e-012
	,1.437585734e-012
	,1.650361435e-012
	,1.934575447e-012
	,2.315315805e-012
	,2.826520537e-012
	,3.456442944e-012
	,4.283791215e-012
	,5.382628526e-012
	,6.845384482e-012
	,8.797269969e-012
	,1.140711790e-011
	,1.490295721e-011
	,1.959348183e-011
	,2.589661889e-011
	,3.437886484e-011
	,4.544128191e-011
	,5.954402868e-011
	,7.815930779e-011
	,1.027396375e-010
	,1.352160894e-010
	,1.781461245e-010
	,2.349196448e-010
	,3.100317855e-010
	,4.094452990e-010
	,5.410688578e-010
	,7.153958077e-010
	,9.463590583e-010
	,1.252448819e-009
	,1.658210109e-009
	,2.196227263e-009
	,2.909757553e-009
	,3.856224920e-009
	,5.111852138e-009
	,6.777798863e-009
	,8.988289707e-009
	,1.192136768e-008
	,1.581310136e-008
	,2.097637344e-008
	,2.781591366e-008
	,3.680150785e-008
	,4.869953948e-008
	,6.444304077e-008
	,8.525704593e-008
	,1.127449163e-007
	,1.489977427e-007
	,1.967307537e-007
	,2.594508404e-007
	,3.416582375e-007
	,4.490832070e-007
	,5.889548282e-007
	,7.702931579e-007
	,1.004208175e-006
	,1.304179021e-006
	,1.686277325e-006
	,2.169289647e-006
	,2.774691262e-006
	,3.526429458e-006
	,4.450492753e-006
	,5.574267364e-006
	,6.925727608e-006
	,8.532531077e-006
	,1.042111554e-005
	,1.261590388e-005
	,1.513868273e-005
	,1.800821998e-005
	,2.124012332e-005
	,2.484694662e-005
	,2.883832792e-005
	,3.322143604e-005
	,3.800130407e-005
	,4.318122516e-005
	,4.876317287e-005
	,5.474815017e-005
	,6.113646810e-005
	,6.792798920e-005
	,7.512232105e-005
	,8.271895607e-005
	,9.071736826e-005
	,9.911703278e-005
	,1.075709055e-004
	,1.162750289e-004
	,1.253468301e-004
	,1.347797651e-004
	,1.445677597e-004
	,1.547048155e-004
	,1.651852114e-004
	,1.760033812e-004
	,1.871538896e-004
	,1.986315503e-004
	,2.104310711e-004
	,2.225473436e-004
	,2.349730443e-004
	,2.477030329e-004
	,2.607353377e-004
	,2.740671077e-004
	,2.876915390e-004
	,3.016043035e-004
	,3.158011022e-004
	,3.302783188e-004
	,3.447758387e-004
	,3.581434143e-004
	,3.717173929e-004
	,3.854969122e-004
	,3.994800259e-004
	,-1.379097387e-006
	,-9.726411272e-007
	,-6.838399789e-007
	,-4.796916800e-007
	,-3.359272616e-007
	,-2.349634646e-007
	,-1.641958036e-007
	,-1.146622150e-007
	,-8.002667296e-008
	,-5.582700981e-008
	,-3.892905019e-008
	,-2.713547212e-008
	,-1.890782267e-008
	,-1.317001555e-008
	,-9.169933984e-009
	,-6.382202177e-009
	,-4.440003358e-009
	,-3.087328335e-009
	,-2.145564738e-009
	,-1.490137575e-009
	,-1.034186177e-009
	,-7.171623136e-010
	,-4.968681274e-010
	,-3.438995529e-010
	,-2.377683468e-010
	,-1.641998753e-010
	,-1.132510082e-010
	,-7.799926947e-011
	,-5.362907829e-011
	,-3.679462552e-011
	,-2.517357976e-011
	,-1.715628879e-011
	,-1.162796218e-011
	,-7.817637461e-012
	,-5.192281741e-012
	,-3.383826371e-012
	,-2.138187071e-012
	,-1.280251860e-012
	,-6.890430345e-013
	,-2.814112467e-013
	,1.488149555e-017
	,1.946221053e-013
	,3.297141034e-013
	,4.238147371e-013
	,4.898391511e-013
	,5.366204753e-013
	,5.701732001e-013
	,5.946782901e-013
	,6.130180889e-013
	,6.270495672e-013
	,6.382209462e-013
	,6.474204262e-013
	,6.552749169e-013
	,6.621866933e-013
	,6.685157872e-013
	,6.744019297e-013
	,6.800144062e-013
	,6.854552474e-013
	,6.907586552e-013
	,6.960037373e-013
	,7.012156620e-013
	,7.064185011e-013
	,7.116126722e-013
	,7.167874711e-013
	,7.219878560e-013
	,7.272608738e-013
	,7.324767670e-013
	,7.377757886e-013
	,7.431185675e-013
	,7.484266225e-013
	,7.537948308e-013
	,7.592228791e-013
	,7.646670100e-013
	,7.701192866e-013
	,7.756664926e-013
	,7.811856585e-013
	,7.868131210e-013
	,7.924506614e-013
	,7.981231867e-013
	,8.038926255e-013
	,8.096688003e-013
	,8.155388602e-013
	,8.215619662e-013
	,8.275981785e-013
	,8.337730253e-013
	,8.400958532e-013
	,8.465717796e-013
	,8.532439873e-013
	,8.601848482e-013
	,8.674593195e-013
	,8.751305830e-013
	,8.833931968e-013
	,8.924354533e-013
	,9.023934805e-013
	,9.136540972e-013
	,9.265990574e-013
	,9.417599236e-013
	,9.599603047e-013
	,9.821024995e-013
	,1.009547580e-012
	,1.044158678e-012
	,1.088223342e-012
	,1.145039816e-012
	,1.218721343e-012
	,1.315302516e-012
	,1.442640017e-012
	,1.611455279e-012
	,1.836088116e-012
	,2.115221371e-012
	,2.470270753e-012
	,2.938390401e-012
	,3.557409769e-012
	,4.378332816e-012
	,5.469022024e-012
	,6.922702357e-012
	,8.864276573e-012
	,1.146254860e-011
	,1.494605566e-011
	,1.960336821e-011
	,2.539661113e-011
	,3.301958199e-011
	,4.305670913e-011
	,5.628055760e-011
	,7.371162250e-011
	,9.669807159e-011
	,1.270311838e-010
	,1.670787108e-010
	,2.199765300e-010
	,2.898777165e-010
	,3.822876019e-010
	,5.045024150e-010
	,6.661949661e-010
	,8.801915644e-010
	,1.163502884e-009
	,1.538691900e-009
	,2.035664458e-009
	,2.694110799e-009
	,3.566717233e-009
	,4.723357967e-009
	,6.256727695e-009
	,8.289783505e-009
	,1.098560474e-008
	,1.456045646e-008
	,1.929438179e-008
	,2.549472366e-008
	,3.370303721e-008
	,4.456442512e-008
	,5.892780202e-008
	,7.790778903e-008
	,1.029639024e-007
	,1.360009391e-007
	,1.794947734e-007
	,2.366477416e-007
	,3.115771103e-007
	,4.095384446e-007
	,5.371825640e-007
	,7.028397586e-007
	,9.168180109e-007
	,1.191692414e-006
	,1.542553516e-006
	,1.987172639e-006
	,2.546035905e-006
	,3.242206977e-006
	,4.100981197e-006
	,5.149324272e-006
	,6.415126229e-006
	,7.926332001e-006
	,9.710037234e-006
	,1.179164871e-005
	,1.419419914e-005
	,1.693787642e-005
	,2.003978876e-005
	,2.351395242e-005
	,2.737145941e-005
	,3.162077319e-005
	,3.626811032e-005
	,4.131783898e-005
	,4.677291964e-005
	,5.263530999e-005
	,5.890589304e-005
	,6.558515584e-005
	,7.267325991e-005
	,8.017022672e-005
	,8.807607465e-005
	,9.610955503e-005
	,1.043422321e-004
	,1.129518045e-004
	,1.219316590e-004
	,1.312754312e-004
	,1.409771228e-004
	,1.510309235e-004
	,1.614310570e-004
	,1.721719384e-004
	,1.832477530e-004
	,1.946508736e-004
	,2.063793434e-004
	,2.184262923e-004
	,2.307863714e-004
	,2.434543665e-004
	,2.564251779e-004
	,2.696938367e-004
	,-1.394985963e-006
	,-9.842818619e-007
	,-6.924464815e-007
	,-4.860779574e-007
	,-3.406775691e-007
	,-2.384989827e-007
	,-1.668251645e-007
	,-1.166147133e-007
	,-8.147386935e-008
	,-5.689755030e-008
	,-3.971935712e-008
	,-2.771769348e-008
	,-1.933582690e-008
	,-1.348393326e-008
	,-9.399597617e-009
	,-6.549746259e-009
	,-4.561824527e-009
	,-3.175558267e-009
	,-2.209174312e-009
	,-1.535761543e-009
	,-1.066733893e-009
	,-7.402657685e-010
	,-5.132062702e-010
	,-3.554321350e-010
	,-2.459110534e-010
	,-1.699607043e-010
	,-1.173387931e-010
	,-8.090905470e-011
	,-5.570601786e-011
	,-3.827972705e-011
	,-2.623599135e-011
	,-1.791538091e-011
	,-1.216848102e-011
	,-8.199992923e-012
	,-5.459760563e-012
	,-3.567487164e-012
	,-2.260536708e-012
	,-1.357339200e-012
	,-7.326995745e-013
	,-3.001254891e-013
	,-3.002458221e-017
	,2.088499173e-013
	,3.547468398e-013
	,4.572438135e-013
	,5.298138627e-013
	,5.817416323e-013
	,6.193840998e-013
	,6.471561069e-013
	,6.681366442e-013
	,6.843506101e-013
	,6.973161435e-013
	,7.080033201e-013
	,7.170872452e-013
	,7.251001082e-013
	,7.323342163e-013
	,7.390931031e-013
	,7.454386452e-013
	,7.515997069e-013
	,7.576157114e-013
	,7.635178843e-013
	,7.693920170e-013
	,7.751918458e-013
	,7.809275007e-013
	,7.867549520e-013
	,7.925752496e-013
	,7.983975315e-013
	,8.042582968e-013
	,8.101365546e-013
	,8.160762188e-013
	,8.220168230e-013
	,8.279595680e-013
	,8.339948926e-013
	,8.399968510e-013
	,8.460800058e-013
	,8.522122962e-013
	,8.583710604e-013
	,8.645828241e-013
	,8.708223670e-013
	,8.771134474e-013
	,8.833785763e-013
	,8.897385823e-013
	,8.961297615e-013
	,9.025665778e-013
	,9.090340973e-013
	,9.155816645e-013
	,9.221650522e-013
	,9.288026404e-013
	,9.354849258e-013
	,9.422463713e-013
	,9.490648893e-013
	,9.560206319e-013
	,9.629940236e-013
	,9.700463664e-013
	,9.772875237e-013
	,9.846216261e-013
	,9.921755594e-013
	,9.999607068e-013
	,1.007973309e-012
	,1.016366098e-012
	,1.025197870e-012
	,1.034696446e-012
	,1.044952889e-012
	,1.056242486e-012
	,1.068898638e-012
	,1.083334479e-012
	,1.100236657e-012
	,1.120221637e-012
	,1.144462251e-012
	,1.174285787e-012
	,1.211673021e-012
	,1.259112272e-012
	,1.320086736e-012
	,1.399191455e-012
	,1.502727430e-012
	,1.632534609e-012
	,1.790987585e-012
	,1.997335189e-012
	,2.267446657e-012
	,2.622549560e-012
	,3.090057807e-012
	,3.708858545e-012
	,4.530396649e-012
	,5.624087149e-012
	,7.083689915e-012
	,9.035762284e-012
	,1.150680824e-011
	,1.468375691e-011
	,1.885232367e-011
	,2.432621873e-011
	,3.151707768e-011
	,4.096628767e-011
	,5.339772421e-011
	,6.976277794e-011
	,9.131883091e-011
	,1.197276938e-010
	,1.571875574e-010
	,2.066065390e-010
	,2.718332049e-010
	,3.579622058e-010
	,4.717400308e-010
	,6.221023289e-010
	,8.208876079e-010
	,1.083778199e-009
	,1.431531892e-009
	,1.891726878e-009
	,2.500895950e-009
	,3.307480049e-009
	,4.375713158e-009
	,5.790788272e-009
	,7.665706786e-009
	,1.015037271e-008
	,1.343945179e-008
	,1.772996525e-008
	,2.340709931e-008
	,3.091667245e-008
	,4.084619939e-008
	,5.396827015e-008
	,7.129822447e-008
	,9.416549954e-008
	,1.243060332e-007
	,1.639781055e-007
	,2.161061551e-007
	,2.844563896e-007
	,3.738467435e-007
	,4.903910824e-007
	,6.417736674e-007
	,8.375440935e-007
	,1.089411538e-006
	,1.411512293e-006
	,1.820610829e-006
	,2.336189283e-006
	,2.980379183e-006
	,3.777697969e-006
	,4.754573854e-006
	,5.938671416e-006
	,7.358071852e-006
	,9.040376220e-006
	,1.101184787e-005
	,1.329666470e-005
	,1.591636060e-005
	,1.888951210e-005
	,2.223163835e-005
	,2.595532450e-005
	,3.007042912e-005
	,3.458444948e-005
	,3.950290389e-005
	,4.482972457e-005
	,5.056760117e-005
	,5.671834245e-005
	,6.328313740e-005
	,7.026280013e-005
	,7.765789761e-005
	,8.526520158e-005
	,9.300944704e-005
	,1.011398693e-004
	,1.096500304e-004
	,1.185335624e-004
	,1.277843434e-004
	,1.373959664e-004
	,1.473627192e-004
	,1.576789574e-004
	,-1.408408258e-006
	,-9.941486285e-007
	,-6.997215256e-007
	,-4.914628349e-007
	,-3.446722119e-007
	,-2.414630338e-007
	,-1.690222475e-007
	,-1.182405381e-007
	,-8.267456585e-008
	,-5.778238165e-008
	,-4.036995299e-008
	,-2.819492766e-008
	,-1.968499638e-008
	,-1.373867029e-008
	,-9.584823362e-009
	,-6.683896091e-009
	,-4.658520131e-009
	,-3.244861406e-009
	,-2.258523045e-009
	,-1.570662016e-009
	,-1.091263951e-009
	,-7.574320534e-010
	,-5.251996314e-010
	,-3.638205939e-010
	,-2.517960493e-010
	,-1.741055802e-010
	,-1.202696390e-010
	,-8.298831142e-011
	,-5.718477568e-011
	,-3.933286747e-011
	,-2.698630153e-011
	,-1.844915158e-011
	,-1.254705795e-011
	,-8.466772046e-012
	,-5.645827069e-012
	,-3.695052903e-012
	,-2.345413686e-012
	,-1.410932254e-012
	,-7.631085083e-013
	,-3.132638587e-013
	,-1.258431480e-017
	,2.189428715e-013
	,3.728436758e-013
	,4.818377235e-013
	,5.598291373e-013
	,6.163547671e-013
	,6.581616989e-013
	,6.896865487e-013
	,7.141040196e-013
	,7.335677758e-013
	,7.495576813e-013
	,7.631382713e-013
	,7.748941603e-013
	,7.854247400e-013
	,7.949911444e-013
	,8.038573795e-013
	,8.121849505e-013
	,8.200755228e-013
	,8.276193261e-013
	,8.349356227e-013
	,8.420423750e-013
	,8.489849591e-013
	,8.558241025e-013
	,8.625889943e-013
	,8.692899732e-013
	,8.759350806e-013
	,8.826111001e-013
	,8.892569907e-013
	,8.959026203e-013
	,9.026052179e-013
	,9.093095386e-013
	,9.160362602e-013
	,9.227741561e-013
	,9.295766436e-013
	,9.364553671e-013
	,9.433223940e-013
	,9.501943293e-013
	,9.571698619e-013
	,9.641229937e-013
	,9.711804538e-013
	,9.782518556e-013
	,9.853748472e-013
	,9.925643625e-013
	,9.997926223e-013
	,1.006999265e-012
	,1.014305327e-012
	,1.021651439e-012
	,1.029032014e-012
	,1.036476919e-012
	,1.043995972e-012
	,1.051488812e-012
	,1.059068906e-012
	,1.066728577e-012
	,1.074423965e-012
	,1.082185928e-012
	,1.089991806e-012
	,1.097903682e-012
	,1.105860151e-012
	,1.113900428e-012
	,1.121996628e-012
	,1.130224623e-012
	,1.138553134e-012
	,1.146988897e-012
	,1.155614206e-012
	,1.164392717e-012
	,1.173459307e-012
	,1.182861908e-012
	,1.192603969e-012
	,1.202889810e-012
	,1.213837912e-012
	,1.225642675e-012
	,1.238546750e-012
	,1.252856281e-012
	,1.269185801e-012
	,1.288018940e-012
	,1.310308647e-012
	,1.337096793e-012
	,1.369933631e-012
	,1.410946665e-012
	,1.462734704e-012
	,1.527839901e-012
	,1.603321222e-012
	,1.699462471e-012
	,1.822840614e-012
	,1.982413056e-012
	,2.190297911e-012
	,2.462365351e-012
	,2.820367777e-012
	,3.293342086e-012
	,3.920469821e-012
	,4.754544814e-012
	,5.836463133e-012
	,7.187168504e-012
	,8.951812826e-012
	,1.125967130e-011
	,1.427809597e-011
	,1.822956331e-011
	,2.341012211e-011
	,3.020747401e-011
	,3.913259477e-011
	,5.085948362e-011
	,6.627761808e-011
	,8.656098216e-011
	,1.132602077e-010
	,1.484237182e-010
	,1.947588341e-010
	,2.558261615e-010
	,3.363487077e-010
	,4.425880795e-010
	,5.828227625e-010
	,7.680097983e-010
	,1.012655225e-009
	,1.335970785e-009
	,1.763407647e-009
	,2.328691106e-009
	,3.076521401e-009
	,4.066162380e-009
	,5.376212765e-009
	,7.110959375e-009
	,9.406520384e-009
	,1.238543084e-008
	,1.632407576e-008
	,2.153046371e-008
	,2.841138495e-008
	,3.750256786e-008
	,4.950870551e-008
	,6.535502755e-008
	,8.625350713e-008
	,1.137873451e-007
	,1.500174568e-007
	,1.976153778e-007
	,2.600264917e-007
	,3.416667170e-007
	,4.481537698e-007
	,5.865705922e-007
	,7.657530554e-007
	,9.965822491e-007
	,1.292274778e-006
	,1.668606199e-006
	,2.144047811e-006
	,2.739763990e-006
	,3.479427432e-006
	,4.388828047e-006
	,5.495276903e-006
	,6.826840916e-006
	,8.411480984e-006
	,1.027617758e-005
	,1.244613036e-005
	,1.494414453e-005
	,1.779022072e-005
	,2.100137188e-005
	,2.459165299e-005
	,2.857235231e-005
	,3.295230184e-005
	,3.773823358e-005
	,4.293514386e-005
	,4.854671870e-005
	,5.457577793e-005
	,6.102420218e-005
	,6.789352047e-005
	,7.506946172e-005
	,-1.419902395e-006
	,-1.002624481e-006
	,-7.059821320e-007
	,-4.961001157e-007
	,-3.481107683e-007
	,-2.440112335e-007
	,-1.709076988e-007
	,-1.196327887e-007
	,-8.370032521e-008
	,-5.853633861e-008
	,-4.092275221e-008
	,-2.859915648e-008
	,-1.997970690e-008
	,-1.395279729e-008
	,-9.739763725e-009
	,-6.795450226e-009
	,-4.738350799e-009
	,-3.301585159e-009
	,-2.298519958e-009
	,-1.598663961e-009
	,-1.110767912e-009
	,-7.709898818e-010
	,-5.346351352e-010
	,-3.704092060e-010
	,-2.564161571e-010
	,-1.773586294e-010
	,-1.225677953e-010
	,-8.461599827e-011
	,-5.833929047e-011
	,-4.015221812e-011
	,-2.756732680e-011
	,-1.886045522e-011
	,-1.283703529e-011
	,-8.669907717e-012
	,-5.786588668e-012
	,-3.790855843e-012
	,-2.408733501e-012
	,-1.450645988e-012
	,-7.855301130e-013
	,-3.228576245e-013
	,-9.869063589e-018
	,2.263204180e-013
	,3.859410555e-013
	,4.995696193e-013
	,5.814095362e-013
	,6.413219197e-013
	,6.860686331e-013
	,7.203650756e-013
	,7.474902786e-013
	,7.695726857e-013
	,7.882217620e-013
	,8.044370334e-013
	,8.189409133e-013
	,8.322682539e-013
	,8.446986740e-013
	,8.565326787e-013
	,8.678437364e-013
	,8.787292829e-013
	,8.892933855e-013
	,8.995478972e-013
	,9.095323981e-013
	,9.192844317e-013
	,9.287795608e-013
	,9.380206050e-013
	,9.469954501e-013
	,9.557723430e-013
	,9.643776007e-013
	,9.727347784e-013
	,9.809857480e-013
	,9.890237793e-013
	,9.970487043e-013
	,1.004949563e-012
	,1.012798049e-012
	,1.020631810e-012
	,1.028424842e-012
	,1.036195421e-012
	,1.044026049e-012
	,1.051848009e-012
	,1.059754820e-012
	,1.067663198e-012
	,1.075554710e-012
	,1.083520109e-012
	,1.091562004e-012
	,1.099607920e-012
	,1.107703807e-012
	,1.115878123e-012
	,1.124091967e-012
	,1.132333485e-012
	,1.140645861e-012
	,1.149017346e-012
	,1.157435356e-012
	,1.165882398e-012
	,1.174413300e-012
	,1.182983520e-012
	,1.191628984e-012
	,1.200322958e-012
	,1.209072542e-012
	,1.217851210e-012
	,1.226744702e-012
	,1.235669419e-012
	,1.244637842e-012
	,1.253712211e-012
	,1.262817754e-012
	,1.272000734e-012
	,1.281291697e-012
	,1.290588351e-012
	,1.299970850e-012
	,1.309492661e-012
	,1.319114885e-012
	,1.328771989e-012
	,1.338632320e-012
	,1.348588989e-012
	,1.358748467e-012
	,1.369146208e-012
	,1.379744043e-012
	,1.390713710e-012
	,1.402171704e-012
	,1.414098289e-012
	,1.426794699e-012
	,1.440439828e-012
	,1.455246354e-012
	,1.471746257e-012
	,1.490421181e-012
	,1.511874224e-012
	,1.536992856e-012
	,1.567029748e-012
	,1.603742764e-012
	,1.644538526e-012
	,1.694107578e-012
	,1.755610629e-012
	,1.832780105e-012
	,1.930796862e-012
	,2.056516335e-012
	,2.219216380e-012
	,2.431291599e-012
	,2.709661398e-012
	,3.077323122e-012
	,3.565500174e-012
	,4.159378144e-012
	,4.925157049e-012
	,5.917635098e-012
	,7.210123812e-012
	,8.895391107e-012
	,1.109546982e-011
	,1.397057759e-011
	,1.773147251e-011
	,2.265549062e-011
	,2.910756532e-011
	,3.756814921e-011
	,4.867042543e-011
	,6.324881023e-011
	,8.240194911e-011
	,1.075597244e-010
	,1.406482486e-010
	,1.841913063e-010
	,2.415230900e-010
	,3.170483689e-010
	,4.165890398e-010
	,5.478428357e-010
	,7.209913642e-010
	,9.495066634e-010
	,1.251220888e-009
	,1.649745854e-009
	,2.176230024e-009
	,2.872101520e-009
	,3.792332431e-009
	,5.009776777e-009
	,6.620387160e-009
	,8.696721670e-009
	,1.143926927e-008
	,1.506153501e-008
	,1.984527213e-008
	,2.616193183e-008
	,3.450065434e-008
	,4.550465474e-008
	,6.001829946e-008
	,7.914766543e-008
	,1.043378911e-007
	,1.374711050e-007
	,1.809890364e-007
	,2.380444167e-007
	,3.126832887e-007
	,4.100658873e-007
	,5.367164729e-007
	,7.008019952e-007
	,9.124269892e-007
	,1.183922531e-006
	,1.530098787e-006
	,1.968421115e-006
	,2.519064664e-006
	,3.204803543e-006
	,4.050701916e-006
	,5.083600231e-006
	,6.331414239e-006
	,7.822309414e-006
	,9.583827264e-006
	,1.164207874e-005
	,1.402104736e-005
	,1.674210019e-005
	,1.982372431e-005
	,2.328147415e-005
	,-1.429645300e-006
	,-1.009876827e-006
	,-7.113805660e-007
	,-5.001205529e-007
	,-3.511017179e-007
	,-2.462313679e-007
	,-1.725512032e-007
	,-1.208459768e-007
	,-8.459332649e-008
	,-5.919179510e-008
	,-4.140245478e-008
	,-2.894914215e-008
	,-2.023416462e-008
	,-1.413704773e-008
	,-9.872519589e-009
	,-6.890525715e-009
	,-4.805947945e-009
	,-3.349255535e-009
	,-2.331869232e-009
	,-1.621849183e-009
	,-1.126838983e-009
	,-7.821372821e-010
	,-5.423934506e-010
	,-3.758333832e-010
	,-2.602254962e-010
	,-1.800438840e-010
	,-1.244658847e-010
	,-8.596012370e-011
	,-5.929191260e-011
	,-4.082722493e-011
	,-2.804503593e-011
	,-1.919762624e-011
	,-1.307404372e-011
	,-8.835287873e-012
	,-5.900675378e-012
	,-3.868187868e-012
	,-2.459552142e-012
	,-1.482340907e-012
	,-8.033137552e-013
	,-3.304346896e-013
	,2.104302714e-017
	,2.320243775e-013
	,3.960738509e-013
	,5.131970474e-013
	,5.978717910e-013
	,6.602403803e-013
	,7.071844630e-013
	,7.434897214e-013
	,7.724659425e-013
	,7.964143538e-013
	,8.169309486e-013
	,8.350754059e-013
	,8.515382873e-013
	,8.668926152e-013
	,8.815029121e-013
	,8.955327717e-013
	,9.091528373e-013
	,9.225382948e-013
	,9.356930603e-013
	,9.487022466e-013
	,9.615317564e-013
	,9.742450847e-013
	,9.868356524e-013
	,9.992818940e-013
	,1.011565743e-012
	,1.023719938e-012
	,1.035696389e-012
	,1.047475410e-012
	,1.059045356e-012
	,1.070425653e-012
	,1.081550037e-012
	,1.092459186e-012
	,1.103127408e-012
	,1.113554703e-012
	,1.123760810e-012
	,1.133753666e-012
	,1.143537186e-012
	,1.153168130e-012
	,1.162676940e-012
	,1.172071291e-012
	,1.181379955e-012
	,1.190614212e-012
	,1.199863088e-012
	,1.209086483e-012
	,1.218298182e-012
	,1.227539383e-012
	,1.236820320e-012
	,1.246149610e-012
	,1.255487725e-012
	,1.264867717e-012
	,1.274321229e-012
	,1.283828681e-012
	,1.293388559e-012
	,1.303031617e-012
	,1.312695196e-012
	,1.322445924e-012
	,1.332215241e-012
	,1.342059750e-012
	,1.352050778e-012
	,1.361977423e-012
	,1.372054817e-012
	,1.382202389e-012
	,1.392376175e-012
	,1.402614290e-012
	,1.412961799e-012
	,1.423282835e-012
	,1.433797019e-012
	,1.444281491e-012
	,1.454939531e-012
	,1.465523528e-012
	,1.476286366e-012
	,1.487140792e-012
	,1.498024041e-012
	,1.509041590e-012
	,1.520087807e-012
	,1.531254173e-012
	,1.542455785e-012
	,1.553894198e-012
	,1.565374124e-012
	,1.577077744e-012
	,1.588882299e-012
	,1.600913577e-012
	,1.613170952e-012
	,1.625795617e-012
	,1.638737026e-012
	,1.652127601e-012
	,1.666153075e-012
	,1.680987536e-012
	,1.696854838e-012
	,1.714019142e-012
	,1.733004596e-012
	,1.754328926e-012
	,1.778743368e-012
	,1.805676154e-012
	,1.836203253e-012
	,1.872174901e-012
	,1.915251787e-012
	,1.967582772e-012
	,2.031606933e-012
	,2.111669457e-012
	,2.213029942e-012
	,2.342911007e-012
	,2.510808148e-012
	,2.729861301e-012
	,3.003468341e-012
	,3.345709883e-012
	,3.786901601e-012
	,4.357129367e-012
	,5.095730906e-012
	,6.054584537e-012
	,7.301120183e-012
	,8.924361114e-012
	,1.104059903e-011
	,1.379634754e-011
	,1.738993265e-011
	,2.208668423e-011
	,2.822836735e-011
	,3.626938095e-011
	,4.680514429e-011
	,6.061936586e-011
	,7.874442584e-011
	,1.025402838e-010
	,1.338002656e-010
	,1.748894654e-010
	,2.289284517e-010
	,3.000366583e-010
	,3.936541551e-010
	,5.169686740e-010
	,6.794262888e-010
	,8.935617054e-010
	,1.176013236e-009
	,1.548756137e-009
	,2.040906516e-009
	,2.691059930e-009
	,3.550434019e-009
	,4.687090961e-009
	,6.141324527e-009
	,8.059557473e-009
	,1.059041773e-008
	,1.392962155e-008
	,1.833441868e-008
	,2.414490635e-008
	,3.180857976e-008
	,4.191338724e-008
	,5.523083986e-008
	,7.277150142e-008
	,9.585594091e-008
	,1.262045049e-007
	,1.660503895e-007
	,2.182798389e-007
	,2.866032852e-007
	,3.757600841e-007
	,4.917571516e-007
	,6.421378586e-007
	,8.362716511e-007
	,1.085646796e-006
	,1.404139716e-006
	,1.808223466e-006
	,2.317073319e-006
	,2.952523497e-006
	,3.738834032e-006
	,-1.438205238e-006
	,-1.016265324e-006
	,-7.161480890e-007
	,-5.036770728e-007
	,-3.537496614e-007
	,-2.481971838e-007
	,-1.740059730e-007
	,-1.219191155e-007
	,-8.538246495e-008
	,-5.977028176e-008
	,-4.182515697e-008
	,-2.925693731e-008
	,-2.045740092e-008
	,-1.429819145e-008
	,-9.988169996e-009
	,-6.972940898e-009
	,-4.864194728e-009
	,-3.390063256e-009
	,-2.360242228e-009
	,-1.641485874e-009
	,-1.140421596e-009
	,-7.915593228e-010
	,-5.489600533e-010
	,-3.804327694e-010
	,-2.634610608e-010
	,-1.823276268e-010
	,-1.260816104e-010
	,-8.710464511e-011
	,-6.010311499e-011
	,-4.140183051e-011
	,-2.845146956e-011
	,-1.948426951e-011
	,-1.327518003e-011
	,-8.975465171e-012
	,-5.997243235e-012
	,-3.933457024e-012
	,-2.502386327e-012
	,-1.508914861e-012
	,-8.182166726e-013
	,-3.367605461e-013
	,-1.717935532e-017
	,2.367435363e-013
	,4.043983934e-013
	,5.243110928e-013
	,6.112440899e-013
	,6.755448416e-013
	,7.241248631e-013
	,7.619014744e-013
	,7.922938556e-013
	,8.176276716e-013
	,8.395008477e-013
	,8.589646038e-013
	,8.768690748e-013
	,8.936959565e-013
	,9.098226167e-013
	,9.254414727e-013
	,9.408138674e-013
	,9.559607919e-013
	,9.709914827e-013
	,9.860048899e-013
	,1.000911254e-012
	,1.015856988e-012
	,1.030765023e-012
	,1.045669559e-012
	,1.060569291e-012
	,1.075450330e-012
	,1.090308968e-012
	,1.105111003e-012
	,1.119875338e-012
	,1.134576544e-012
	,1.149202244e-012
	,1.163665604e-012
	,1.178073615e-012
	,1.192337247e-012
	,1.206421255e-012
	,1.220320104e-012
	,1.234006641e-012
	,1.247509585e-012
	,1.260786955e-012
	,1.273805906e-012
	,1.286580327e-012
	,1.299030590e-012
	,1.311258253e-012
	,1.323270212e-012
	,1.335029181e-012
	,1.346587953e-012
	,1.357919271e-012
	,1.369158375e-012
	,1.380251429e-012
	,1.391272947e-012
	,1.402215932e-012
	,1.413176252e-012
	,1.424143308e-012
	,1.435065041e-012
	,1.446018364e-012
	,1.457068810e-012
	,1.468125679e-012
	,1.479244789e-012
	,1.490428178e-012
	,1.501660911e-012
	,1.513003351e-012
	,1.524335452e-012
	,1.535842216e-012
	,1.547331488e-012
	,1.558929841e-012
	,1.570604481e-012
	,1.582372693e-012
	,1.594211136e-012
	,1.606120593e-012
	,1.618118557e-012
	,1.630155945e-012
	,1.642255679e-012
	,1.654548613e-012
	,1.666862330e-012
	,1.679261837e-012
	,1.691700194e-012
	,1.704291441e-012
	,1.716980228e-012
	,1.729658258e-012
	,1.742506304e-012
	,1.755409648e-012
	,1.768444107e-012
	,1.781555585e-012
	,1.794741680e-012
	,1.808114136e-012
	,1.821534578e-012
	,1.835144096e-012
	,1.848878411e-012
	,1.862748489e-012
	,1.876846700e-012
	,1.891202076e-012
	,1.905767728e-012
	,1.920685579e-012
	,1.936007794e-012
	,1.951879900e-012
	,1.968459067e-012
	,1.985891502e-012
	,2.004418601e-012
	,2.024407758e-012
	,2.045865971e-012
	,2.068797938e-012
	,2.094291223e-012
	,2.122945582e-012
	,2.155830512e-012
	,2.194342643e-012
	,2.239927690e-012
	,2.295100394e-012
	,2.362817871e-012
	,2.447276805e-012
	,2.554152016e-012
	,2.689085120e-012
	,2.852425495e-012
	,3.057441687e-012
	,3.318598569e-012
	,3.652732371e-012
	,4.082013901e-012
	,4.635122426e-012
	,5.349761820e-012
	,6.275132226e-012
	,7.475733028e-012
	,9.035583913e-012
	,1.106519540e-011
	,1.370965474e-011
	,1.715901093e-011
	,2.166267656e-011
	,2.754839560e-011
	,3.524637711e-011
	,4.530615414e-011
	,5.846219073e-011
	,7.569977993e-011
	,9.830033156e-011
	,1.279513033e-010
	,1.668614681e-010
	,2.179694585e-010
	,2.851384449e-010
	,3.734662496e-010
	,4.896838402e-010
	,6.426830345e-010
	,8.442185318e-010
	,1.109840835e-009
	,1.460138726e-009
	,1.922400230e-009
	,2.532841469e-009
	,3.339614771e-009
	,4.363818069e-009
	,5.711240008e-009
	,7.486667166e-009
	,9.826318513e-009
	,1.290978346e-008
	,1.697370809e-008
	,2.232966261e-008
	,2.938746968e-008
	,3.868555674e-008
	,5.093027674e-008
	,6.704660652e-008
	,8.824311529e-008
	,1.160946013e-007
	,1.526410353e-007
	,2.005291631e-007
	,2.631628270e-007
	,3.448959949e-007
	,-1.445875475e-006
	,-1.022002939e-006
	,-7.204375992e-007
	,-5.068797354e-007
	,-3.561343262e-007
	,-2.499667409e-007
	,-1.753144448e-007
	,-1.228833011e-007
	,-8.609056652e-008
	,-6.028857377e-008
	,-4.220319709e-008
	,-2.953162337e-008
	,-2.065610452e-008
	,-1.444116064e-008
	,-1.009035947e-008
	,-7.045400068e-009
	,-4.915110880e-009
	,-3.425526758e-009
	,-2.384780334e-009
	,-1.658420163e-009
	,-1.152126812e-009
	,-7.996857319e-010
	,-5.546322178e-010
	,-3.844117663e-010
	,-2.662636081e-010
	,-1.843075344e-010
	,-1.274831843e-010
	,-8.809787596e-011
	,-6.080704335e-011
	,-4.190050259e-011
	,-2.880409752e-011
	,-1.973290267e-011
	,-1.344965575e-011
	,-9.096976840e-012
	,-6.080879865e-012
	,-3.989948661e-012
	,-2.539396454e-012
	,-1.531916538e-012
	,-8.310325539e-013
	,-3.421934505e-013
	,1.461888587e-018
	,2.407934902e-013
	,4.115032659e-013
	,5.338015224e-013
	,6.226820335e-013
	,6.885262488e-013
	,7.384203996e-013
	,7.774761554e-013
	,8.089724951e-013
	,8.353479232e-013
	,8.582196851e-013
	,8.787484986e-013
	,8.976725463e-013
	,9.155545120e-013
	,9.328192280e-013
	,9.496250665e-013
	,9.662028239e-013
	,9.826717624e-013
	,9.990947505e-013
	,1.015554969e-012
	,1.032031061e-012
	,1.048607461e-012
	,1.065215243e-012
	,1.081996853e-012
	,1.098826554e-012
	,1.115765022e-012
	,1.132795026e-012
	,1.149879491e-012
	,1.167022960e-012
	,1.184257025e-012
	,1.201516676e-012
	,1.218797475e-012
	,1.236133362e-012
	,1.253481519e-012
	,1.270812446e-012
	,1.288123791e-012
	,1.305389029e-012
	,1.322641004e-012
	,1.339797319e-012
	,1.356834946e-012
	,1.373803230e-012
	,1.390603272e-012
	,1.407255803e-012
	,1.423738893e-012
	,1.440008678e-012
	,1.456088604e-012
	,1.471925307e-012
	,1.487483331e-012
	,1.502774843e-012
	,1.517775300e-012
	,1.532495878e-012
	,1.546984041e-012
	,1.561152953e-012
	,1.575085533e-012
	,1.588733169e-012
	,1.602267078e-012
	,1.615600528e-012
	,1.628829858e-012
	,1.641928752e-012
	,1.655052083e-012
	,1.668094061e-012
	,1.681119226e-012
	,1.694206528e-012
	,1.707306571e-012
	,1.720457420e-012
	,1.733713015e-012
	,1.747006520e-012
	,1.760405815e-012
	,1.773876124e-012
	,1.787367894e-012
	,1.800976576e-012
	,1.814695070e-012
	,1.828487658e-012
	,1.842321184e-012
	,1.856380128e-012
	,1.870409152e-012
	,1.884569083e-012
	,1.898777784e-012
	,1.913143865e-012
	,1.927624456e-012
	,1.942141390e-012
	,1.956759467e-012
	,1.971514560e-012
	,1.986334662e-012
	,2.001301336e-012
	,2.016347221e-012
	,2.031509550e-012
	,2.046785083e-012
	,2.062165415e-012
	,2.077634619e-012
	,2.093251386e-012
	,2.108948514e-012
	,2.124806417e-012
	,2.140811047e-012
	,2.156926847e-012
	,2.173229215e-012
	,2.189702174e-012
	,2.206349432e-012
	,2.223252810e-012
	,2.240401919e-012
	,2.257865684e-012
	,2.275740966e-012
	,2.294073715e-012
	,2.313005335e-012
	,2.332729598e-012
	,2.353257628e-012
	,2.374560863e-012
	,2.397022100e-012
	,2.421120633e-012
	,2.447110130e-012
	,2.475702874e-012
	,2.507550578e-012
	,2.543691720e-012
	,2.585419179e-012
	,2.634581308e-012
	,2.693433229e-012
	,2.765147191e-012
	,2.850269429e-012
	,2.954324644e-012
	,3.083548044e-012
	,3.245404012e-012
	,3.449669750e-012
	,3.708924077e-012
	,4.039648985e-012
	,4.462964586e-012
	,5.006375643e-012
	,5.702216518e-012
	,6.600706146e-012
	,7.763429454e-012
	,9.270998125e-012
	,1.122888040e-011
	,1.377501021e-011
	,1.709026437e-011
	,2.141176379e-011
	,2.705041054e-011
	,3.441431313e-011
	,4.403807152e-011
	,5.662563574e-011
	,7.310253312e-011
	,9.468531043e-011
	,1.229751487e-010
	,1.600370860e-010
	,2.086101572e-010
	,2.723750181e-010
	,3.561363659e-010
	,4.662353014e-010
	,6.110471927e-010
	,8.016435579e-010
	,1.052631046e-009
	,1.383432589e-009
	,1.819817827e-009
	,2.396059196e-009
	,3.121070571e-009
	,4.072428844e-009
	,5.324198212e-009
	,6.971548077e-009
	,9.139903467e-009
	,1.199448447e-008
	,1.575281110e-008
	,2.070105907e-008
	,2.721540356e-008
	,-1.452814554e-006
	,-1.027209542e-006
	,-7.243387490e-007
	,-5.097958280e-007
	,-3.583064189e-007
	,-2.515783009e-007
	,-1.765054690e-007
	,-1.237602488e-007
	,-8.673393973e-008
	,-6.075889057e-008
	,-4.254570965e-008
	,-2.978001319e-008
	,-2.083534704e-008
	,-1.456972535e-008
	,-1.018189045e-008
	,-7.109990218e-009
	,-4.960256150e-009
	,-3.456813340e-009
	,-2.406349234e-009
	,-1.673279719e-009
	,-1.162397550e-009
	,-8.068223795e-010
	,-5.596187256e-010
	,-3.879126993e-010
	,-2.687308027e-010
	,-1.860508504e-010
	,-1.287171050e-010
	,-8.897207626e-011
	,-6.142652420e-011
	,-4.233914776e-011
	,-2.911419879e-011
	,-1.995154153e-011
	,-1.360298427e-011
	,-9.203766835e-012
	,-6.154340152e-012
	,-4.039600111e-012
	,-2.571948557e-012
	,-1.552106362e-012
	,-8.423067469e-013
	,-3.469898896e-013
	,3.185028780e-018
	,2.443366841e-013
	,4.177590481e-013
	,5.421703444e-013
	,6.326827736e-013
	,6.998813771e-013
	,7.509792720e-013
	,7.910338746e-013
	,8.234598223e-013
	,8.506938964e-013
	,8.744212236e-013
	,8.957850812e-013
	,9.155472017e-013
	,9.342920429e-013
	,9.524275713e-013
	,9.701702759e-013
	,9.876838028e-013
	,1.005121616e-012
	,1.022578018e-012
	,1.040093373e-012
	,1.057773052e-012
	,1.075551577e-012
	,1.093506019e-012
	,1.111637475e-012
	,1.129948450e-012
	,1.148443123e-012
	,1.167099509e-012
	,1.185873070e-012
	,1.204867557e-012
	,1.224002246e-012
	,1.243301625e-012
	,1.262748359e-012
	,1.282359939e-012
	,1.302063003e-012
	,1.321896033e-012
	,1.341841590e-012
	,1.361836125e-012
	,1.381974465e-012
	,1.402117347e-012
	,1.422369257e-012
	,1.442630566e-012
	,1.462939444e-012
	,1.483253231e-012
	,1.503560125e-012
	,1.523911611e-012
	,1.544197723e-012
	,1.564421436e-012
	,1.584569018e-012
	,1.604648405e-012
	,1.624570047e-012
	,1.644378431e-012
	,1.664024004e-012
	,1.683389594e-012
	,1.702645999e-012
	,1.721609104e-012
	,1.740280112e-012
	,1.758765907e-012
	,1.776870889e-012
	,1.794691918e-012
	,1.812222938e-012
	,1.829384892e-012
	,1.846249422e-012
	,1.862834750e-012
	,1.879167247e-012
	,1.895254589e-012
	,1.911184028e-012
	,1.927010183e-012
	,1.942708355e-012
	,1.958347210e-012
	,1.974023713e-012
	,1.989601579e-012
	,2.005325704e-012
	,2.021010300e-012
	,2.036800791e-012
	,2.052662923e-012
	,2.068676639e-012
	,2.084711712e-012
	,2.100866465e-012
	,2.117145283e-012
	,2.133524358e-012
	,2.150021858e-012
	,2.166626194e-012
	,2.183321020e-012
	,2.200195889e-012
	,2.217103706e-012
	,2.234247437e-012
	,2.251426361e-012
	,2.268752275e-012
	,2.286163458e-012
	,2.303798649e-012
	,2.321461358e-012
	,2.339276904e-012
	,2.357251711e-012
	,2.375324788e-012
	,2.393509557e-012
	,2.411875829e-012
	,2.430327214e-012
	,2.448940993e-012
	,2.467695442e-012
	,2.486576463e-012
	,2.505621287e-012
	,2.524830071e-012
	,2.544193102e-012
	,2.563682392e-012
	,2.583375482e-012
	,2.603279318e-012
	,2.623383560e-012
	,2.643740425e-012
	,2.664412938e-012
	,2.685401777e-012
	,2.706855082e-012
	,2.728732278e-012
	,2.750993474e-012
	,2.773872024e-012
	,2.797485677e-012
	,2.822143499e-012
	,2.847924914e-012
	,2.875306395e-012
	,2.904572939e-012
	,2.936450510e-012
	,2.971635519e-012
	,3.011084725e-012
	,3.056242329e-012
	,3.107922227e-012
	,3.167617234e-012
	,3.238509780e-012
	,3.323845009e-012
	,3.427941370e-012
	,3.556179291e-012
	,3.715910418e-012
	,3.916538242e-012
	,4.170121557e-012
	,4.492577377e-012
	,4.904622910e-012
	,5.433211202e-012
	,6.113473688e-012
	,6.990697730e-012
	,8.125014602e-012
	,9.594599885e-012
	,1.150077375e-011
	,1.396318077e-011
	,1.716431784e-011
	,2.133061830e-011
	,2.675825353e-011
	,3.383612591e-011
	,4.307427973e-011
	,5.514177644e-011
	,7.091733972e-011
	,9.155577094e-011
	,1.185750397e-010
	,1.539729593e-010
	,2.003793771e-010
	,2.612549975e-010
	,3.411696566e-010
	,4.461544980e-010
	,5.840640717e-010
	,7.652902806e-010
	,1.003871460e-009
	,1.318279021e-009
	,1.733107968e-009
	,2.249775572e-009
	,-1.459166568e-006
	,-1.031985646e-006
	,-7.279227667e-007
	,-5.124769004e-007
	,-3.603038480e-007
	,-2.530600083e-007
	,-1.776000450e-007
	,-1.245656616e-007
	,-8.732433488e-008
	,-6.119002309e-008
	,-4.285926776e-008
	,-3.000701848e-008
	,-2.099879655e-008
	,-1.468662551e-008
	,-1.026481208e-008
	,-7.168248969e-009
	,-5.000788317e-009
	,-3.484792173e-009
	,-2.425591407e-009
	,-1.686527546e-009
	,-1.171559045e-009
	,-8.131943926e-010
	,-5.640748261e-010
	,-3.910428863e-010
	,-2.709370026e-010
	,-1.876094706e-010
	,-1.298198344e-010
	,-8.975281400e-011
	,-6.197927014e-011
	,-4.273019281e-011
	,-2.939040526e-011
	,-2.014601921e-011
	,-1.373934423e-011
	,-9.298605599e-012
	,-6.219551296e-012
	,-4.083694172e-012
	,-2.600778467e-012
	,-1.570042268e-012
	,-8.523147451e-013
	,-3.512012442e-013
	,1.185294611e-017
	,2.475255900e-013
	,4.233177417e-013
	,5.495601094e-013
	,6.415686943e-013
	,7.099836259e-013
	,7.620607866e-013
	,8.030113177e-013
	,8.362920996e-013
	,8.642887415e-013
	,8.887421895e-013
	,9.108514880e-013
	,9.313447421e-013
	,9.508184716e-013
	,9.696993364e-013
	,9.881719215e-013
	,1.006513078e-012
	,1.024709125e-012
	,1.043030753e-012
	,1.061450390e-012
	,1.080018688e-012
	,1.098739353e-012
	,1.117731386e-012
	,1.136913905e-012
	,1.156322469e-012
	,1.176017439e-012
	,1.195890415e-012
	,1.216032514e-012
	,1.236409534e-012
	,1.257024661e-012
	,1.277907188e-012
	,1.298952108e-012
	,1.320293878e-012
	,1.341863677e-012
	,1.363650853e-012
	,1.385590448e-012
	,1.407813683e-012
	,1.430156232e-012
	,1.452758401e-012
	,1.475509543e-012
	,1.498424592e-012
	,1.521485848e-012
	,1.544724638e-012
	,1.568082796e-012
	,1.591561730e-012
	,1.615133139e-012
	,1.638829972e-012
	,1.662660374e-012
	,1.686492708e-012
	,1.710408432e-012
	,1.734421696e-012
	,1.758419713e-012
	,1.782411672e-012
	,1.806447337e-012
	,1.830413032e-012
	,1.854287662e-012
	,1.878120048e-012
	,1.901833434e-012
	,1.925426721e-012
	,1.948833753e-012
	,1.972051919e-012
	,1.995127481e-012
	,2.017882696e-012
	,2.040444345e-012
	,2.062761935e-012
	,2.084670827e-012
	,2.106317697e-012
	,2.127559786e-012
	,2.148516460e-012
	,2.169112424e-012
	,2.189401460e-012
	,2.209291772e-012
	,2.229016035e-012
	,2.248419586e-012
	,2.267596100e-012
	,2.286690164e-012
	,2.305711387e-012
	,2.324617890e-012
	,2.343538543e-012
	,2.362491728e-012
	,2.381498277e-012
	,2.400566077e-012
	,2.419702332e-012
	,2.438988500e-012
	,2.458312734e-012
	,2.477786934e-012
	,2.497441958e-012
	,2.517158233e-012
	,2.537019199e-012
	,2.557032010e-012
	,2.577120744e-012
	,2.597441528e-012
	,2.617852332e-012
	,2.638370285e-012
	,2.659063997e-012
	,2.679865693e-012
	,2.700826284e-012
	,2.721822016e-012
	,2.742977531e-012
	,2.764259722e-012
	,2.785599664e-012
	,2.807073751e-012
	,2.828583658e-012
	,2.850187815e-012
	,2.871903298e-012
	,2.893602750e-012
	,2.915373582e-012
	,2.937172506e-012
	,2.958967984e-012
	,2.980795993e-012
	,3.002637422e-012
	,3.024403554e-012
	,3.046274851e-012
	,3.068061922e-012
	,3.089988045e-012
	,3.111933750e-012
	,3.133957623e-012
	,3.156217931e-012
	,3.178597501e-012
	,3.201230112e-012
	,3.224187039e-012
	,3.247565039e-012
	,3.271572037e-012
	,3.296265471e-012
	,3.321860787e-012
	,3.348749711e-012
	,3.377191810e-012
	,3.407653535e-012
	,3.440715791e-012
	,3.477077026e-012
	,3.517283526e-012
	,3.562673493e-012
	,3.614828821e-012
	,3.675655409e-012
	,3.747603300e-012
	,3.833935235e-012
	,3.938908048e-012
	,4.067383292e-012
	,4.226624264e-012
	,4.425692593e-012
	,4.676456277e-012
	,4.994254605e-012
	,5.399045457e-012
	,5.916736089e-012
	,6.581378518e-012
	,7.436882743e-012
	,8.540929212e-012
	,9.968641039e-012
	,1.181730923e-011
	,1.421549043e-011
	,1.733066211e-011
	,2.138191514e-011
	,2.665582021e-011
	,3.352796620e-011
	,4.244925538e-011
	,5.408393885e-011
	,6.927326958e-011
	,8.911920068e-011
	,1.150696337e-010
	,1.490277594e-010
	,1.934999603e-010
	,-1.465053906e-006
	,-1.036414909e-006
	,-7.312477511e-007
	,-5.149641737e-007
	,-3.621563726e-007
	,-2.544336023e-007
	,-1.786141724e-007
	,-1.253113679e-007
	,-8.787051934e-008
	,-6.158847942e-008
	,-4.314870615e-008
	,-3.021623269e-008
	,-2.114912574e-008
	,-1.479385166e-008
	,-1.034061161e-008
	,-7.221292768e-009
	,-5.037548094e-009
	,-3.510092121e-009
	,-2.442967595e-009
	,-1.698492050e-009
	,-1.179840829e-009
	,-8.189607956e-010
	,-5.681108301e-010
	,-3.938793409e-010
	,-2.729363648e-010
	,-1.890216330e-010
	,-1.308184788e-010
	,-9.045941474e-011
	,-6.247917869e-011
	,-4.308354443e-011
	,-2.963973482e-011
	,-2.032144370e-011
	,-1.386218559e-011
	,-9.383983123e-012
	,-6.278276592e-012
	,-4.123191051e-012
	,-2.626622959e-012
	,-1.586100785e-012
	,-8.612247375e-013
	,-3.550027525e-013
	,-1.592616245e-017
	,2.503224554e-013
	,4.282994966e-013
	,5.561825549e-013
	,6.495068356e-013
	,7.189794620e-013
	,7.720531199e-013
	,8.137970787e-013
	,8.477763590e-013
	,8.764681053e-013
	,9.015947267e-013
	,9.243247212e-013
	,9.454806010e-013
	,9.656308980e-013
	,9.850796158e-013
	,1.004291585e-012
	,1.023264246e-012
	,1.042225628e-012
	,1.061264343e-012
	,1.080465973e-012
	,1.099787805e-012
	,1.119383669e-012
	,1.139179573e-012
	,1.159268203e-012
	,1.179584861e-012
	,1.200240717e-012
	,1.221120581e-012
	,1.242280064e-012
	,1.263776290e-012
	,1.285523677e-012
	,1.307594596e-012
	,1.329969415e-012
	,1.352658054e-012
	,1.375618323e-012
	,1.398907607e-012
	,1.422434214e-012
	,1.446331297e-012
	,1.470461630e-012
	,1.494930534e-012
	,1.519641983e-012
	,1.544696128e-012
	,1.569984777e-012
	,1.595533881e-012
	,1.621336287e-012
	,1.647396485e-012
	,1.673706225e-012
	,1.700210836e-012
	,1.726967548e-012
	,1.753931455e-012
	,1.781071800e-012
	,1.808428322e-012
	,1.835921964e-012
	,1.863603584e-012
	,1.891347760e-012
	,1.919329677e-012
	,1.947374880e-012
	,1.975576054e-012
	,2.003887717e-012
	,2.032269507e-012
	,2.060726018e-012
	,2.089254275e-012
	,2.117832138e-012
	,2.146428537e-012
	,2.174947917e-012
	,2.203459203e-012
	,2.231852481e-012
	,2.260243826e-012
	,2.288432990e-012
	,2.316470674e-012
	,2.344341109e-012
	,2.372015628e-012
	,2.399377528e-012
	,2.426501843e-012
	,2.453279494e-012
	,2.479725153e-012
	,2.505817986e-012
	,2.531519823e-012
	,2.556820064e-012
	,2.581712704e-012
	,2.606226201e-012
	,2.630355803e-012
	,2.654099787e-012
	,2.677656471e-012
	,2.700849677e-012
	,2.723871039e-012
	,2.746759876e-012
	,2.769520103e-012
	,2.792198038e-012
	,2.814813679e-012
	,2.837488846e-012
	,2.860099265e-012
	,2.882701434e-012
	,2.905335455e-012
	,2.927934125e-012
	,2.950538644e-012
	,2.973092356e-012
	,2.995617558e-012
	,3.018090856e-012
	,3.040543686e-012
	,3.062944613e-012
	,3.085272333e-012
	,3.107626108e-012
	,3.129841458e-012
	,3.152149179e-012
	,3.174406772e-012
	,3.196700917e-012
	,3.218938302e-012
	,3.241255108e-012
	,3.263711802e-012
	,3.286108186e-012
	,3.308661951e-012
	,3.331288609e-012
	,3.353969886e-012
	,3.376787656e-012
	,3.399694977e-012
	,3.422686680e-012
	,3.445872471e-012
	,3.469146978e-012
	,3.492523672e-012
	,3.516130536e-012
	,3.539898644e-012
	,3.563777608e-012
	,3.587941882e-012
	,3.612262387e-012
	,3.636835254e-012
	,3.661608840e-012
	,3.686722564e-012
	,3.712193344e-012
	,3.738018255e-012
	,3.764311651e-012
	,3.791200261e-012
	,3.818745388e-012
	,3.847143731e-012
	,3.876579874e-012
	,3.907343618e-012
	,3.939803872e-012
	,3.974137283e-012
	,4.011000421e-012
	,4.051043119e-012
	,4.095129713e-012
	,4.144378939e-012
	,4.200385016e-012
	,4.264860588e-012
	,4.340377468e-012
	,4.430010835e-012
	,4.537817848e-012
	,4.669156586e-012
	,4.830810842e-012
	,5.031865482e-012
	,5.283662998e-012
	,5.601351045e-012
	,6.003574052e-012
	,6.515189832e-012
	,7.169768391e-012
	,8.009899073e-012
	,9.091224893e-012
	,1.048630285e-011
	,1.228972498e-011
	,1.462518095e-011
	,1.765379565e-011
	,2.158529628e-011
	,-1.470557349e-006
	,-1.040554655e-006
	,-7.343547641e-007
	,-5.172874883e-007
	,-3.638859055e-007
	,-2.557152715e-007
	,-1.795598470e-007
	,-1.260062683e-007
	,-8.837909938e-008
	,-6.195916222e-008
	,-4.341766241e-008
	,-3.041035421e-008
	,-2.128833735e-008
	,-1.489289261e-008
	,-1.041040018e-008
	,-7.269955337e-009
	,-5.071161529e-009
	,-3.533177965e-009
	,-2.458814311e-009
	,-1.709410352e-009
	,-1.187407128e-009
	,-8.242349729e-010
	,-5.718053575e-010
	,-3.964770753e-010
	,-2.747677318e-010
	,-1.903149462e-010
	,-1.317327276e-010
	,-9.110590869e-011
	,-6.293624215e-011
	,-4.340638874e-011
	,-2.986730854e-011
	,-2.048140046e-011
	,-1.397405567e-011
	,-9.461623277e-012
	,-6.331562718e-012
	,-4.159136904e-012
	,-2.650153535e-012
	,-1.600634533e-012
	,-8.693472027e-013
	,-3.584047534e-013
	,-1.472518595e-017
	,2.528710842e-013
	,4.327476525e-013
	,5.621319314e-013
	,6.566795895e-013
	,7.271180620e-013
	,7.809830067e-013
	,8.234427998e-013
	,8.581245469e-013
	,8.874669091e-013
	,9.131601826e-013
	,9.365292532e-013
	,9.582435349e-013
	,9.789329659e-013
	,9.990635773e-013
	,1.018810190e-012
	,1.038457121e-012
	,1.058039982e-012
	,1.077737929e-012
	,1.097604587e-012
	,1.117667943e-012
	,1.137967423e-012
	,1.158557904e-012
	,1.179371871e-012
	,1.200495794e-012
	,1.221962883e-012
	,1.243720191e-012
	,1.265812572e-012
	,1.288220443e-012
	,1.310989861e-012
	,1.334053048e-012
	,1.357512297e-012
	,1.381266724e-012
	,1.405369748e-012
	,1.429803302e-012
	,1.454687848e-012
	,1.479853214e-012
	,1.505448373e-012
	,1.531367012e-012
	,1.557658476e-012
	,1.584336707e-012
	,1.611343275e-012
	,1.638679327e-012
	,1.666458175e-012
	,1.694562330e-012
	,1.723030173e-012
	,1.751827501e-012
	,1.780953217e-012
	,1.810428313e-012
	,1.840239526e-012
	,1.870347642e-012
	,1.900740702e-012
	,1.931439071e-012
	,1.962457996e-012
	,1.993758629e-012
	,2.025328907e-012
	,2.057174418e-012
	,2.089251351e-012
	,2.121627954e-012
	,2.154207993e-012
	,2.187020811e-012
	,2.220086723e-012
	,2.253340927e-012
	,2.286785094e-012
	,2.320468620e-012
	,2.354313757e-012
	,2.388229176e-012
	,2.422340564e-012
	,2.456537221e-012
	,2.490787087e-012
	,2.525080135e-012
	,2.559414382e-012
	,2.593725028e-012
	,2.627898083e-012
	,2.662054115e-012
	,2.695985461e-012
	,2.729667996e-012
	,2.763162290e-012
	,2.796299895e-012
	,2.829047391e-012
	,2.861297370e-012
	,2.893041894e-012
	,2.924165879e-012
	,2.954668019e-012
	,2.984439965e-012
	,3.013515188e-012
	,3.041770301e-012
	,3.069335479e-012
	,3.096229520e-012
	,3.122471066e-012
	,3.148088103e-012
	,3.173272006e-012
	,3.198000321e-012
	,3.222419411e-012
	,3.246574599e-012
	,3.270582641e-012
	,3.294420197e-012
	,3.318312789e-012
	,3.342051813e-012
	,3.365859657e-012
	,3.389734861e-012
	,3.413672516e-012
	,3.437687346e-012
	,3.461814338e-012
	,3.486020228e-012
	,3.510409136e-012
	,3.534861070e-012
	,3.559506257e-012
	,3.584250602e-012
	,3.609160839e-012
	,3.634174568e-012
	,3.659381394e-012
	,3.684714218e-012
	,3.710239512e-012
	,3.735868507e-012
	,3.761659320e-012
	,3.787652995e-012
	,3.813738831e-012
	,3.840002933e-012
	,3.866453710e-012
	,3.893020041e-012
	,3.919821607e-012
	,3.946728807e-012
	,3.973848005e-012
	,4.001114923e-012
	,4.028573110e-012
	,4.056224236e-012
	,4.083981413e-012
	,4.112012466e-012
	,4.140241627e-012
	,4.168716937e-012
	,4.197347956e-012
	,4.226282038e-012
	,4.255420339e-012
	,4.284922483e-012
	,4.314701635e-012
	,4.344886613e-012
	,4.375495796e-012
	,4.406623280e-012
	,4.438320652e-012
	,4.470778818e-012
	,4.504118343e-012
	,4.538494729e-012
	,4.574176524e-012
	,4.611539477e-012
	,4.650725460e-012
	,4.692622256e-012
	,4.737727174e-012
	,4.786797612e-012
	,4.841166444e-012
	,4.902161326e-012
	,4.971640218e-012
	,5.052020217e-012
	,5.146267109e-012
	,5.258501548e-012
	,5.393782883e-012
	,5.558993230e-012
	,5.762731426e-012
	,6.016322157e-012
	,6.334441615e-012
	,6.736023249e-012
	,-1.094335468e-008
	,-8.180244494e-009
	,-6.109373873e-009
	,-4.566511495e-009
	,-3.420319170e-009
	,-2.568753135e-009
	,-1.934862720e-009
	,-1.461734229e-009
	,-1.107618793e-009
	,-8.423650026e-010
	,-6.435030885e-010
	,-4.941433963e-010
	,-3.815497291e-010
	,-2.964608187e-010
	,-2.320401274e-010
	,-1.830244560e-010
	,-1.455909704e-010
	,-1.169237504e-010
	,-9.495836345e-011
	,-7.808834277e-011
	,-6.493552073e-011
	,-5.466456159e-011
	,-4.653373295e-011
	,-4.000055380e-011
	,-3.468476191e-011
	,-3.031293348e-011
	,-2.672382096e-011
	,-2.373685356e-011
	,-2.120801636e-011
	,-1.902838536e-011
	,-1.712701665e-011
	,-1.543577518e-011
	,-1.389809056e-011
	,-1.245967135e-011
	,-1.107322393e-011
	,-9.686650452e-012
	,-8.239175356e-012
	,-6.656869969e-012
	,-4.846060215e-012
	,-2.682645589e-012
	,1.237510983e-017
	,3.428967422e-012
	,7.915702570e-012
	,1.388993750e-011
	,2.191305734e-011
	,3.274903514e-011
	,4.752941228e-011
	,6.778755272e-011
	,9.564938105e-011
	,1.340762806e-010
	,1.871401906e-010
	,2.605862000e-010
	,3.623200572e-010
	,5.031662433e-010
	,6.986558307e-010
	,9.697584719e-010
	,1.343364217e-009
	,1.855080495e-009
	,2.556754166e-009
	,3.516269183e-009
	,4.836803434e-009
	,6.633518441e-009
	,9.087114471e-009
	,1.243713739e-008
	,1.699992880e-008
	,2.323277263e-008
	,3.171142503e-008
	,4.323803125e-008
	,5.886046970e-008
	,7.996689199e-008
	,1.082048614e-007
	,1.459044666e-007
	,1.960205889e-007
	,2.622712759e-007
	,3.493467315e-007
	,4.631246752e-007
	,6.109219121e-007
	,8.017821728e-007
	,1.046797716e-006
	,1.359459315e-006
	,1.755984434e-006
	,2.253404154e-006
	,2.860480231e-006
	,3.599624136e-006
	,4.501110710e-006
	,5.592226626e-006
	,6.902179731e-006
	,8.443948641e-006
	,1.010629423e-005
	,1.196539810e-005
	,1.398016950e-005
	,1.626366425e-005
	,1.883842025e-005
	,2.172390154e-005
	,2.494520122e-005
	,2.852235484e-005
	,3.247634553e-005
	,3.682748573e-005
	,4.159579370e-005
	,4.678156182e-005
	,5.217395145e-005
	,5.798380939e-005
	,6.422478723e-005
	,7.088794686e-005
	,7.792370835e-005
	,8.492661074e-005
	,9.209195589e-005
	,9.966557875e-005
	,1.076562984e-004
	,1.160738957e-004
	,1.247577740e-004
	,1.334038887e-004
	,1.425082075e-004
	,1.520558154e-004
	,1.618895978e-004
	,1.716227974e-004
	,1.817938928e-004
	,1.924016607e-004
	,2.034116616e-004
	,2.146370797e-004
	,2.261470781e-004
	,2.364496630e-004
	,2.471406196e-004
	,2.583689810e-004
	,2.690843568e-004
	,2.797383839e-004
	,2.908569075e-004
	,3.023999226e-004
	,3.143414896e-004
	,3.256084048e-004
	,3.364517889e-004
	,3.476072584e-004
	,3.590146701e-004
	,3.706738071e-004
	,3.824545357e-004
	,3.929118565e-004
	,4.036724737e-004
	,4.147083564e-004
	,4.259961623e-004
	,4.375056203e-004
	,4.492274359e-004
	,4.611775557e-004
	,4.733342509e-004
	,4.856903023e-004
	,4.982412999e-004
	,5.109760161e-004
	,5.238779884e-004
	,5.369561613e-004
	,5.502162366e-004
	,5.636492046e-004
	,5.772748150e-004
	,5.910650934e-004
	,6.050164632e-004
	,6.191261925e-004
	,6.333912801e-004
	,6.478125035e-004
	,6.622952966e-004
	,6.767343260e-004
	,6.913161301e-004
	,7.060439722e-004
	,7.209317571e-004
	,7.351892394e-004
	,7.493494710e-004
	,7.636291280e-004
	,7.780263057e-004
	,7.925710127e-004
	,8.072381101e-004
	,8.220214358e-004
	,8.369198770e-004
	,8.519324334e-004
	,8.670582054e-004
	,8.822963841e-004
	,8.976459497e-004
	,9.131090963e-004
	,9.286885596e-004
	,9.443903176e-004
	,9.602072461e-004
	,9.761341649e-004
	,9.921708028e-004
	,1.008316939e-003
	,1.024572400e-003
	,1.040935211e-003
	,1.057422250e-003
	,1.074038491e-003
	,1.090764927e-003
	,1.107600591e-003
	,1.124545280e-003
	,1.141600194e-003
	,1.158765397e-003
	,1.176040959e-003
	,1.193426946e-003
	,1.210923418e-003
	,1.228530422e-003
	,1.246247992e-003
	,1.264085044e-003
	,1.282067131e-003
	,1.300148969e-003
	,1.318342071e-003
	,1.336648685e-003
	,1.355069360e-003
	,1.373603357e-003
	,-3.641257322e-008
	,-2.731788431e-008
	,-2.048679089e-008
	,-1.536190520e-008
	,-1.151098344e-008
	,-8.611103756e-009
	,-6.424081417e-009
	,-4.774831476e-009
	,-3.536375596e-009
	,-2.611450630e-009
	,-1.924154689e-009
	,-1.416492467e-009
	,-1.043347772e-009
	,-7.697446058e-010
	,-5.691700039e-010
	,-4.219583680e-010
	,-3.137142587e-010
	,-2.339477166e-010
	,-1.750289490e-010
	,-1.314336312e-010
	,-9.912547281e-011
	,-7.512326009e-011
	,-5.726736328e-011
	,-4.394689782e-011
	,-3.397218746e-011
	,-2.646912178e-011
	,-2.082066880e-011
	,-1.653615298e-011
	,-1.327583148e-011
	,-1.076928957e-011
	,-8.837509940e-012
	,-7.332465461e-012
	,-6.139716383e-012
	,-5.169464858e-012
	,-4.355643446e-012
	,-3.639471502e-012
	,-2.975890840e-012
	,-2.320517600e-012
	,-1.639149066e-012
	,-8.832356604e-013
	,-2.141040891e-018
	,1.075106851e-012
	,2.431987121e-012
	,4.190631573e-012
	,6.513512067e-012
	,9.615301326e-012
	,1.379937082e-011
	,1.948018661e-011
	,2.722347334e-011
	,3.781904354e-011
	,5.235433975e-011
	,7.233388461e-011
	,9.984139985e-011
	,1.377653093e-010
	,1.900620479e-010
	,2.622664432e-010
	,3.621098568e-010
	,5.002837176e-010
	,6.916956901e-010
	,9.570682695e-010
	,1.325037316e-009
	,1.835894577e-009
	,2.544984659e-009
	,3.528387820e-009
	,4.889796697e-009
	,6.773353731e-009
	,9.386116546e-009
	,1.299648439e-008
	,1.793411619e-008
	,2.475002389e-008
	,3.415491894e-008
	,4.710737442e-008
	,6.479062705e-008
	,8.904211170e-008
	,1.222288550e-007
	,1.675074547e-007
	,2.290463372e-007
	,3.120655927e-007
	,4.231327559e-007
	,5.711703635e-007
	,7.626626580e-007
	,1.007150773e-006
	,1.320272611e-006
	,1.709727928e-006
	,2.191452303e-006
	,2.783979646e-006
	,3.506161376e-006
	,4.375960553e-006
	,5.416331858e-006
	,6.649025590e-006
	,8.096302761e-006
	,9.780499813e-006
	,1.172398348e-005
	,1.394905720e-005
	,1.647760838e-005
	,1.933106199e-005
	,2.253035594e-005
	,2.601197209e-005
	,2.982239183e-005
	,3.399881951e-005
	,3.855484682e-005
	,4.350230246e-005
	,4.867918659e-005
	,5.398063115e-005
	,5.964022689e-005
	,6.566536145e-005
	,7.206139053e-005
	,7.839159736e-005
	,8.510024810e-005
	,9.220363287e-005
	,9.962520677e-005
	,1.074014200e-004
	,1.153639189e-004
	,1.235725166e-004
	,1.319259475e-004
	,1.406869211e-004
	,1.498650207e-004
	,1.594748592e-004
	,1.693702647e-004
	,1.787350825e-004
	,1.885403581e-004
	,1.988247241e-004
	,2.095980368e-004
	,2.208968748e-004
	,2.316567646e-004
	,2.425390944e-004
	,2.536516718e-004
	,2.650532983e-004
	,2.757434102e-004
	,2.863205779e-004
	,2.971161713e-004
	,3.068858851e-004
	,3.169742248e-004
	,3.273418294e-004
	,3.379656727e-004
	,3.488224980e-004
	,3.598980018e-004
	,3.711814044e-004
	,3.826794963e-004
	,3.943816811e-004
	,4.062804951e-004
	,4.183549447e-004
	,4.306123644e-004
	,4.430625510e-004
	,4.556909534e-004
	,4.684971142e-004
	,4.814773198e-004
	,4.946210386e-004
	,5.079207897e-004
	,5.213833747e-004
	,5.350167682e-004
	,5.488125013e-004
	,5.627855708e-004
	,5.768201976e-004
	,5.902106774e-004
	,6.037345517e-004
	,6.173875282e-004
	,6.310236763e-004
	,6.445998842e-004
	,6.582966479e-004
	,6.721157690e-004
	,6.860579811e-004
	,7.001393909e-004
	,7.143360266e-004
	,7.286461408e-004
	,7.430685776e-004
	,7.576022624e-004
	,7.722705171e-004
	,7.870600740e-004
	,8.019611237e-004
	,8.169729647e-004
	,8.320949573e-004
	,8.473264741e-004
	,8.626665375e-004
	,8.781152437e-004
	,8.936731357e-004
	,9.093472223e-004
	,9.251404479e-004
	,9.410435923e-004
	,9.570544983e-004
	,9.731730110e-004
	,9.893990135e-004
	,1.005732425e-003
	,1.022173198e-003
	,1.038734216e-003
	,1.055422097e-003
	,1.072217168e-003
	,1.089114108e-003
	,1.106118825e-003
	,1.123230769e-003
	,1.140451430e-003
	,1.157780922e-003
	,1.175219359e-003
	,1.192766842e-003
	,1.210423464e-003
	,1.228189301e-003
	,1.246064407e-003
	,1.264093139e-003
	,1.282234483e-003
	,1.300488934e-003
	,1.318857008e-003
	,-1.348555966e-007
	,-1.003622178e-007
	,-7.472368560e-008
	,-5.565424379e-008
	,-4.147922313e-008
	,-3.094346424e-008
	,-2.310176859e-008
	,-1.724896361e-008
	,-1.286561761e-008
	,-9.579215536e-009
	,-7.121696000e-009
	,-5.286472063e-009
	,-3.912835873e-009
	,-2.887241571e-009
	,-2.125276743e-009
	,-1.560907722e-009
	,-1.143612807e-009
	,-8.356393696e-010
	,-6.089556012e-010
	,-4.427729238e-010
	,-3.215410037e-010
	,-2.334551841e-010
	,-1.695958080e-010
	,-1.233330491e-010
	,-8.981867112e-011
	,-6.552171867e-011
	,-4.788448187e-011
	,-3.506099767e-011
	,-2.572027340e-011
	,-1.890388049e-011
	,-1.392056778e-011
	,-1.026827230e-011
	,-7.581713669e-012
	,-5.594653878e-012
	,-4.112328219e-012
	,-2.994404467e-012
	,-2.137786362e-012
	,-1.463106015e-012
	,-9.124681072e-013
	,-4.378397932e-013
	,-1.900692824e-017
	,4.367921758e-013
	,9.088737930e-013
	,1.455939944e-012
	,2.127043679e-012
	,2.983802664e-012
	,4.106836518e-012
	,5.604465229e-012
	,7.624020311e-012
	,1.036734294e-011
	,1.411252867e-011
	,1.924369612e-011
	,2.626594924e-011
	,3.578300458e-011
	,4.881017727e-011
	,6.669553398e-011
	,9.107980547e-011
	,1.243549040e-010
	,1.699818314e-010
	,2.326292381e-010
	,3.185017201e-010
	,4.358371516e-010
	,5.971027389e-010
	,8.187961215e-010
	,1.123459102e-009
	,1.542918674e-009
	,2.120807303e-009
	,2.917364893e-009
	,4.015978920e-009
	,5.531871763e-009
	,7.586822477e-009
	,1.039812448e-008
	,1.424968283e-008
	,1.952662881e-008
	,2.674672549e-008
	,3.661703006e-008
	,5.010922716e-008
	,6.846070572e-008
	,9.345832159e-008
	,1.274438924e-007
	,1.733272221e-007
	,2.351834672e-007
	,3.183609427e-007
	,4.297168295e-007
	,5.779269970e-007
	,7.728697578e-007
	,1.028300007e-006
	,1.359945702e-006
	,1.786144364e-006
	,2.326472122e-006
	,3.000937535e-006
	,3.834846764e-006
	,4.851337604e-006
	,6.074298950e-006
	,7.528292915e-006
	,9.236104297e-006
	,1.121920210e-005
	,1.344372609e-005
	,1.592747948e-005
	,1.870652193e-005
	,2.177928880e-005
	,2.505419783e-005
	,2.862966188e-005
	,3.243136980e-005
	,3.654105410e-005
	,4.097168938e-005
	,4.573268470e-005
	,5.083390334e-005
	,5.628572147e-005
	,6.209904562e-005
	,6.827211381e-005
	,7.475807143e-005
	,8.147757291e-005
	,8.855245497e-005
	,9.599054199e-005
	,1.038002494e-004
	,1.115723876e-004
	,1.195909120e-004
	,1.279575070e-004
	,1.366899875e-004
	,1.458066399e-004
	,1.553292739e-004
	,1.652695837e-004
	,1.756711115e-004
	,1.860582484e-004
	,1.967254816e-004
	,2.071111739e-004
	,2.165276975e-004
	,2.259987797e-004
	,2.355888680e-004
	,2.454199920e-004
	,2.555049886e-004
	,2.658293036e-004
	,2.763820127e-004
	,2.871545050e-004
	,2.981374566e-004
	,3.093289038e-004
	,3.207134207e-004
	,3.322840847e-004
	,3.440379644e-004
	,3.559831753e-004
	,3.681133342e-004
	,3.804249407e-004
	,3.929043750e-004
	,4.055511809e-004
	,4.183796186e-004
	,4.309692590e-004
	,4.434224736e-004
	,4.560248643e-004
	,4.687677177e-004
	,4.816455381e-004
	,4.946596259e-004
	,5.078187532e-004
	,5.211123067e-004
	,5.345555734e-004
	,5.481311121e-004
	,5.618334218e-004
	,5.756604629e-004
	,5.894864752e-004
	,6.030850687e-004
	,6.168044257e-004
	,6.306391714e-004
	,6.445906768e-004
	,6.586603321e-004
	,6.728562707e-004
	,6.871710357e-004
	,7.015965408e-004
	,7.161319025e-004
	,7.307755686e-004
	,7.455337011e-004
	,7.604243573e-004
	,7.754246052e-004
	,7.905338823e-004
	,8.057511527e-004
	,8.210764028e-004
	,8.365093196e-004
	,8.520494981e-004
	,8.676972406e-004
	,8.832075035e-004
	,8.984596306e-004
	,9.138121332e-004
	,9.292607556e-004
	,9.448052186e-004
	,9.604452793e-004
	,9.761807290e-004
	,9.920113904e-004
	,1.007937117e-003
	,1.023982267e-003
	,1.040128411e-003
	,1.056370033e-003
	,1.072706169e-003
	,1.089138100e-003
	,1.105665060e-003
	,1.122286346e-003
	,1.139003335e-003
	,1.155816037e-003
	,1.172724454e-003
	,1.189728588e-003
	,1.206828429e-003
	,1.224027209e-003
	,1.241354515e-003
	,-5.706097895e-007
	,-4.207948573e-007
	,-3.101887541e-007
	,-2.289075380e-007
	,-1.692127406e-007
	,-1.252903495e-007
	,-9.285814899e-008
	,-6.880610156e-008
	,-5.091613088e-008
	,-3.761346697e-008
	,-2.773844698e-008
	,-2.041642985e-008
	,-1.500052980e-008
	,-1.100885483e-008
	,-8.074132214e-009
	,-5.918991004e-009
	,-4.336671975e-009
	,-3.174328134e-009
	,-2.319342387e-009
	,-1.689772573e-009
	,-1.228229915e-009
	,-8.916013521e-010
	,-6.461722192e-010
	,-4.671099749e-010
	,-3.365186078e-010
	,-2.415004327e-010
	,-1.726622415e-010
	,-1.230514556e-010
	,-8.746577472e-011
	,-6.202943070e-011
	,-4.388569616e-011
	,-3.095445664e-011
	,-2.173668705e-011
	,-1.515977898e-011
	,-1.045935690e-011
	,-7.091918641e-012
	,-4.671009797e-012
	,-2.921140985e-012
	,-1.646032959e-012
	,-7.059613471e-013
	,4.490438029e-018
	,5.449001117e-013
	,9.826537478e-013
	,1.353624684e-012
	,1.689284300e-012
	,2.016553894e-012
	,2.359876158e-012
	,2.744603078e-012
	,3.199727116e-012
	,3.760842395e-012
	,4.472334813e-012
	,5.393479192e-012
	,6.603264435e-012
	,8.213298750e-012
	,1.037374984e-011
	,1.328932701e-011
	,1.724017313e-011
	,2.259869346e-011
	,2.988137067e-011
	,3.979629245e-011
	,5.331908809e-011
	,7.179827285e-011
	,9.707679373e-011
	,1.316868786e-010
	,1.791090467e-010
	,2.441284459e-010
	,3.331042862e-010
	,4.526829378e-010
	,6.160808568e-010
	,8.383727818e-010
	,1.141103694e-009
	,1.552896859e-009
	,2.114003827e-009
	,2.880548411e-009
	,3.928215690e-009
	,5.360628036e-009
	,7.270276834e-009
	,9.785931076e-009
	,1.317177954e-008
	,1.772731196e-008
	,2.385318142e-008
	,3.208658883e-008
	,4.314108181e-008
	,5.797196934e-008
	,7.783620342e-008
	,1.044147181e-007
	,1.398592242e-007
	,1.870691270e-007
	,2.497312550e-007
	,3.325632141e-007
	,4.418388817e-007
	,5.853568512e-007
	,7.726016476e-007
	,1.015547701e-006
	,1.328663668e-006
	,1.728942986e-006
	,2.235980733e-006
	,2.871770043e-006
	,3.659647217e-006
	,4.625173092e-006
	,5.794159320e-006
	,7.191970784e-006
	,8.842756801e-006
	,1.076876076e-005
	,1.298985587e-005
	,1.552306518e-005
	,1.837922111e-005
	,2.156059381e-005
	,2.508328236e-005
	,2.895381479e-005
	,3.315981712e-005
	,3.767782878e-005
	,4.253694027e-005
	,4.773744678e-005
	,5.327962314e-005
	,5.916392098e-005
	,6.539178752e-005
	,7.185248646e-005
	,7.861953632e-005
	,8.572320984e-005
	,9.317283036e-005
	,1.009798542e-004
	,1.091611322e-004
	,1.176749294e-004
	,1.261768729e-004
	,1.348552896e-004
	,1.438223858e-004
	,1.530711319e-004
	,1.625848991e-004
	,1.723720421e-004
	,1.823960970e-004
	,1.926518093e-004
	,2.028827968e-004
	,2.131923800e-004
	,2.237336164e-004
	,2.345014398e-004
	,2.454910802e-004
	,2.566977328e-004
	,2.678297846e-004
	,2.790524793e-004
	,2.904524672e-004
	,3.020168690e-004
	,3.137501585e-004
	,3.256504200e-004
	,3.377120206e-004
	,3.499310078e-004
	,3.623007268e-004
	,3.746006511e-004
	,3.870011049e-004
	,3.995353227e-004
	,4.122014354e-004
	,4.249990600e-004
	,4.379248307e-004
	,4.509755627e-004
	,4.641479833e-004
	,4.774538387e-004
	,4.908770058e-004
	,5.044325196e-004
	,5.181057620e-004
	,5.318924497e-004
	,5.456721569e-004
	,5.590436997e-004
	,5.725231029e-004
	,5.861137958e-004
	,5.998104038e-004
	,6.136174921e-004
	,6.275304518e-004
	,6.415585899e-004
	,6.556944051e-004
	,6.699316897e-004
	,6.842695546e-004
	,6.987071502e-004
	,7.132436643e-004
	,7.279003481e-004
	,7.426587438e-004
	,7.575161733e-004
	,7.724722248e-004
	,7.875263594e-004
	,8.026780732e-004
	,8.179270302e-004
	,8.332756396e-004
	,8.487204088e-004
	,8.642738048e-004
	,8.799248899e-004
	,8.956717485e-004
	,9.115140927e-004
	,9.274517797e-004
	,9.434846219e-004
	,9.596124588e-004
	,9.758351565e-004
	,9.921692923e-004
	,1.008608450e-003
	,1.025143272e-003
	,1.041773726e-003
	,1.058499798e-003
	,1.075318694e-003
	,1.092179454e-003
	,1.109133511e-003
	,1.126181023e-003
	,1.143323030e-003
	,1.160559543e-003
	,-2.424999481e-006
	,-1.839554446e-006
	,-1.378417565e-006
	,-1.021244976e-006
	,-7.517261760e-007
	,-5.518190949e-007
	,-4.037119597e-007
	,-2.943560370e-007
	,-2.142342276e-007
	,-1.557538074e-007
	,-1.131124860e-007
	,-8.199371316e-008
	,-5.924035290e-008
	,-4.262991034e-008
	,-3.058187102e-008
	,-2.189908961e-008
	,-1.566587738e-008
	,-1.119894825e-008
	,-7.999917154e-009
	,-5.709275167e-009
	,-4.068962930e-009
	,-2.894581297e-009
	,-2.054700770e-009
	,-1.455176900e-009
	,-1.028116112e-009
	,-7.246432474e-010
	,-5.095931034e-010
	,-3.574802213e-010
	,-2.501213750e-010
	,-1.745145938e-010
	,-1.213559385e-010
	,-8.402969919e-011
	,-5.784652830e-011
	,-3.949250695e-011
	,-2.663120807e-011
	,-1.761892744e-011
	,-1.130117083e-011
	,-6.868085810e-012
	,-3.752016837e-012
	,-1.555420222e-012
	,1.467263008e-017
	,1.108840244e-012
	,1.907440688e-012
	,2.491145343e-012
	,2.926845936e-012
	,3.261452557e-012
	,3.527810607e-012
	,3.750172972e-012
	,3.946167533e-012
	,4.129712040e-012
	,4.312465991e-012
	,4.504374464e-012
	,4.715646438e-012
	,4.959676873e-012
	,5.251788507e-012
	,5.611567282e-012
	,6.064917269e-012
	,6.646152298e-012
	,7.400923262e-012
	,8.393098143e-012
	,9.707587702e-012
	,1.145969639e-011
	,1.380723794e-011
	,1.696460458e-011
	,2.122502239e-011
	,2.698960557e-011
	,3.480427662e-011
	,4.541309739e-011
	,5.983137218e-011
	,7.944485956e-011
	,1.061458748e-010
	,1.425194380e-010
	,1.920974860e-010
	,2.573548978e-010
	,3.453312857e-010
	,4.646610922e-010
	,6.266610336e-010
	,8.463277557e-010
	,1.144241545e-009
	,1.548849959e-009
	,2.098892412e-009
	,2.847125292e-009
	,3.858225054e-009
	,5.138710399e-009
	,6.845844251e-009
	,9.121702224e-009
	,1.215544555e-008
	,1.619873551e-008
	,2.158607485e-008
	,2.876160022e-008
	,3.831395216e-008
	,5.102227293e-008
	,6.791416873e-008
	,9.034103114e-008
	,1.200816056e-007
	,1.594537494e-007
	,2.114450233e-007
	,2.798317644e-007
	,3.696986590e-007
	,4.873687271e-007
	,6.407929568e-007
	,8.398993391e-007
	,1.096829218e-006
	,1.426212408e-006
	,1.845250466e-006
	,2.374026193e-006
	,3.035132337e-006
	,3.853391315e-006
	,4.855273126e-006
	,6.068109077e-006
	,7.519168845e-006
	,9.234671794e-006
	,1.123899429e-005
	,1.355391888e-005
	,1.619769201e-005
	,1.918227885e-005
	,2.252129126e-005
	,2.622316015e-005
	,3.029362652e-005
	,3.473387725e-005
	,3.953904538e-005
	,4.470756481e-005
	,5.022798610e-005
	,5.610535944e-005
	,6.233556700e-005
	,6.891358042e-005
	,7.583407711e-005
	,8.309182930e-005
	,9.068144344e-005
	,9.859679521e-005
	,1.068326976e-004
	,1.153838512e-004
	,1.242424100e-004
	,1.334040996e-004
	,1.428592798e-004
	,1.525953146e-004
	,1.625633888e-004
	,1.727987821e-004
	,1.830466048e-004
	,1.933834240e-004
	,2.039545125e-004
	,2.147517490e-004
	,2.257669243e-004
	,2.369924285e-004
	,2.484217663e-004
	,2.600456232e-004
	,2.718585517e-004
	,2.838546582e-004
	,2.960276679e-004
	,3.083724565e-004
	,3.208838617e-004
	,3.335609009e-004
	,3.463963455e-004
	,3.593836027e-004
	,3.725187390e-004
	,3.857990955e-004
	,3.992195943e-004
	,4.127753523e-004
	,4.264676255e-004
	,4.402928947e-004
	,4.542454561e-004
	,4.683337133e-004
	,4.825438145e-004
	,4.968731071e-004
	,5.105678541e-004
	,5.242396393e-004
	,5.380235651e-004
	,5.519220825e-004
	,5.659328078e-004
	,5.800544124e-004
	,5.942837446e-004
	,6.086317185e-004
	,6.230852048e-004
	,6.376430809e-004
	,6.523042465e-004
	,6.670677236e-004
	,6.819325556e-004
	,6.969159910e-004
	,7.120025277e-004
	,7.271900280e-004
	,7.424777852e-004
	,7.578651345e-004
	,7.733517511e-004
	,7.889381417e-004
	,8.046222938e-004
	,8.204076048e-004
	,8.362967043e-004
	,8.522834777e-004
	,8.683668403e-004
	,8.845464468e-004
	,9.008219518e-004
	,9.171930249e-004
	,9.336594868e-004
	,9.502211163e-004
	,9.668984462e-004
	,9.836737920e-004
	,1.000544900e-003
	,1.017511667e-003
	,1.034574009e-003
	,1.051731855e-003
	,1.068985150e-003
	,-6.074782654e-006
	,-4.647531934e-006
	,-3.512642148e-006
	,-2.625605490e-006
	,-1.942242957e-006
	,-1.423115727e-006
	,-1.034253375e-006
	,-7.461432705e-007
	,-5.344750288e-007
	,-3.806865096e-007
	,-2.702274888e-007
	,-1.913476048e-007
	,-1.351704821e-007
	,-9.523787481e-008
	,-6.692906288e-008
	,-4.694442156e-008
	,-3.287559583e-008
	,-2.298840620e-008
	,-1.605234956e-008
	,-1.119498239e-008
	,-7.798348820e-009
	,-5.426358406e-009
	,-3.772450207e-009
	,-2.620579005e-009
	,-1.819017426e-009
	,-1.261555948e-009
	,-8.740284930e-010
	,-6.047510782e-010
	,-4.177426057e-010
	,-2.879434446e-010
	,-1.978993813e-010
	,-1.354716408e-010
	,-9.221765070e-011
	,-6.226190575e-011
	,-4.152249638e-011
	,-2.716724503e-011
	,-1.723246803e-011
	,-1.035579498e-011
	,-5.593340584e-012
	,-2.291913942e-012
	,-2.924286441e-018
	,1.594907546e-012
	,2.709072763e-012
	,3.491749617e-012
	,4.045886335e-012
	,4.442514619e-012
	,4.730845161e-012
	,4.944685293e-012
	,5.107608146e-012
	,5.235696414e-012
	,5.340225962e-012
	,5.429146523e-012
	,5.508171247e-012
	,5.581793038e-012
	,5.653436873e-012
	,5.726308472e-012
	,5.803607392e-012
	,5.888132536e-012
	,5.983026075e-012
	,6.093530012e-012
	,6.225775956e-012
	,6.387606234e-012
	,6.589581919e-012
	,6.846041782e-012
	,7.176248338e-012
	,7.606353477e-012
	,8.171746269e-012
	,8.920528015e-012
	,9.918022438e-012
	,1.125282312e-011
	,1.304552685e-011
	,1.546006514e-011
	,1.871887137e-011
	,2.312551971e-011
	,2.909200312e-011
	,3.717965581e-011
	,4.815413843e-011
	,6.305950808e-011
	,8.329880604e-011
	,1.099524961e-010
	,1.453986437e-010
	,1.932970373e-010
	,2.580951731e-010
	,3.458450995e-010
	,4.647846586e-010
	,6.261312320e-010
	,8.451627677e-010
	,1.142691673e-009
	,1.547072425e-009
	,2.066334223e-009
	,2.746196075e-009
	,3.651234533e-009
	,4.856115916e-009
	,6.460219939e-009
	,8.595767115e-009
	,1.143842095e-008
	,1.522187721e-008
	,2.025635054e-008
	,2.695327278e-008
	,3.585765361e-008
	,4.769022273e-008
	,6.340223404e-008
	,8.424602537e-008
	,1.118653511e-007
	,1.483823333e-007
	,1.964776803e-007
	,2.598386918e-007
	,3.430829202e-007
	,4.521009961e-007
	,5.943232329e-007
	,7.790160039e-007
	,1.017594738e-006
	,1.323889301e-006
	,1.714361204e-006
	,2.208206181e-006
	,2.827292762e-006
	,3.595910058e-006
	,4.540268151e-006
	,5.687791780e-006
	,7.066240481e-006
	,8.702743364e-006
	,1.062285583e-005
	,1.284974512e-005
	,1.540358737e-005
	,1.830122087e-005
	,2.155605448e-005
	,2.517819587e-005
	,2.917474149e-005
	,3.355017529e-005
	,3.830680473e-005
	,4.344518883e-005
	,4.896454113e-005
	,5.486308467e-005
	,6.113835092e-005
	,6.778740117e-005
	,7.480698297e-005
	,8.219372517e-005
	,8.994411207e-005
	,9.805444422e-005
	,1.065209423e-004
	,1.153406215e-004
	,1.245100508e-004
	,1.340256916e-004
	,1.438844369e-004
	,1.540826657e-004
	,1.643196304e-004
	,1.746497535e-004
	,1.852714580e-004
	,1.961774300e-004
	,2.073587141e-004
	,2.188061979e-004
	,2.305120178e-004
	,2.424692249e-004
	,2.546715573e-004
	,2.671113832e-004
	,2.797836405e-004
	,2.926808625e-004
	,3.057955719e-004
	,3.191213651e-004
	,3.326549706e-004
	,3.463887724e-004
	,3.602738458e-004
	,3.742852696e-004
	,3.884751822e-004
	,4.028362592e-004
	,4.173689438e-004
	,4.320687175e-004
	,4.469288690e-004
	,4.612539041e-004
	,4.751969764e-004
	,4.892795924e-004
	,5.035007024e-004
	,5.178624071e-004
	,5.323611137e-004
	,5.469946349e-004
	,5.617670575e-004
	,5.766760013e-004
	,5.917178215e-004
	,6.068919798e-004
	,6.220009187e-004
	,6.372045396e-004
	,6.525194673e-004
	,6.679540076e-004
	,6.834964881e-004
	,6.991457775e-004
	,7.149008042e-004
	,7.307619712e-004
	,7.467269200e-004
	,7.627947184e-004
	,7.789666876e-004
	,7.952436126e-004
	,8.116237348e-004
	,8.281040404e-004
	,8.446840015e-004
	,8.613630225e-004
	,8.781405504e-004
	,8.950160734e-004
	,9.119891191e-004
	,9.290681050e-004
	,9.462540091e-004
	,9.635373172e-004
	,-9.387637736e-006
	,-7.239621292e-006
	,-5.501389705e-006
	,-4.119202772e-006
	,-3.040325048e-006
	,-2.216484836e-006
	,-1.599843361e-006
	,-1.145242698e-006
	,-8.141615054e-007
	,-5.754646017e-007
	,-4.047956016e-007
	,-2.835912109e-007
	,-1.979886655e-007
	,-1.377981072e-007
	,-9.564516296e-008
	,-6.625123519e-008
	,-4.582483389e-008
	,-3.166070875e-008
	,-2.185401457e-008
	,-1.507246275e-008
	,-1.038747417e-008
	,-7.153634455e-009
	,-4.923212808e-009
	,-3.386010316e-009
	,-2.327237505e-009
	,-1.598357477e-009
	,-1.096793883e-009
	,-7.517820821e-010
	,-5.145492837e-010
	,-3.515000232e-010
	,-2.394938576e-010
	,-1.625870850e-010
	,-1.097997344e-010
	,-7.357598729e-011
	,-4.872126585e-011
	,-3.166709213e-011
	,-1.996329946e-011
	,-1.192857490e-011
	,-6.409199531e-012
	,-2.613898927e-012
	,4.699303502e-018
	,1.804377376e-012
	,3.054167668e-012
	,3.923993225e-012
	,4.533640747e-012
	,4.965108733e-012
	,5.274519911e-012
	,5.500369808e-012
	,5.669099226e-012
	,5.798765577e-012
	,5.901656889e-012
	,5.986352049e-012
	,6.058677517e-012
	,6.122655519e-012
	,6.181002665e-012
	,6.235681663e-012
	,6.288140421e-012
	,6.339356742e-012
	,6.390093248e-012
	,6.441064727e-012
	,6.492734391e-012
	,6.545614482e-012
	,6.600417442e-012
	,6.658046038e-012
	,6.719728296e-012
	,6.787942716e-012
	,6.865304766e-012
	,6.955041782e-012
	,7.061486157e-012
	,7.190360856e-012
	,7.349408941e-012
	,7.549213626e-012
	,7.803961471e-012
	,8.132876299e-012
	,8.562017680e-012
	,9.126625033e-012
	,9.874567662e-012
	,1.087087322e-011
	,1.220367313e-011
	,1.399276902e-011
	,1.640095404e-011
	,1.964947339e-011
	,2.403948612e-011
	,2.998071675e-011
	,3.803093615e-011
	,4.870480594e-011
	,6.265342044e-011
	,8.143795212e-011
	,1.067711242e-010
	,1.409837384e-010
	,1.872428558e-010
	,2.498568187e-010
	,3.346881784e-010
	,4.497181715e-010
	,6.058145798e-010
	,8.119769200e-010
	,1.076008764e-009
	,1.427130705e-009
	,1.894157639e-009
	,2.515446754e-009
	,3.342051572e-009
	,4.441912232e-009
	,5.905417428e-009
	,7.852779197e-009
	,1.044379947e-008
	,1.389078186e-008
	,1.847556743e-008
	,2.457195771e-008
	,3.267513420e-008
	,4.344011987e-008
	,5.773181365e-008
	,7.668974075e-008
	,1.017918346e-007
	,1.348861864e-007
	,1.785895933e-007
	,2.361845086e-007
	,3.118977246e-007
	,4.111309166e-007
	,5.407243422e-007
	,7.092475770e-007
	,9.273014878e-007
	,1.207807759e-006
	,1.566250918e-006
	,2.020828591e-006
	,2.592460525e-006
	,3.304609993e-006
	,4.182886142e-006
	,5.254423582e-006
	,6.547072547e-006
	,8.088471101e-006
	,9.905099720e-006
	,1.202142455e-005
	,1.445922286e-005
	,1.723714911e-005
	,2.037055628e-005
	,2.387155321e-005
	,2.774923787e-005
	,3.201006273e-005
	,3.665826922e-005
	,4.169636259e-005
	,4.712545047e-005
	,5.294592453e-005
	,5.915775666e-005
	,6.576010383e-005
	,7.275192488e-005
	,8.010800519e-005
	,8.783530631e-005
	,9.593683638e-005
	,1.044098392e-004
	,1.132515724e-004
	,1.224594773e-004
	,1.320311274e-004
	,1.419632962e-004
	,1.518381577e-004
	,1.619798241e-004
	,1.724427446e-004
	,1.832201180e-004
	,1.943056317e-004
	,2.056912770e-004
	,2.173719729e-004
	,2.293398054e-004
	,2.415880901e-004
	,2.541107289e-004
	,2.669030158e-004
	,2.799577974e-004
	,2.932687991e-004
	,3.068308290e-004
	,3.206403423e-004
	,3.346897819e-004
	,3.489750054e-004
	,3.634940570e-004
	,3.782394546e-004
	,3.932065482e-004
	,4.083911857e-004
	,4.232925255e-004
	,4.373921334e-004
	,4.516651504e-004
	,4.661112608e-004
	,4.807269751e-004
	,4.955106270e-004
	,5.104641682e-004
	,5.255852036e-004
	,5.408712688e-004
	,5.563216185e-004
	,5.719356779e-004
	,5.877130452e-004
	,6.036534937e-004
	,6.197616931e-004
	,6.360362648e-004
	,6.523118863e-004
	,6.684138336e-004
	,6.846426797e-004
	,7.009974414e-004
	,7.174772840e-004
	,7.340831835e-004
	,7.508149944e-004
	,7.676703381e-004
	,7.846500162e-004
	,8.017522704e-004
	,8.189767823e-004
	,8.363233185e-004
	,-1.125463495e-005
	,-8.673300935e-006
	,-6.592810458e-006
	,-4.945328777e-006
	,-3.660698480e-006
	,-2.674951411e-006
	,-1.934051064e-006
	,-1.384047579e-006
	,-9.811962579e-007
	,-6.910001836e-007
	,-4.842036005e-007
	,-3.379284949e-007
	,-2.350538440e-007
	,-1.630388040e-007
	,-1.128210845e-007
	,-7.791611417e-008
	,-5.372036905e-008
	,-3.698751216e-008
	,-2.543824228e-008
	,-1.747893818e-008
	,-1.200055408e-008
	,-8.233877523e-009
	,-5.646280362e-009
	,-3.869832833e-009
	,-2.650893855e-009
	,-1.814844878e-009
	,-1.241604189e-009
	,-8.486722919e-010
	,-5.793977685e-010
	,-3.948969265e-010
	,-2.684956642e-010
	,-1.819048352e-010
	,-1.225932685e-010
	,-8.197823662e-011
	,-5.417414544e-011
	,-3.514210911e-011
	,-2.211283732e-011
	,-1.318980292e-011
	,-7.075141208e-012
	,-2.880960227e-012
	,2.783115518e-017
	,1.983097717e-012
	,3.352286795e-012
	,4.301818342e-012
	,4.964462504e-012
	,5.431061715e-012
	,5.763697325e-012
	,6.004849959e-012
	,6.183473752e-012
	,6.319514783e-012
	,6.426476204e-012
	,6.513651015e-012
	,6.587426323e-012
	,6.652122300e-012
	,6.710690060e-012
	,6.765210738e-012
	,6.817047703e-012
	,6.867182989e-012
	,6.916274679e-012
	,6.964775436e-012
	,7.013029993e-012
	,7.061275203e-012
	,7.109755178e-012
	,7.158597064e-012
	,7.207950358e-012
	,7.258105904e-012
	,7.309140878e-012
	,7.361364297e-012
	,7.415210183e-012
	,7.470920976e-012
	,7.528771596e-012
	,7.589793421e-012
	,7.654953393e-012
	,7.725566216e-012
	,7.803392992e-012
	,7.890764345e-012
	,7.991053558e-012
	,8.108430944e-012
	,8.248809380e-012
	,8.420092387e-012
	,8.632920774e-012
	,8.901743646e-012
	,9.246093423e-012
	,9.692373993e-012
	,1.027639764e-011
	,1.104672057e-011
	,1.206913118e-011
	,1.343306776e-011
	,1.525973918e-011
	,1.771399110e-011
	,2.101976397e-011
	,2.543598645e-011
	,3.106842780e-011
	,3.861296649e-011
	,4.874001779e-011
	,6.235868885e-011
	,8.070288672e-011
	,1.054479909e-010
	,1.388703700e-010
	,1.840648165e-010
	,2.452393307e-010
	,3.281194170e-010
	,4.320110615e-010
	,5.698700925e-010
	,7.529152189e-010
	,9.960265454e-010
	,1.318996817e-009
	,1.748153552e-009
	,2.318516280e-009
	,3.076662177e-009
	,4.084532130e-009
	,5.424481527e-009
	,7.205975694e-009
	,9.574457163e-009
	,1.272307038e-008
	,1.690813846e-008
	,2.246954844e-008
	,2.985752999e-008
	,3.966772080e-008
	,5.268690666e-008
	,6.993908667e-008
	,9.268211487e-008
	,1.227608059e-007
	,1.624800809e-007
	,2.148313331e-007
	,2.836741623e-007
	,3.739532128e-007
	,4.919497209e-007
	,6.455627506e-007
	,8.446083787e-007
	,1.101116258e-006
	,1.429592725e-006
	,1.847209552e-006
	,2.373870420e-006
	,3.032106960e-006
	,3.846766489e-006
	,4.844476798e-006
	,6.052906390e-006
	,7.499878208e-006
	,9.212426498e-006
	,1.121590226e-005
	,1.353322972e-005
	,1.618438513e-005
	,1.918609701e-005
	,2.255182648e-005
	,2.629200487e-005
	,3.041418835e-005
	,3.492369579e-005
	,3.982378524e-005
	,4.511605998e-005
	,5.080105613e-005
	,5.687849702e-005
	,6.334777257e-005
	,7.020765280e-005
	,7.745696875e-005
	,8.509450886e-005
	,9.311914778e-005
	,1.015299277e-004
	,1.103261498e-004
	,1.195076119e-004
	,1.290737506e-004
	,1.386047111e-004
	,1.484257681e-004
	,1.585976362e-004
	,1.691151493e-004
	,1.799737499e-004
	,1.911703198e-004
	,2.027007679e-004
	,2.145620544e-004
	,2.267513175e-004
	,2.392006915e-004
	,2.518423543e-004
	,2.647653234e-004
	,2.779634138e-004
	,2.914303542e-004
	,3.051635215e-004
	,3.191540991e-004
	,3.333966986e-004
	,3.478859848e-004
	,3.626167133e-004
	,3.775833550e-004
	,3.927377162e-004
	,4.065901603e-004
	,4.206224889e-004
	,4.348329352e-004
	,4.492221393e-004
	,4.637853768e-004
	,4.785202080e-004
	,4.934246187e-004
	,5.084967702e-004
	,5.237349542e-004
	,5.391375887e-004
	,5.547032161e-004
	,5.704367492e-004
	,5.863316794e-004
	,6.023867170e-004
	,6.186009059e-004
	,6.349733975e-004
	,6.515034465e-004
	,6.681921493e-004
	,6.850381219e-004
	,-1.229008380e-005
	,-9.479145317e-006
	,-7.197831082e-006
	,-5.377075690e-006
	,-3.956952767e-006
	,-2.876338717e-006
	,-2.070024108e-006
	,-1.477954929e-006
	,-1.048294127e-006
	,-7.394074278e-007
	,-5.190846089e-007
	,-3.629742816e-007
	,-2.529782944e-007
	,-1.758309773e-007
	,-1.219189883e-007
	,-8.432650187e-008
	,-5.815207362e-008
	,-4.003472236e-008
	,-2.753750554e-008
	,-1.892785486e-008
	,-1.300137958e-008
	,-8.924788159e-009
	,-6.122520182e-009
	,-4.197442832e-009
	,-2.875757576e-009
	,-1.968840838e-009
	,-1.346847704e-009
	,-9.204572800e-010
	,-6.282687375e-010
	,-4.281067423e-010
	,-2.910214282e-010
	,-1.971528936e-010
	,-1.328843873e-010
	,-8.888409658e-011
	,-5.875920516e-011
	,-3.813166111e-011
	,-2.400362846e-011
	,-1.432328935e-011
	,-7.686079989e-012
	,-3.130905681e-012
	,9.189911275e-018
	,2.156559348e-012
	,3.646721901e-012
	,4.681038055e-012
	,5.403705142e-012
	,5.913246260e-012
	,6.277080628e-012
	,6.541324020e-012
	,6.737613551e-012
	,6.887476359e-012
	,7.005615947e-012
	,7.102210069e-012
	,7.184151756e-012
	,7.256120794e-012
	,7.321450992e-012
	,7.382275125e-012
	,7.440123448e-012
	,7.495987392e-012
	,7.550652135e-012
	,7.604588198e-012
	,7.658148721e-012
	,7.711465185e-012
	,7.764781023e-012
	,7.818199831e-012
	,7.871833666e-012
	,7.925660440e-012
	,7.979781089e-012
	,8.034253466e-012
	,8.089107702e-012
	,8.144391784e-012
	,8.200180588e-012
	,8.256458399e-012
	,8.313353669e-012
	,8.371042888e-012
	,8.429613990e-012
	,8.489213179e-012
	,8.549895493e-012
	,8.612149677e-012
	,8.676369493e-012
	,8.743189058e-012
	,8.813269378e-012
	,8.887624183e-012
	,8.967676733e-012
	,9.055264263e-012
	,9.152697084e-012
	,9.263479856e-012
	,9.391886696e-012
	,9.543980971e-012
	,9.727940598e-012
	,9.954607263e-012
	,1.023881229e-011
	,1.060051545e-011
	,1.106687353e-011
	,1.167447323e-011
	,1.247304814e-011
	,1.352973577e-011
	,1.493607617e-011
	,1.681623589e-011
	,1.916725657e-011
	,2.227236021e-011
	,2.640982158e-011
	,3.193874518e-011
	,3.934536942e-011
	,4.928868239e-011
	,6.266185040e-011
	,8.067639125e-011
	,1.049794052e-010
	,1.378074394e-010
	,1.800802953e-010
	,2.348403029e-010
	,3.073825015e-010
	,4.035229822e-010
	,5.309878611e-010
	,7.000432774e-010
	,9.243313800e-010
	,1.221983061e-009
	,1.617095304e-009
	,2.141695606e-009
	,2.838350010e-009
	,3.763620326e-009
	,4.992667169e-009
	,6.625336643e-009
	,8.794219499e-009
	,1.167531841e-008
	,1.550213302e-008
	,2.058422895e-008
	,2.733166430e-008
	,3.628704353e-008
	,4.815877302e-008
	,6.379340222e-008
	,8.448857380e-008
	,1.118511821e-007
	,1.479788408e-007
	,1.955974662e-007
	,2.582302594e-007
	,3.404010857e-007
	,4.478730268e-007
	,5.879190093e-007
	,7.696155169e-007
	,1.004142364e-006
	,1.305061604e-006
	,1.688538449e-006
	,2.173458701e-006
	,2.781394014e-006
	,3.536372551e-006
	,4.464430800e-006
	,5.592952768e-006
	,6.949841092e-006
	,8.562585547e-006
	,1.045735393e-005
	,1.265819125e-005
	,1.518642206e-005
	,1.806022548e-005
	,2.129459735e-005
	,2.490135553e-005
	,2.888938594e-005
	,3.326506283e-005
	,3.803263604e-005
	,4.319464576e-005
	,4.875231392e-005
	,5.470591255e-005
	,6.105521362e-005
	,6.779936832e-005
	,7.493715371e-005
	,8.246783488e-005
	,9.039012379e-005
	,9.870297894e-005
	,1.074055272e-004
	,1.164970139e-004
	,1.256094466e-004
	,1.349733210e-004
	,1.446919195e-004
	,1.547589360e-004
	,1.651688910e-004
	,1.759170636e-004
	,1.869977480e-004
	,1.984064135e-004
	,2.101380136e-004
	,2.221881311e-004
	,2.345544752e-004
	,2.472319402e-004
	,2.602167881e-004
	,2.735058239e-004
	,2.870958359e-004
	,3.009853469e-004
	,3.151711183e-004
	,3.296514906e-004
	,3.444253551e-004
	,3.594930643e-004
	,3.743100493e-004
	,3.882113967e-004
	,4.023321624e-004
	,4.164478774e-004
	,4.307250287e-004
	,4.451839921e-004
	,4.598224064e-004
	,4.746382668e-004
	,4.896296338e-004
	,5.047953582e-004
	,5.201357430e-004
	,5.356462154e-004
	,-1.305766001e-005
	,-1.002455454e-005
	,-7.557165703e-006
	,-5.617866939e-006
	,-4.122417224e-006
	,-2.992036263e-006
	,-2.152113161e-006
	,-1.536133899e-006
	,-1.089283979e-006
	,-7.681349534e-007
	,-5.391562127e-007
	,-3.769519759e-007
	,-2.624285222e-007
	,-1.818380422e-007
	,-1.257784086e-007
	,-8.692412150e-008
	,-6.003102153e-008
	,-4.143386419e-008
	,-2.858271768e-008
	,-1.970752142e-008
	,-1.358137510e-008
	,-9.354780519e-009
	,-6.440040374e-009
	,-4.430848558e-009
	,-3.046462349e-009
	,-2.092993929e-009
	,-1.436598707e-009
	,-9.849194113e-010
	,-6.742515117e-010
	,-4.606715616e-010
	,-3.139065419e-010
	,-2.131005014e-010
	,-1.438911535e-010
	,-9.639260650e-011
	,-6.380397822e-011
	,-4.144906628e-011
	,-2.611472176e-011
	,-1.559423959e-011
	,-8.373077081e-012
	,-3.412427782e-012
	,-2.208769404e-017
	,2.352343633e-012
	,3.978954191e-012
	,5.108895279e-012
	,5.899010459e-012
	,6.456642697e-012
	,6.855233377e-012
	,7.145177405e-012
	,7.360746055e-012
	,7.525581489e-012
	,7.655827808e-012
	,7.762509820e-012
	,7.853083081e-012
	,7.932806251e-012
	,8.005232444e-012
	,8.072618765e-012
	,8.136867822e-012
	,8.198939040e-012
	,8.259636340e-012
	,8.319533215e-012
	,8.378994292e-012
	,8.438225670e-012
	,8.497414073e-012
	,8.556714063e-012
	,8.616201510e-012
	,8.675861166e-012
	,8.735841066e-012
	,8.796091394e-012
	,8.856664784e-012
	,8.917554971e-012
	,8.978838191e-012
	,9.040436589e-012
	,9.102431831e-012
	,9.164832221e-012
	,9.227571389e-012
	,9.290753353e-012
	,9.354397171e-012
	,9.418523102e-012
	,9.483124724e-012
	,9.548334041e-012
	,9.614162069e-012
	,9.680645308e-012
	,9.747850126e-012
	,9.815982619e-012
	,9.885159335e-012
	,9.955731273e-012
	,1.002796494e-011
	,1.010228586e-011
	,1.017935576e-011
	,1.025987753e-011
	,1.034491533e-011
	,1.043590852e-011
	,1.053470413e-011
	,1.064384120e-011
	,1.076679879e-011
	,1.090817717e-011
	,1.107415306e-011
	,1.127314098e-011
	,1.151650550e-011
	,1.181951939e-011
	,1.220264431e-011
	,1.269404437e-011
	,1.333167631e-011
	,1.416680738e-011
	,1.520741060e-011
	,1.653694024e-011
	,1.828534141e-011
	,2.059647495e-011
	,2.366426754e-011
	,2.775036027e-011
	,3.320993483e-011
	,4.052371556e-011
	,5.034303454e-011
	,6.355133370e-011
	,8.099078925e-011
	,1.030437502e-010
	,1.321685866e-010
	,1.706601408e-010
	,2.215605313e-010
	,2.889055792e-010
	,3.780505544e-010
	,4.961028810e-010
	,6.524978455e-010
	,8.597622527e-010
	,1.134530254e-009
	,1.498891341e-009
	,1.982181870e-009
	,2.623358884e-009
	,3.474162848e-009
	,4.603267483e-009
	,6.101899161e-009
	,8.091123058e-009
	,1.073158017e-008
	,1.423633547e-008
	,1.888783600e-008
	,2.506026523e-008
	,3.324384355e-008
	,4.400122686e-008
	,5.824556545e-008
	,7.709167356e-008
	,1.020008759e-007
	,1.348822041e-007
	,1.782192698e-007
	,2.352270126e-007
	,3.100418059e-007
	,4.079466817e-007
	,5.356301522e-007
	,7.014721616e-007
	,9.158438546e-007
	,1.191396768e-006
	,1.543309770e-006
	,1.989450326e-006
	,2.550402426e-006
	,3.249315723e-006
	,4.111544750e-006
	,5.164070477e-006
	,6.434731627e-006
	,7.951336355e-006
	,9.740746853e-006
	,1.182802317e-005
	,1.423574752e-005
	,1.698355031e-005
	,2.008788951e-005
	,2.356206593e-005
	,2.741641215e-005
	,3.165855047e-005
	,3.629388674e-005
	,4.132595639e-005
	,4.675682604e-005
	,5.258747468e-005
	,5.881809865e-005
	,6.544849334e-005
	,7.247801709e-005
	,7.990588326e-005
	,8.773129038e-005
	,9.595339057e-005
	,1.045719732e-004
	,1.132678721e-004
	,1.221801650e-004
	,1.314549637e-004
	,1.410856046e-004
	,1.510659583e-004
	,1.613904969e-004
	,1.720543085e-004
	,1.830512541e-004
	,1.943761375e-004
	,2.060236595e-004
	,2.179895306e-004
	,2.302683957e-004
	,2.428555019e-004
	,2.557462020e-004
	,2.689361258e-004
	,2.824211131e-004
	,2.961983441e-004
	,3.102656397e-004
	,3.246173013e-004
	,3.392503327e-004
	,3.540540762e-004
	,3.675708500e-004
	,3.812956560e-004
	,3.952284566e-004
	,-1.357506808e-005
	,-1.036064850e-005
	,-7.795303131e-006
	,-5.783679686e-006
	,-4.238342347e-006
	,-3.074059737e-006
	,-2.209913816e-006
	,-1.576507930e-006
	,-1.117229942e-006
	,-7.873160642e-007
	,-5.519894165e-007
	,-3.844421659e-007
	,-2.668329683e-007
	,-1.849526139e-007
	,-1.280784285e-007
	,-8.862957974e-008
	,-6.129544801e-008
	,-4.237056333e-008
	,-2.927604754e-008
	,-2.022032734e-008
	,-1.396041425e-008
	,-9.634780645e-009
	,-6.646757078e-009
	,-4.583361934e-009
	,-3.158895061e-009
	,-2.175793148e-009
	,-1.497489727e-009
	,-1.029614113e-009
	,-7.069735454e-010
	,-4.845447170e-010
	,-3.312422228e-010
	,-2.256097562e-010
	,-1.528412006e-010
	,-1.027225255e-010
	,-6.820929865e-011
	,-4.444474968e-011
	,-2.808110345e-011
	,-1.681182210e-011
	,-9.047812987e-012
	,-3.694960480e-012
	,-1.070452550e-017
	,2.555420561e-012
	,4.327973470e-012
	,5.562853534e-012
	,6.428674409e-012
	,7.041327140e-012
	,7.480308278e-012
	,7.800323504e-012
	,8.038842763e-012
	,8.221636817e-012
	,8.366210211e-012
	,8.484811653e-012
	,8.585661983e-012
	,8.674451429e-012
	,8.755085983e-012
	,8.830229986e-012
	,8.901731688e-012
	,8.970824284e-012
	,9.038375452e-012
	,9.105050326e-012
	,9.171172175e-012
	,9.237058373e-012
	,9.302882798e-012
	,9.368771502e-012
	,9.434900453e-012
	,9.501258268e-012
	,9.567891682e-012
	,9.634836827e-012
	,9.702160332e-012
	,9.769813375e-012
	,9.837872817e-012
	,9.906288062e-012
	,9.975156232e-012
	,1.004438866e-011
	,1.011404828e-011
	,1.018408729e-011
	,1.025456075e-011
	,1.032544536e-011
	,1.039675804e-011
	,1.046850035e-011
	,1.054066912e-011
	,1.061332120e-011
	,1.068639415e-011
	,1.075996336e-011
	,1.083405922e-011
	,1.090859887e-011
	,1.098371421e-011
	,1.105943745e-011
	,1.113574974e-011
	,1.121264069e-011
	,1.129036126e-011
	,1.136892653e-011
	,1.144850710e-011
	,1.152928869e-011
	,1.161157772e-011
	,1.169561600e-011
	,1.178198830e-011
	,1.187116127e-011
	,1.196413440e-011
	,1.206185561e-011
	,1.216580420e-011
	,1.227802047e-011
	,1.240116912e-011
	,1.253879508e-011
	,1.269567190e-011
	,1.287848961e-011
	,1.309585826e-011
	,1.335968439e-011
	,1.368594955e-011
	,1.409605175e-011
	,1.459981356e-011
	,1.521307085e-011
	,1.599923466e-011
	,1.701663449e-011
	,1.834387941e-011
	,2.008686918e-011
	,2.238854842e-011
	,2.544217993e-011
	,2.950889647e-011
	,3.494048307e-011
	,4.221688011e-011
	,5.131579005e-011
	,6.320814704e-011
	,7.886442590e-011
	,9.949458484e-011
	,1.267020985e-010
	,1.626101848e-010
	,2.100318341e-010
	,2.726947591e-010
	,3.555337205e-010
	,4.650978241e-010
	,6.100789242e-010
	,8.020008521e-010
	,1.056152684e-009
	,1.392820473e-009
	,1.838924511e-009
	,2.430190836e-009
	,3.214012426e-009
	,4.253312842e-009
	,5.631579669e-009
	,7.459579368e-009
	,9.884244859e-009
	,1.310043541e-008
	,1.736649113e-008
	,2.302241854e-008
	,3.043653733e-008
	,4.025347712e-008
	,5.324447462e-008
	,7.042341605e-008
	,9.311975512e-008
	,1.230712841e-007
	,1.625409962e-007
	,2.144620891e-007
	,2.826146710e-007
	,3.718385207e-007
	,4.882788640e-007
	,6.396627281e-007
	,8.355948346e-007
	,1.087853476e-006
	,1.410656838e-006
	,1.820861217e-006
	,2.338044404e-006
	,2.984427810e-006
	,3.784599384e-006
	,4.765020420e-006
	,5.953330395e-006
	,7.377506271e-006
	,9.064951015e-006
	,1.104161226e-005
	,1.333123680e-005
	,1.595482174e-005
	,1.893030704e-005
	,2.227248634e-005
	,2.599316105e-005
	,3.010133006e-005
	,3.460360995e-005
	,3.950461982e-005
	,4.480748060e-005
	,5.051392521e-005
	,5.662486209e-005
	,6.314057928e-005
	,7.006103667e-005
	,7.738593158e-005
	,8.511479591e-005
	,9.324719420e-005
	,1.015235447e-004
	,1.099726882e-004
	,1.187933480e-004
	,1.279788561e-004
	,1.375229996e-004
	,1.474198426e-004
	,1.576633741e-004
	,1.682478242e-004
	,1.791675576e-004
	,1.904170570e-004
	,2.019908982e-004
	,2.138837516e-004
	,2.260913045e-004
	,2.386091284e-004
	,2.514312429e-004
	,2.645526420e-004
	,-1.394395099e-005
	,-1.062779448e-005
	,-7.983381165e-006
	,-5.914105646e-006
	,-4.330104028e-006
	,-3.138418007e-006
	,-2.254602063e-006
	,-1.607179795e-006
	,-1.138024344e-006
	,-8.007899997e-007
	,-5.590491879e-007
	,-3.888584366e-007
	,-2.700360468e-007
	,-1.873068558e-007
	,-1.298108274e-007
	,-8.990354135e-008
	,-6.223129436e-008
	,-4.305727991e-008
	,-2.977944648e-008
	,-2.058901530e-008
	,-1.423023281e-008
	,-9.832118448e-009
	,-6.791011899e-009
	,-4.688770404e-009
	,-3.235892042e-009
	,-2.232017911e-009
	,-1.538530162e-009
	,-1.059554355e-009
	,-7.287972490e-010
	,-5.004307328e-010
	,-3.427815923e-010
	,-2.339642774e-010
	,-1.588592427e-010
	,-1.070236926e-010
	,-7.124632608e-011
	,-4.654838064e-011
	,-2.949319606e-011
	,-1.770907514e-011
	,-9.559610009e-012
	,-3.916069600e-012
	,4.175612003e-019
	,2.725270281e-012
	,4.629691819e-012
	,5.968141225e-012
	,6.916132859e-012
	,7.594710062e-012
	,8.087035913e-012
	,8.450587217e-012
	,8.724861634e-012
	,8.937191825e-012
	,9.106400798e-012
	,9.245666241e-012
	,9.364045137e-012
	,9.467914357e-012
	,9.561758347e-012
	,9.648627901e-012
	,9.730754643e-012
	,9.809636711e-012
	,9.886362766e-012
	,9.961722997e-012
	,1.003623127e-011
	,1.011020228e-011
	,1.018402599e-011
	,1.025775598e-011
	,1.033164015e-011
	,1.040568119e-011
	,1.047998059e-011
	,1.055462191e-011
	,1.062961887e-011
	,1.070501320e-011
	,1.078079905e-011
	,1.085698727e-011
	,1.093360122e-011
	,1.101066245e-011
	,1.108823347e-011
	,1.116616724e-011
	,1.124458280e-011
	,1.132352706e-011
	,1.140289328e-011
	,1.148275639e-011
	,1.156308642e-011
	,1.164393297e-011
	,1.172518801e-011
	,1.180700349e-011
	,1.188928725e-011
	,1.197208591e-011
	,1.205538950e-011
	,1.213916670e-011
	,1.222346162e-011
	,1.230830758e-011
	,1.239365686e-011
	,1.247959722e-011
	,1.256604048e-011
	,1.265313989e-011
	,1.274073739e-011
	,1.282900635e-011
	,1.291785803e-011
	,1.300746926e-011
	,1.309784426e-011
	,1.318909466e-011
	,1.328127467e-011
	,1.337463697e-011
	,1.346930456e-011
	,1.356561781e-011
	,1.366384239e-011
	,1.376454166e-011
	,1.386836310e-011
	,1.397610688e-011
	,1.408903261e-011
	,1.420863071e-011
	,1.433698596e-011
	,1.447700468e-011
	,1.463244628e-011
	,1.480840229e-011
	,1.501179847e-011
	,1.525193831e-011
	,1.553666394e-011
	,1.586197318e-011
	,1.626016472e-011
	,1.675525897e-011
	,1.737974258e-011
	,1.817698670e-011
	,1.920557174e-011
	,2.054440687e-011
	,2.230013807e-011
	,2.461621169e-011
	,2.768470941e-011
	,3.160244523e-011
	,3.657608628e-011
	,4.308296086e-011
	,5.161087044e-011
	,6.280394446e-011
	,7.751352362e-011
	,9.686529242e-011
	,1.223478960e-010
	,1.559308738e-010
	,2.002209286e-010
	,2.586683927e-010
	,3.358285981e-010
	,4.377625401e-010
	,5.724882805e-010
	,7.506320281e-010
	,9.862795192e-010
	,1.298103609e-009
	,1.710865923e-009
	,2.257406463e-009
	,2.981278048e-009
	,3.940246866e-009
	,5.210933004e-009
	,6.894936450e-009
	,9.126938971e-009
	,1.208577790e-008
	,1.600827705e-008
	,2.113064812e-008
	,2.791056748e-008
	,3.688094364e-008
	,4.874369729e-008
	,6.442157691e-008
	,8.512472339e-008
	,1.124356572e-007
	,1.484169144e-007
	,1.957447387e-007
	,2.578738229e-007
	,3.392357235e-007
	,4.454720940e-007
	,5.837001619e-007
	,7.628022911e-007
	,9.937237416e-007
	,1.289753301e-006
	,1.666751323e-006
	,2.143281335e-006
	,2.740598451e-006
	,3.482452680e-006
	,4.394681209e-006
	,5.504592357e-006
	,6.840179135e-006
	,8.429231416e-006
	,1.029845116e-005
	,1.247264989e-005
	,1.497412412e-005
	,1.782225465e-005
	,2.103333827e-005
	,2.462063019e-005
	,2.859455184e-005
	,3.296304043e-005
	,3.773186943e-005
	,4.290513830e-005
	,4.848561267e-005
	,5.447493778e-005
	,6.087410323e-005
	,6.768369938e-005
	,7.490419492e-005
	,8.253551361e-005
	,9.038777413e-005
	,9.835791586e-005
	,1.067087877e-004
	,1.154337054e-004
	,1.245263005e-004
	,1.339803250e-004
	,1.437898783e-004
	,1.539495915e-004
	,-1.425201376e-005
	,-1.085044871e-005
	,-8.137564873e-006
	,-6.022104659e-006
	,-4.405891529e-006
	,-3.191112119e-006
	,-2.290776262e-006
	,-1.631651154e-006
	,-1.153949060e-006
	,-8.088268135e-007
	,-5.639905415e-007
	,-3.924182277e-007
	,-2.726355696e-007
	,-1.892088483e-007
	,-1.312022521e-007
	,-9.092063307e-008
	,-6.297398479e-008
	,-4.359900366e-008
	,-3.017415998e-008
	,-2.087632417e-008
	,-1.443916927e-008
	,-9.983933063e-009
	,-6.901236611e-009
	,-4.768742274e-009
	,-3.293875486e-009
	,-2.274030794e-009
	,-1.568949706e-009
	,-1.081561483e-009
	,-7.447018139e-010
	,-5.119084545e-010
	,-3.510475542e-010
	,-2.398988618e-010
	,-1.631001902e-010
	,-1.100325375e-010
	,-7.335709048e-011
	,-4.800259629e-011
	,-3.046541885e-011
	,-1.832543251e-011
	,-9.911124343e-012
	,-4.068281936e-012
	,3.446110630e-018
	,2.843710479e-012
	,4.842535244e-012
	,6.258282474e-012
	,7.271604932e-012
	,8.007084349e-012
	,8.550550234e-012
	,8.961113815e-012
	,9.279516547e-012
	,9.533658839e-012
	,9.742813961e-012
	,9.920142579e-012
	,1.007470935e-011
	,1.021269476e-011
	,1.033834917e-011
	,1.045468907e-011
	,1.056376077e-011
	,1.066705101e-011
	,1.076573483e-011
	,1.086073348e-011
	,1.095282582e-011
	,1.104262816e-011
	,1.113064935e-011
	,1.121737567e-011
	,1.130322622e-011
	,1.138849838e-011
	,1.147339081e-011
	,1.155819568e-011
	,1.164297788e-011
	,1.172790713e-011
	,1.181301715e-011
	,1.189848130e-011
	,1.198429467e-011
	,1.207049533e-011
	,1.215715195e-011
	,1.224422906e-011
	,1.233179853e-011
	,1.241985642e-011
	,1.250843016e-011
	,1.259756831e-011
	,1.268714241e-011
	,1.277732264e-011
	,1.286801829e-011
	,1.295929590e-011
	,1.305111933e-011
	,1.314344345e-011
	,1.323636332e-011
	,1.332987412e-011
	,1.342399109e-011
	,1.351861253e-011
	,1.361388417e-011
	,1.370969547e-011
	,1.380608751e-011
	,1.390309597e-011
	,1.400069917e-011
	,1.409890469e-011
	,1.419770329e-011
	,1.429713610e-011
	,1.439718324e-011
	,1.449786491e-011
	,1.459915396e-011
	,1.470110945e-011
	,1.480374360e-011
	,1.490700993e-011
	,1.501107767e-011
	,1.511586423e-011
	,1.522146202e-011
	,1.532797454e-011
	,1.543541348e-011
	,1.554393507e-011
	,1.565375539e-011
	,1.576508508e-011
	,1.587809399e-011
	,1.599320236e-011
	,1.611110139e-011
	,1.623216348e-011
	,1.635755195e-011
	,1.648839448e-011
	,1.662638083e-011
	,1.677374279e-011
	,1.693351057e-011
	,1.710955701e-011
	,1.730751486e-011
	,1.752096149e-011
	,1.776533274e-011
	,1.805111617e-011
	,1.839183210e-011
	,1.880575941e-011
	,1.931712356e-011
	,1.995883893e-011
	,2.077500809e-011
	,2.182527990e-011
	,2.318769808e-011
	,2.494915616e-011
	,2.710951294e-011
	,2.990443004e-011
	,3.353325332e-011
	,3.825883434e-011
	,4.442743243e-011
	,5.249565735e-011
	,6.306639386e-011
	,7.693508232e-011
	,9.514675213e-011
	,1.190824209e-010
	,1.505777101e-010
	,1.920530106e-010
	,2.467112763e-010
	,3.187880752e-010
	,4.138886375e-010
	,5.394326448e-010
	,7.052439973e-010
	,9.243347503e-010
	,1.213942369e-009
	,1.596906848e-009
	,2.103498226e-009
	,2.773840443e-009
	,3.661129278e-009
	,4.835807740e-009
	,6.391459177e-009
	,8.452189009e-009
	,1.118269851e-008
	,1.473389764e-008
	,1.942948938e-008
	,2.563904223e-008
	,3.384823618e-008
	,4.469659108e-008
	,5.902473048e-008
	,7.793524096e-008
	,1.028704904e-007
	,1.357112441e-007
	,1.788989715e-007
	,2.355913116e-007
	,3.098455286e-007
	,4.068384736e-007
	,5.331202579e-007
	,6.968954433e-007
	,9.083192044e-007
	,1.179786971e-006
	,1.526185945e-006
	,1.965067854e-006
	,2.516695906e-006
	,3.203925194e-006
	,4.051876952e-006
	,5.087405928e-006
	,6.338378206e-006
	,7.832824585e-006
	,9.598052397e-006
	,1.165980957e-005
	,1.404159486e-005
	,1.676417446e-005
	,1.984533056e-005
	,2.329981736e-005
	,2.713953308e-005
	,3.137376954e-005
	,3.600955183e-005
	,4.105208529e-005
	,4.650512097e-005
	,5.237120350e-005
	,5.865211528e-005
	,6.534906965e-005
	,7.246294383e-005
	,-1.450728266e-005
	,-1.103308921e-005
	,-8.265729618e-006
	,-6.112797952e-006
	,-4.469541132e-006
	,-3.235171332e-006
	,-2.320780399e-006
	,-1.651543847e-006
	,-1.164593354e-006
	,-8.146522832e-007
	,-5.681225712e-007
	,-3.954170298e-007
	,-2.748202757e-007
	,-1.908016571e-007
	,-1.323631546e-007
	,-9.176607052e-008
	,-6.358906337e-008
	,-4.404601123e-008
	,-3.049867767e-008
	,-2.111167745e-008
	,-1.460969320e-008
	,-1.010737331e-008
	,-6.990516593e-009
	,-4.833261217e-009
	,-3.340461577e-009
	,-2.307638846e-009
	,-1.593171816e-009
	,-1.098999442e-009
	,-7.572382512e-010
	,-5.209049230e-010
	,-3.574878001e-010
	,-2.444931757e-010
	,-1.663610838e-010
	,-1.123295954e-010
	,-7.495651176e-011
	,-4.909608028e-011
	,-3.119080046e-011
	,-1.878172051e-011
	,-1.016931617e-011
	,-4.179262346e-012
	,7.153472862e-018
	,2.928941118e-012
	,4.994770555e-012
	,6.464852103e-012
	,7.523805767e-012
	,8.298990564e-012
	,8.878463239e-012
	,9.322743660e-012
	,9.673696563e-012
	,9.960095308e-012
	,1.020170974e-011
	,1.041219001e-011
	,1.060086373e-011
	,1.077402256e-011
	,1.093605079e-011
	,1.108980612e-011
	,1.123718682e-011
	,1.137951387e-011
	,1.151755447e-011
	,1.165176245e-011
	,1.178245292e-011
	,1.190977742e-011
	,1.203372206e-011
	,1.215446046e-011
	,1.227201919e-011
	,1.238646828e-011
	,1.249804318e-011
	,1.260693133e-011
	,1.271342808e-011
	,1.281792384e-011
	,1.292074544e-011
	,1.302227453e-011
	,1.312286326e-011
	,1.322276242e-011
	,1.332232520e-011
	,1.342169498e-011
	,1.352111015e-011
	,1.362067940e-011
	,1.372052546e-011
	,1.382072997e-011
	,1.392134872e-011
	,1.402240625e-011
	,1.412400923e-011
	,1.422619619e-011
	,1.432892407e-011
	,1.443224945e-011
	,1.453618661e-011
	,1.464074728e-011
	,1.474597104e-011
	,1.485183409e-011
	,1.495834269e-011
	,1.506551627e-011
	,1.517333999e-011
	,1.528179146e-011
	,1.539092262e-011
	,1.550075125e-011
	,1.561122474e-011
	,1.572233574e-011
	,1.583416707e-011
	,1.594658636e-011
	,1.605975610e-011
	,1.617347045e-011
	,1.628788539e-011
	,1.640294458e-011
	,1.651862979e-011
	,1.663490896e-011
	,1.675176946e-011
	,1.686920825e-011
	,1.698719521e-011
	,1.710574840e-011
	,1.722484303e-011
	,1.734441021e-011
	,1.746451293e-011
	,1.758513723e-011
	,1.770628052e-011
	,1.782796366e-011
	,1.795033419e-011
	,1.807334906e-011
	,1.819723856e-011
	,1.832216894e-011
	,1.844831533e-011
	,1.857615187e-011
	,1.870593591e-011
	,1.883841250e-011
	,1.897427714e-011
	,1.911459809e-011
	,1.926068158e-011
	,1.941437555e-011
	,1.957811883e-011
	,1.975018466e-011
	,1.993456526e-011
	,2.013726007e-011
	,2.036417429e-011
	,2.062280448e-011
	,2.092378892e-011
	,2.128118977e-011
	,2.171378072e-011
	,2.224570475e-011
	,2.291099565e-011
	,2.375539131e-011
	,2.477312512e-011
	,2.604590910e-011
	,2.766896570e-011
	,2.975112257e-011
	,3.243527784e-011
	,3.590956985e-011
	,4.042135758e-011
	,4.629656933e-011
	,5.395892643e-011
	,6.397094763e-011
	,7.708045102e-011
	,9.426807354e-011
	,1.168292390e-010
	,1.464733512e-010
	,1.854580211e-010
	,2.367660002e-010
	,3.043393013e-010
	,3.933897521e-010
	,5.108104329e-010
	,6.656793229e-010
	,8.700439395e-010
	,1.139889990e-009
	,1.496344257e-009
	,1.967393128e-009
	,2.590134105e-009
	,3.413729551e-009
	,4.503371735e-009
	,5.945557806e-009
	,7.855138364e-009
	,1.032677807e-008
	,1.358993271e-008
	,1.790190853e-008
	,2.359894211e-008
	,3.112421386e-008
	,4.106108789e-008
	,5.417621377e-008
	,7.147463142e-008
	,9.427188997e-008
	,1.242842599e-007
	,1.637421916e-007
	,2.155318106e-007
	,2.833675254e-007
	,3.719985306e-007
	,4.874496697e-007
	,6.372925367e-007
	,8.309370705e-007
	,1.079925706e-006
	,1.398202405e-006
	,1.802319321e-006
	,2.311536668e-006
	,2.947761969e-006
	,3.735326007e-006
	,4.700521862e-006
	,5.870957415e-006
	,7.274753901e-006
	,8.939677056e-006
	,1.089228141e-005
	,1.315716679e-005
	,1.575641559e-005
	,1.870925165e-005
	,2.203199086e-005
	,-1.470260714e-005
	,-1.117257686e-005
	,-8.366325688e-006
	,-6.185388739e-006
	,-4.521182470e-006
	,-3.271218216e-006
	,-2.345339307e-006
	,-1.666724796e-006
	,-1.171686544e-006
	,-8.195141759e-007
	,-5.716467362e-007
	,-3.979847940e-007
	,-2.766921859e-007
	,-1.921654593e-007
	,-1.333557291e-007
	,-9.248758837e-008
	,-6.411289195e-008
	,-4.442585520e-008
	,-3.077379919e-008
	,-2.131073626e-008
	,-1.475357568e-008
	,-1.021127744e-008
	,-7.065484452e-009
	,-4.887304915e-009
	,-3.379387576e-009
	,-2.335650416e-009
	,-1.613308602e-009
	,-1.113457891e-009
	,-7.676040349e-010
	,-5.283220760e-010
	,-3.627810510e-010
	,-2.482567399e-010
	,-1.690227777e-010
	,-1.141972641e-010
	,-7.625145793e-011
	,-4.997730268e-011
	,-3.177246857e-011
	,-1.914560673e-011
	,-1.037409363e-011
	,-4.266680225e-012
	,2.307946555e-017
	,2.995184579e-012
	,5.112296079e-012
	,6.623266646e-012
	,7.715766874e-012
	,8.519717460e-012
	,9.124681435e-012
	,9.592565379e-012
	,9.966059148e-012
	,1.027467559e-011
	,1.053870036e-011
	,1.077213050e-011
	,1.098451500e-011
	,1.118249968e-011
	,1.137054414e-011
	,1.155175641e-011
	,1.172811881e-011
	,1.190103008e-011
	,1.207130265e-011
	,1.223955648e-011
	,1.240600540e-011
	,1.257088684e-011
	,1.273413845e-011
	,1.289571573e-011
	,1.305555119e-011
	,1.321339109e-011
	,1.336915117e-011
	,1.352254772e-011
	,1.367339867e-011
	,1.382147259e-011
	,1.396663290e-011
	,1.410871150e-011
	,1.424760501e-011
	,1.438331718e-011
	,1.451584165e-011
	,1.464537615e-011
	,1.477213854e-011
	,1.489643658e-011
	,1.501858466e-011
	,1.513911806e-011
	,1.525826756e-011
	,1.537643394e-011
	,1.549403340e-011
	,1.561125821e-011
	,1.572841895e-011
	,1.584559906e-011
	,1.596301008e-011
	,1.608075527e-011
	,1.619894964e-011
	,1.631754742e-011
	,1.643669870e-011
	,1.655638896e-011
	,1.667666404e-011
	,1.679745272e-011
	,1.691880868e-011
	,1.704068879e-011
	,1.716315707e-011
	,1.728605983e-011
	,1.740948110e-011
	,1.753328601e-011
	,1.765755977e-011
	,1.778219680e-011
	,1.790715658e-011
	,1.803252907e-011
	,1.815822609e-011
	,1.828436194e-011
	,1.841084972e-011
	,1.853774009e-011
	,1.866500032e-011
	,1.879277064e-011
	,1.892102783e-011
	,1.904976687e-011
	,1.917903178e-011
	,1.930887572e-011
	,1.943930417e-011
	,1.957034935e-011
	,1.970203736e-011
	,1.983442058e-011
	,1.996744027e-011
	,2.010119767e-011
	,2.023571466e-011
	,2.037103469e-011
	,2.050719529e-011
	,2.064419690e-011
	,2.078220377e-011
	,2.092124745e-011
	,2.106140840e-011
	,2.120292406e-011
	,2.134589420e-011
	,2.149071092e-011
	,2.163762356e-011
	,2.178713344e-011
	,2.193982465e-011
	,2.209671787e-011
	,2.225887257e-011
	,2.242590501e-011
	,2.259799288e-011
	,2.277867311e-011
	,2.297039548e-011
	,2.317646566e-011
	,2.340138046e-011
	,2.365095508e-011
	,2.393317181e-011
	,2.425881085e-011
	,2.464234744e-011
	,2.510363286e-011
	,2.565343149e-011
	,2.630357046e-011
	,2.710437898e-011
	,2.810194608e-011
	,2.935664753e-011
	,3.094175788e-011
	,3.296224972e-011
	,3.555300677e-011
	,3.889287349e-011
	,4.321486980e-011
	,4.882561562e-011
	,5.612861089e-011
	,6.565477151e-011
	,7.810324584e-011
	,9.439541663e-011
	,1.157457723e-010
	,1.437557549e-010
	,1.805381579e-010
	,2.288806160e-010
	,2.924164991e-010
	,3.760335979e-010
	,4.861489471e-010
	,6.312431902e-010
	,8.225349257e-010
	,1.074865571e-009
	,1.407877927e-009
	,1.847583100e-009
	,2.428442928e-009
	,3.196146104e-009
	,4.211315468e-009
	,5.554196745e-009
	,7.282317332e-009
	,9.559181135e-009
	,1.256481683e-008
	,1.653234575e-008
	,2.176914079e-008
	,2.868022245e-008
	,3.779842599e-008
	,4.982378070e-008
	,6.567429366e-008
	,8.655111689e-008
	,1.140215715e-007
	,1.501238612e-007
	,1.974976534e-007
	,2.595444965e-007
	,3.406212221e-007
	,4.462676024e-007
	,5.834661604e-007
	,7.609267658e-007
	,9.893792470e-007
	,1.281857670e-006
	,1.653935401e-006
	,2.123866165e-006
	,2.712595650e-006
	,3.443596207e-006
	,-1.486264467e-005
	,-1.128707388e-005
	,-8.449727250e-006
	,-6.245779071e-006
	,-4.564203299e-006
	,-3.301214157e-006
	,-2.365444595e-006
	,-1.676536346e-006
	,-1.177382054e-006
	,-8.236368519e-007
	,-5.746672796e-007
	,-4.001978830e-007
	,-2.783109842e-007
	,-1.933471129e-007
	,-1.342164757e-007
	,-9.311333737e-008
	,-6.456698357e-008
	,-4.475485036e-008
	,-3.101182161e-008
	,-2.148272438e-008
	,-1.487770947e-008
	,-1.030078065e-008
	,-7.129957549e-009
	,-4.933706191e-009
	,-3.412752862e-009
	,-2.359619911e-009
	,-1.630510621e-009
	,-1.125788285e-009
	,-7.764292729e-010
	,-5.346262135e-010
	,-3.672723717e-010
	,-2.514445898e-010
	,-1.712732767e-010
	,-1.157733945e-010
	,-7.734204407e-011
	,-5.071785100e-011
	,-3.226008263e-011
	,-1.944991898e-011
	,-1.054477980e-011
	,-4.339370580e-012
	,-1.190550200e-017
	,3.049867337e-012
	,5.208896467e-012
	,6.752708938e-012
	,7.871897892e-012
	,8.698199590e-012
	,9.322689668e-012
	,9.808249636e-012
	,1.019834054e-011
	,1.052299440e-011
	,1.080298954e-011
	,1.105260540e-011
	,1.128163512e-011
	,1.149698817e-011
	,1.170325923e-011
	,1.190363155e-011
	,1.210031025e-011
	,1.229473300e-011
	,1.248778255e-011
	,1.268019481e-011
	,1.287228447e-011
	,1.306433774e-011
	,1.325633572e-011
	,1.344837786e-011
	,1.364040727e-011
	,1.383229579e-011
	,1.402398532e-011
	,1.421522475e-011
	,1.440590253e-011
	,1.459582350e-011
	,1.478469945e-011
	,1.497242273e-011
	,1.515859727e-011
	,1.534303807e-011
	,1.552548640e-011
	,1.570561951e-011
	,1.588314352e-011
	,1.605783735e-011
	,1.622938729e-011
	,1.639760420e-011
	,1.656227631e-011
	,1.672323864e-011
	,1.688045487e-011
	,1.703399053e-011
	,1.718395991e-011
	,1.733054442e-011
	,1.747410617e-011
	,1.761494954e-011
	,1.775356385e-011
	,1.789034322e-011
	,1.802567207e-011
	,1.815993905e-011
	,1.829347766e-011
	,1.842652252e-011
	,1.855933271e-011
	,1.869210766e-011
	,1.882503221e-011
	,1.895817737e-011
	,1.909161646e-011
	,1.922557657e-011
	,1.936000620e-011
	,1.949504279e-011
	,1.963063920e-011
	,1.976696883e-011
	,1.990390454e-011
	,2.004159321e-011
	,2.017999431e-011
	,2.031916613e-011
	,2.045908637e-011
	,2.059976171e-011
	,2.074126467e-011
	,2.088354452e-011
	,2.102668259e-011
	,2.117060422e-011
	,2.131527374e-011
	,2.146083956e-011
	,2.160722512e-011
	,2.175438531e-011
	,2.190241992e-011
	,2.205125919e-011
	,2.220101056e-011
	,2.235154487e-011
	,2.250293412e-011
	,2.265522014e-011
	,2.280829958e-011
	,2.296229771e-011
	,2.311720906e-011
	,2.327302239e-011
	,2.342970377e-011
	,2.358731549e-011
	,2.374595811e-011
	,2.390559196e-011
	,2.406628398e-011
	,2.422809963e-011
	,2.439114337e-011
	,2.455552843e-011
	,2.472144543e-011
	,2.488910817e-011
	,2.505874145e-011
	,2.523079533e-011
	,2.540571792e-011
	,2.558397891e-011
	,2.576480828e-011
	,2.595016944e-011
	,2.614113348e-011
	,2.633906934e-011
	,2.654608751e-011
	,2.676460309e-011
	,2.699823866e-011
	,2.725128769e-011
	,2.752936921e-011
	,2.784134927e-011
	,2.819767368e-011
	,2.859449756e-011
	,2.905708885e-011
	,2.960508373e-011
	,3.026393734e-011
	,3.106722410e-011
	,3.205826866e-011
	,3.329476247e-011
	,3.485149186e-011
	,3.682704045e-011
	,3.935011579e-011
	,4.259020135e-011
	,4.676932235e-011
	,5.216555679e-011
	,5.916377394e-011
	,6.826921792e-011
	,8.014101029e-011
	,9.563841660e-011
	,1.159078360e-010
	,1.424522409e-010
	,1.772526708e-010
	,2.229208084e-010
	,2.829022840e-010
	,3.617438895e-010
	,4.654494365e-010
	,6.019507559e-010
	,7.817310306e-010
	,1.018654227e-009
	,1.331066299e-009
	,1.743162142e-009
	,2.287058155e-009
	,3.005526179e-009
	,3.955297222e-009
	,5.169608780e-009
	,6.765368167e-009
	,8.869422951e-009
	,1.164387908e-008
	,1.530250375e-008
	,2.012697848e-008
	,2.648814349e-008
	,3.487367905e-008
	,4.592223647e-008
	,6.047370419e-008
	,7.962656699e-008
	,1.048138346e-007
	,1.378997338e-007
	,1.813001733e-007
	,2.381312902e-007
	,3.123909513e-007
	,-1.499629709e-005
	,-1.138448624e-005
	,-8.521504160e-006
	,-6.298020030e-006
	,-4.601477798e-006
	,-3.327098041e-006
	,-2.381682790e-006
	,-1.683693403e-006
	,-1.182340020e-006
	,-8.272703397e-007
	,-5.773359311e-007
	,-4.021545416e-007
	,-2.797421650e-007
	,-1.943913134e-007
	,-1.349765162e-007
	,-9.366534940e-008
	,-6.496713610e-008
	,-4.504443131e-008
	,-3.122107517e-008
	,-2.163373623e-008
	,-1.498656456e-008
	,-1.037916615e-008
	,-7.186348501e-009
	,-4.974237605e-009
	,-3.441859296e-009
	,-2.380502569e-009
	,-1.645478043e-009
	,-1.136503316e-009
	,-7.840888760e-010
	,-5.400911191e-010
	,-3.711611417e-010
	,-2.542016150e-010
	,-1.732174686e-010
	,-1.171335592e-010
	,-7.828225640e-011
	,-5.135560393e-011
	,-3.267961473e-011
	,-1.971139349e-011
	,-1.069130818e-011
	,-4.401642361e-012
	,-1.159220378e-017
	,3.096573000e-012
	,5.291232492e-012
	,6.862919105e-012
	,8.004473270e-012
	,8.849398302e-012
	,9.489885073e-012
	,9.989685489e-012
	,1.039298875e-011
	,1.073024843e-011
	,1.102256606e-011
	,1.128446676e-011
	,1.152605159e-011
	,1.175423692e-011
	,1.197386168e-011
	,1.218817291e-011
	,1.239952718e-011
	,1.260937192e-011
	,1.281877726e-011
	,1.302852781e-011
	,1.323903147e-011
	,1.345059001e-011
	,1.366336947e-011
	,1.387747977e-011
	,1.409292649e-011
	,1.430965158e-011
	,1.452757200e-011
	,1.474662959e-011
	,1.496668050e-011
	,1.518750676e-011
	,1.540907027e-011
	,1.563110852e-011
	,1.585340572e-011
	,1.607581002e-011
	,1.629803866e-011
	,1.651983223e-011
	,1.674081352e-011
	,1.696075075e-011
	,1.717915710e-011
	,1.739570063e-011
	,1.760985766e-011
	,1.782132148e-011
	,1.802969701e-011
	,1.823479450e-011
	,1.843639820e-011
	,1.863437348e-011
	,1.882858616e-011
	,1.901899691e-011
	,1.920547822e-011
	,1.938803955e-011
	,1.956661097e-011
	,1.974123917e-011
	,1.991205275e-011
	,2.007937279e-011
	,2.024334807e-011
	,2.040447363e-011
	,2.056313955e-011
	,2.071986139e-011
	,2.087508901e-011
	,2.102927079e-011
	,2.118272452e-011
	,2.133593769e-011
	,2.148908297e-011
	,2.164241655e-011
	,2.179609941e-011
	,2.195028066e-011
	,2.210507578e-011
	,2.226062740e-011
	,2.241688144e-011
	,2.257392912e-011
	,2.273183596e-011
	,2.289061299e-011
	,2.305026783e-011
	,2.321084152e-011
	,2.337242356e-011
	,2.353483877e-011
	,2.369826713e-011
	,2.386256975e-011
	,2.402787043e-011
	,2.419416907e-011
	,2.436141732e-011
	,2.452954912e-011
	,2.469874342e-011
	,2.486887657e-011
	,2.503999175e-011
	,2.521209884e-011
	,2.538511423e-011
	,2.555908993e-011
	,2.573414030e-011
	,2.591006680e-011
	,2.608705309e-011
	,2.626502538e-011
	,2.644397954e-011
	,2.662398347e-011
	,2.680496629e-011
	,2.698697825e-011
	,2.717009516e-011
	,2.735422950e-011
	,2.753946838e-011
	,2.772587518e-011
	,2.791343084e-011
	,2.810222027e-011
	,2.829238947e-011
	,2.848389770e-011
	,2.867705096e-011
	,2.887193587e-011
	,2.906879952e-011
	,2.926793187e-011
	,2.946877295e-011
	,2.967240159e-011
	,2.987916896e-011
	,3.008981878e-011
	,3.030522357e-011
	,3.052635734e-011
	,3.075482051e-011
	,3.099262242e-011
	,3.124239885e-011
	,3.150770296e-011
	,3.179346133e-011
	,3.210099773e-011
	,3.243698380e-011
	,3.281175698e-011
	,3.323660962e-011
	,3.372489032e-011
	,3.429396666e-011
	,3.496995702e-011
	,3.578502421e-011
	,3.678088729e-011
	,3.801224786e-011
	,3.955067395e-011
	,4.148982319e-011
	,4.395211695e-011
	,4.709849633e-011
	,5.113941579e-011
	,5.635044973e-011
	,6.309505944e-011
	,7.184977552e-011
	,8.324069382e-011
	,9.809119205e-011
	,1.174476568e-010
	,1.427339572e-010
	,1.758298778e-010
	,2.191948425e-010
	,2.760705418e-010
	,3.507318129e-010
	,4.487948463e-010
	,5.777127956e-010
	,7.473256889e-010
	,9.706392810e-010
	,1.264867810e-009
	,1.652821273e-009
	,2.164769463e-009
	,2.840960446e-009
	,3.699001788e-009
	,4.822883853e-009
	,6.302740586e-009
	,8.251626296e-009
	,1.081858174e-008
	,1.419903764e-008
	,1.865193028e-008
	,2.451728976e-008
	,-1.510809323e-005
	,-1.146786536e-005
	,-8.583724382e-006
	,-6.343632978e-006
	,-4.634116858e-006
	,-3.349566059e-006
	,-2.393218588e-006
	,-1.689771045e-006
	,-1.186758455e-006
	,-8.305265418e-007
	,-5.797316711e-007
	,-4.039120747e-007
	,-2.810275524e-007
	,-1.953286384e-007
	,-1.356582102e-007
	,-9.415996545e-008
	,-6.532528117e-008
	,-4.530330045e-008
	,-3.140789953e-008
	,-2.176838537e-008
	,-1.508349473e-008
	,-1.044886952e-008
	,-7.236424283e-009
	,-5.010179967e-009
	,-3.467634377e-009
	,-2.398969723e-009
	,-1.658696139e-009
	,-1.145953432e-009
	,-7.908354057e-010
	,-5.448985721e-010
	,-3.745780421e-010
	,-2.566213067e-010
	,-1.749219894e-010
	,-1.183248875e-010
	,-7.910501553e-011
	,-5.191325988e-011
	,-3.304612770e-011
	,-1.993976006e-011
	,-1.081918471e-011
	,-4.456003883e-012
	,1.686571758e-017
	,3.137232320e-012
	,5.362951466e-012
	,6.958826216e-012
	,8.119816776e-012
	,8.980760746e-012
	,9.635001257e-012
	,1.014702610e-011
	,1.056155598e-011
	,1.090941997e-011
	,1.121195608e-011
	,1.148405475e-011
	,1.173579451e-011
	,1.197437925e-011
	,1.220461846e-011
	,1.242990776e-011
	,1.265260875e-011
	,1.287432603e-011
	,1.309623798e-011
	,1.331905948e-011
	,1.354335740e-011
	,1.376943841e-011
	,1.399753909e-011
	,1.422789693e-011
	,1.446052493e-011
	,1.469544502e-011
	,1.493266634e-011
	,1.517215509e-011
	,1.541390958e-011
	,1.565769485e-011
	,1.590346770e-011
	,1.615098869e-011
	,1.640010302e-011
	,1.665054453e-011
	,1.690197653e-011
	,1.715397926e-011
	,1.740611508e-011
	,1.765808778e-011
	,1.790934538e-011
	,1.815968120e-011
	,1.840897291e-011
	,1.865716744e-011
	,1.890436240e-011
	,1.915058764e-011
	,1.939581749e-011
	,1.964002812e-011
	,1.988308921e-011
	,2.012483759e-011
	,2.036508453e-011
	,2.060354473e-011
	,2.084003204e-011
	,2.107428632e-011
	,2.130593573e-011
	,2.153488665e-011
	,2.176065337e-011
	,2.198307202e-011
	,2.220193130e-011
	,2.241698337e-011
	,2.262808423e-011
	,2.283500987e-011
	,2.303793114e-011
	,2.323681556e-011
	,2.343187477e-011
	,2.362341225e-011
	,2.381195235e-011
	,2.399776806e-011
	,2.418155078e-011
	,2.436371907e-011
	,2.454476873e-011
	,2.472513504e-011
	,2.490525869e-011
	,2.508534418e-011
	,2.526578860e-011
	,2.544657300e-011
	,2.562801105e-011
	,2.581018916e-011
	,2.599326674e-011
	,2.617718230e-011
	,2.636201556e-011
	,2.654791513e-011
	,2.673484023e-011
	,2.692281472e-011
	,2.711185991e-011
	,2.730198107e-011
	,2.749322989e-011
	,2.768554440e-011
	,2.787904495e-011
	,2.807361568e-011
	,2.826929579e-011
	,2.846615646e-011
	,2.866412391e-011
	,2.886321052e-011
	,2.906346583e-011
	,2.926482228e-011
	,2.946734551e-011
	,2.967099400e-011
	,2.987581615e-011
	,3.008177986e-011
	,3.028890303e-011
	,3.049715821e-011
	,3.070660172e-011
	,3.091720496e-011
	,3.112899059e-011
	,3.134195505e-011
	,3.155619777e-011
	,3.177162303e-011
	,3.198833715e-011
	,3.220629804e-011
	,3.242556387e-011
	,3.264625547e-011
	,3.286839461e-011
	,3.309202516e-011
	,3.331739336e-011
	,3.354452135e-011
	,3.377333056e-011
	,3.400413052e-011
	,3.423712314e-011
	,3.447269980e-011
	,3.471123535e-011
	,3.495324015e-011
	,3.519936765e-011
	,3.545040636e-011
	,3.570758529e-011
	,3.597237356e-011
	,3.624688604e-011
	,3.653305837e-011
	,3.683222423e-011
	,3.714938223e-011
	,3.748952780e-011
	,3.785901976e-011
	,3.826617889e-011
	,3.872183376e-011
	,3.924005318e-011
	,3.983925962e-011
	,4.054324082e-011
	,4.138273305e-011
	,4.239879854e-011
	,4.364281031e-011
	,4.517762026e-011
	,4.709787182e-011
	,4.952049801e-011
	,5.259875288e-011
	,5.653343469e-011
	,6.158768773e-011
	,6.810643350e-011
	,7.654209341e-011
	,8.748878031e-011
	,1.017268534e-010
	,1.202814627e-010
	,1.445000338e-010
	,1.761539058e-010
	,2.175798846e-010
	,2.718537937e-010
	,3.429303724e-010
	,4.361357109e-010
	,5.585454075e-010
	,7.194498690e-010
	,9.311398340e-010
	,1.209898177e-009
	,1.577336597e-009
	,2.062211018e-009
	,-1.520444493e-005
	,-1.154085243e-005
	,-8.638604702e-006
	,-6.384031363e-006
	,-4.663024429e-006
	,-3.368900135e-006
	,-2.401413061e-006
	,-1.695168926e-006
	,-1.190747278e-006
	,-8.334768697e-007
	,-5.819059853e-007
	,-4.055083748e-007
	,-2.821952203e-007
	,-1.961799311e-007
	,-1.362770329e-007
	,-9.460866334e-008
	,-6.564991859e-008
	,-4.553774118e-008
	,-3.157693126e-008
	,-2.189008630e-008
	,-1.517100948e-008
	,-1.051173142e-008
	,-7.281532185e-009
	,-5.042517269e-009
	,-3.490795025e-009
	,-2.415542145e-009
	,-1.670542194e-009
	,-1.154411113e-009
	,-7.968651800e-010
	,-5.491892211e-010
	,-3.776234109e-010
	,-2.587750061e-010
	,-1.764371047e-010
	,-1.193824742e-010
	,-7.983449268e-011
	,-5.240710314e-011
	,-3.337046200e-011
	,-2.014151236e-011
	,-1.093208444e-011
	,-4.503937048e-012
	,8.250016620e-018
	,3.173123503e-012
	,5.426161992e-012
	,7.043347757e-012
	,8.221403096e-012
	,9.096498799e-012
	,9.762810429e-012
	,1.028561393e-011
	,1.070995151e-011
	,1.106708882e-011
	,1.137863852e-011
	,1.165950979e-011
	,1.192012368e-011
	,1.216761392e-011
	,1.240697522e-011
	,1.264153846e-011
	,1.287386005e-011
	,1.310551515e-011
	,1.333770166e-011
	,1.357119452e-011
	,1.380661249e-011
	,1.404434584e-011
	,1.428461801e-011
	,1.452762469e-011
	,1.477356541e-011
	,1.502249107e-011
	,1.527441929e-011
	,1.552937433e-011
	,1.578727891e-011
	,1.604812187e-011
	,1.631179469e-011
	,1.657807881e-011
	,1.684670869e-011
	,1.711740769e-011
	,1.738969105e-011
	,1.766312019e-011
	,1.793731226e-011
	,1.821198885e-011
	,1.848712906e-011
	,1.876265391e-011
	,1.903893333e-011
	,1.931602352e-011
	,1.959397229e-011
	,1.987292290e-011
	,2.015272588e-011
	,2.043336845e-011
	,2.071481400e-011
	,2.099689158e-011
	,2.127945383e-011
	,2.156240322e-011
	,2.184554183e-011
	,2.212870671e-011
	,2.241171777e-011
	,2.269426498e-011
	,2.297620471e-011
	,2.325718078e-011
	,2.353697264e-011
	,2.381522678e-011
	,2.409168719e-011
	,2.436601648e-011
	,2.463798440e-011
	,2.490710908e-011
	,2.517316250e-011
	,2.543584024e-011
	,2.569481291e-011
	,2.594981850e-011
	,2.620058103e-011
	,2.644695170e-011
	,2.668885782e-011
	,2.692622142e-011
	,2.715913003e-011
	,2.738780144e-011
	,2.761261824e-011
	,2.783393721e-011
	,2.805237364e-011
	,2.826846957e-011
	,2.848280690e-011
	,2.869591632e-011
	,2.890832008e-011
	,2.912042710e-011
	,2.933254106e-011
	,2.954509704e-011
	,2.975815883e-011
	,2.997197296e-011
	,3.018663524e-011
	,3.040233699e-011
	,3.061911633e-011
	,3.083703717e-011
	,3.105611972e-011
	,3.127642246e-011
	,3.149794143e-011
	,3.172069891e-011
	,3.194479048e-011
	,3.217018223e-011
	,3.239687067e-011
	,3.262476212e-011
	,3.285402190e-011
	,3.308464740e-011
	,3.331654181e-011
	,3.354978837e-011
	,3.378429856e-011
	,3.402021086e-011
	,3.425740038e-011
	,3.449593791e-011
	,3.473580425e-011
	,3.497701218e-011
	,3.521955570e-011
	,3.546341534e-011
	,3.570866210e-011
	,3.595529479e-011
	,3.620323498e-011
	,3.645258073e-011
	,3.670328452e-011
	,3.695541596e-011
	,3.720892314e-011
	,3.746393160e-011
	,3.772037094e-011
	,3.797833218e-011
	,3.823785814e-011
	,3.849918075e-011
	,3.876211555e-011
	,3.902682377e-011
	,3.929340139e-011
	,3.956214056e-011
	,3.983310697e-011
	,4.010662493e-011
	,4.038296905e-011
	,4.066250714e-011
	,4.094592177e-011
	,4.123366367e-011
	,4.152686908e-011
	,4.182661606e-011
	,4.213326384e-011
	,4.244920582e-011
	,4.277658272e-011
	,4.311809376e-011
	,4.347749177e-011
	,4.385954715e-011
	,4.427057958e-011
	,4.471850496e-011
	,4.521393001e-011
	,4.577031600e-011
	,4.640536418e-011
	,4.714214963e-011
	,4.801062419e-011
	,4.904988440e-011
	,5.031089568e-011
	,5.185946334e-011
	,5.378304139e-011
	,5.619507523e-011
	,5.924383735e-011
	,6.312153460e-011
	,6.806005445e-011
	,7.440417844e-011
	,8.258607646e-011
	,9.317210756e-011
	,1.069053810e-010
	,1.247610629e-010
	,1.480213898e-010
	,1.783719819e-010
	,2.180302598e-010
	,-1.529114346e-005
	,-1.160702338e-005
	,-8.688447539e-006
	,-6.420698947e-006
	,-4.689111269e-006
	,-3.384797080e-006
	,-2.408269240e-006
	,-1.700098992e-006
	,-1.194408573e-006
	,-8.361870098e-007
	,-5.839035115e-007
	,-4.069746034e-007
	,-2.832673241e-007
	,-1.969611432e-007
	,-1.368445660e-007
	,-9.501989713e-008
	,-6.594723941e-008
	,-4.575229603e-008
	,-3.173150655e-008
	,-2.200129035e-008
	,-1.525091039e-008
	,-1.056907522e-008
	,-7.322643907e-009
	,-5.071962488e-009
	,-3.511863959e-009
	,-2.430602625e-009
	,-1.681296160e-009
	,-1.162080629e-009
	,-8.023266603e-010
	,-5.530709238e-010
	,-3.803751113e-010
	,-2.607185500e-010
	,-1.778025941e-010
	,-1.203343452e-010
	,-8.049021822e-011
	,-5.285044690e-011
	,-3.366110609e-011
	,-2.032221703e-011
	,-1.103306369e-011
	,-4.546822039e-012
	,5.273683560e-018
	,3.205127229e-012
	,5.482489983e-012
	,7.118575619e-012
	,8.311775011e-012
	,9.199412146e-012
	,9.876489277e-012
	,1.040874384e-011
	,1.084187069e-011
	,1.120729008e-011
	,1.152677777e-011
	,1.181558572e-011
	,1.208407352e-011
	,1.233948081e-011
	,1.258686562e-011
	,1.282978964e-011
	,1.307058079e-011
	,1.331095190e-011
	,1.355221748e-011
	,1.379501884e-011
	,1.404007371e-011
	,1.428774770e-011
	,1.453838815e-011
	,1.479218874e-011
	,1.504922768e-011
	,1.530969521e-011
	,1.557366681e-011
	,1.584106292e-011
	,1.611192108e-011
	,1.638610694e-011
	,1.666356959e-011
	,1.694397060e-011
	,1.722703737e-011
	,1.751228448e-011
	,1.779931515e-011
	,1.808788364e-011
	,1.837774360e-011
	,1.866913982e-011
	,1.896228623e-011
	,1.925754390e-011
	,1.955502081e-011
	,1.985492919e-011
	,2.015740619e-011
	,2.046230535e-011
	,2.076972776e-011
	,2.107953626e-011
	,2.139163825e-011
	,2.170599364e-011
	,2.202237137e-011
	,2.234067619e-011
	,2.266081893e-011
	,2.298260069e-011
	,2.330582425e-011
	,2.363045550e-011
	,2.395624675e-011
	,2.428308723e-011
	,2.461079027e-011
	,2.493920325e-011
	,2.526813975e-011
	,2.559731372e-011
	,2.592657266e-011
	,2.625563468e-011
	,2.658424592e-011
	,2.691209434e-011
	,2.723884594e-011
	,2.756429026e-011
	,2.788802115e-011
	,2.820974908e-011
	,2.852913358e-011
	,2.884578879e-011
	,2.915945602e-011
	,2.946966381e-011
	,2.977617687e-011
	,3.007865006e-011
	,3.037667207e-011
	,3.067005956e-011
	,3.095854847e-011
	,3.124197992e-011
	,3.152044679e-011
	,3.179390015e-011
	,3.206267326e-011
	,3.232711137e-011
	,3.258763581e-011
	,3.284491865e-011
	,3.309953330e-011
	,3.335208586e-011
	,3.360334534e-011
	,3.385376528e-011
	,3.410386326e-011
	,3.435405235e-011
	,3.460469145e-011
	,3.485593834e-011
	,3.510813323e-011
	,3.536133061e-011
	,3.561568950e-011
	,3.587131854e-011
	,3.612822240e-011
	,3.638648995e-011
	,3.664618211e-011
	,3.690730698e-011
	,3.716981068e-011
	,3.743377539e-011
	,3.769924587e-011
	,3.796620921e-011
	,3.823467132e-011
	,3.850462473e-011
	,3.877608839e-011
	,3.904909594e-011
	,3.932366726e-011
	,3.959978434e-011
	,3.987744253e-011
	,4.015668273e-011
	,4.043744367e-011
	,4.071982306e-011
	,4.100376048e-011
	,4.128924528e-011
	,4.157639098e-011
	,4.186516500e-011
	,4.215548587e-011
	,4.244741976e-011
	,4.274108990e-011
	,4.303638459e-011
	,4.333337971e-011
	,4.363207483e-011
	,4.393259873e-011
	,4.423488948e-011
	,4.453906137e-011
	,4.484496225e-011
	,4.515299972e-011
	,4.546297693e-011
	,4.577507594e-011
	,4.608945201e-011
	,4.640628465e-011
	,4.672570711e-011
	,4.704807970e-011
	,4.737354590e-011
	,4.770265674e-011
	,4.803595409e-011
	,4.837378272e-011
	,4.871694912e-011
	,4.906661009e-011
	,4.942401798e-011
	,4.979094063e-011
	,5.016949192e-011
	,5.056250568e-011
	,5.097352308e-011
	,5.140751228e-011
	,5.187017965e-011
	,5.236969006e-011
	,5.291569815e-011
	,5.352108142e-011
	,5.420347799e-011
	,5.498510696e-011
	,5.589505474e-011
	,5.697085900e-011
	,5.826182195e-011
	,5.983194144e-011
	,6.176502376e-011
	,6.417021590e-011
	,6.718906107e-011
	,7.100851744e-011
	,-1.537131072e-005
	,-1.166837068e-005
	,-8.734597827e-006
	,-6.454537984e-006
	,-4.712884267e-006
	,-3.396595463e-006
	,-2.414476080e-006
	,-1.704679634e-006
	,-1.197811131e-006
	,-8.387032355e-007
	,-5.857564000e-007
	,-4.083334975e-007
	,-2.842601432e-007
	,-1.976840315e-007
	,-1.373693481e-007
	,-9.539989061e-008
	,-6.622179029e-008
	,-4.595029062e-008
	,-3.187405970e-008
	,-2.210378010e-008
	,-1.532450261e-008
	,-1.062185704e-008
	,-7.360459693e-009
	,-5.099028272e-009
	,-3.531216357e-009
	,-2.444425649e-009
	,-1.691158813e-009
	,-1.169108550e-009
	,-8.073269407e-010
	,-5.566215730e-010
	,-3.828896640e-010
	,-2.624927719e-010
	,-1.790477606e-010
	,-1.212015016e-010
	,-8.108686737e-011
	,-5.325341603e-011
	,-3.392506245e-011
	,-2.048608291e-011
	,-1.112452369e-011
	,-4.585531966e-012
	,1.070418599e-017
	,3.233999696e-012
	,5.533243041e-012
	,7.186313722e-012
	,8.393087386e-012
	,9.291900965e-012
	,9.978524031e-012
	,1.051934385e-011
	,1.096021794e-011
	,1.133298961e-011
	,1.165967845e-011
	,1.195549129e-011
	,1.223103780e-011
	,1.249355497e-011
	,1.274825577e-011
	,1.299858600e-011
	,1.324708820e-011
	,1.349536649e-011
	,1.374472440e-011
	,1.399596409e-011
	,1.424965319e-011
	,1.450628020e-011
	,1.476613429e-011
	,1.502945381e-011
	,1.529638765e-011
	,1.556692933e-011
	,1.584131920e-011
	,1.611942275e-011
	,1.640126817e-011
	,1.668662191e-011
	,1.697532528e-011
	,1.726706378e-011
	,1.756133701e-011
	,1.785779926e-011
	,1.815606564e-011
	,1.845622872e-011
	,1.875852647e-011
	,1.906338725e-011
	,1.937110108e-011
	,1.968198100e-011
	,1.999623916e-011
	,2.031404569e-011
	,2.063542972e-011
	,2.096050570e-011
	,2.128922357e-011
	,2.162161684e-011
	,2.195759910e-011
	,2.229718393e-011
	,2.264020950e-011
	,2.298666673e-011
	,2.333643061e-011
	,2.368933333e-011
	,2.404536803e-011
	,2.440428252e-011
	,2.476592484e-011
	,2.513019089e-011
	,2.549688217e-011
	,2.586583849e-011
	,2.623695454e-011
	,2.661004420e-011
	,2.698496291e-011
	,2.736159937e-011
	,2.773973779e-011
	,2.811934923e-011
	,2.850015616e-011
	,2.888201593e-011
	,2.926473623e-011
	,2.964807038e-011
	,3.003174347e-011
	,3.041554898e-011
	,3.079910662e-011
	,3.118217275e-011
	,3.156434739e-011
	,3.194535107e-011
	,3.232481004e-011
	,3.270242864e-011
	,3.307772884e-011
	,3.345047774e-011
	,3.382027490e-011
	,3.418666338e-011
	,3.454929312e-011
	,3.490783092e-011
	,3.526179519e-011
	,3.561089870e-011
	,3.595472950e-011
	,3.629311220e-011
	,3.662583480e-011
	,3.695288305e-011
	,3.727432691e-011
	,3.759044027e-011
	,3.790160576e-011
	,3.820839260e-011
	,3.851140179e-011
	,3.881137950e-011
	,3.910912951e-011
	,3.940526223e-011
	,3.970050611e-011
	,3.999535931e-011
	,4.029029371e-011
	,4.058582181e-011
	,4.088210725e-011
	,4.117940199e-011
	,4.147802715e-011
	,4.177793729e-011
	,4.207939775e-011
	,4.238240459e-011
	,4.268701813e-011
	,4.299335606e-011
	,4.330135134e-011
	,4.361111320e-011
	,4.392266875e-011
	,4.423603302e-011
	,4.455107693e-011
	,4.486793913e-011
	,4.518664638e-011
	,4.550718873e-011
	,4.582944378e-011
	,4.615365104e-011
	,4.647962833e-011
	,4.680743915e-011
	,4.713713164e-011
	,4.746865603e-011
	,4.780202794e-011
	,4.813729301e-011
	,4.847443233e-011
	,4.881347040e-011
	,4.915443917e-011
	,4.949728240e-011
	,4.984212829e-011
	,5.018897531e-011
	,5.053774849e-011
	,5.088853373e-011
	,5.124145634e-011
	,5.159639189e-011
	,5.195343306e-011
	,5.231271677e-011
	,5.267420652e-011
	,5.303800471e-011
	,5.340420249e-011
	,5.377288719e-011
	,5.414422698e-011
	,5.451828359e-011
	,5.489546801e-011
	,5.527579246e-011
	,5.565966732e-011
	,5.604745950e-011
	,5.643963660e-011
	,5.683686218e-011
	,5.723994358e-011
	,5.764994181e-011
	,5.806802799e-011
	,5.849589843e-011
	,5.893566495e-011
	,5.939034938e-011
	,5.986309984e-011
	,6.035874691e-011
	,6.088318672e-011
	,6.144407695e-011
	,6.205158824e-011
	,6.271839828e-011
	,6.346141033e-011
	,-2.482323744e-008
	,-1.876361410e-008
	,-1.418482113e-008
	,-1.072611049e-008
	,-8.111448872e-009
	,-6.131072125e-009
	,-4.628016163e-009
	,-3.486654899e-009
	,-2.621405143e-009
	,-1.967310692e-009
	,-1.473739690e-009
	,-1.101871469e-009
	,-8.229842730e-010
	,-6.149691366e-010
	,-4.603046570e-010
	,-3.453794447e-010
	,-2.598936919e-010
	,-1.961759779e-010
	,-1.485779986e-010
	,-1.129715239e-010
	,-8.628664200e-011
	,-6.625978044e-011
	,-5.119747689e-011
	,-3.982286238e-011
	,-3.123545496e-011
	,-2.471475030e-011
	,-1.975290133e-011
	,-1.595975882e-011
	,-1.303854197e-011
	,-1.076634634e-011
	,-8.985723077e-012
	,-7.570789065e-012
	,-6.424960468e-012
	,-5.473452374e-012
	,-4.650207892e-012
	,-3.907772941e-012
	,-3.207522342e-012
	,-2.507197125e-012
	,-1.773218824e-012
	,-9.534990515e-013
	,-1.185328561e-017
	,1.157305285e-012
	,2.610983164e-012
	,4.485232988e-012
	,6.948010065e-012
	,1.022686947e-011
	,1.463149861e-011
	,2.058914121e-011
	,2.868540642e-011
	,3.972616059e-011
	,5.482047695e-011
	,7.549954362e-011
	,1.038783106e-010
	,1.428773882e-010
	,1.965375569e-010
	,2.704502106e-010
	,3.723606577e-010
	,5.130001597e-010
	,7.072444067e-010
	,9.756591637e-010
	,1.346711213e-009
	,1.858959745e-009
	,2.565586020e-009
	,3.536251906e-009
	,4.872438092e-009
	,6.713749673e-009
	,9.247080985e-009
	,1.272266718e-008
	,1.749033436e-008
	,2.401561500e-008
	,3.287332710e-008
	,4.489918811e-008
	,6.117235815e-008
	,8.310369837e-008
	,1.120370002e-007
	,1.496976838e-007
	,1.983813047e-007
	,2.614181703e-007
	,3.404399443e-007
	,4.416981727e-007
	,5.699571795e-007
	,7.310721780e-007
	,9.339166945e-007
	,1.188125656e-006
	,1.505191463e-006
	,1.898703532e-006
	,2.384583977e-006
	,2.981310345e-006
	,3.710117143e-006
	,4.595170584e-006
	,5.663715880e-006
	,6.931265208e-006
	,8.386012876e-006
	,1.007923065e-005
	,1.204650813e-005
	,1.431693946e-005
	,1.691777568e-005
	,1.972279320e-005
	,2.265253506e-005
	,2.568853090e-005
	,2.895291323e-005
	,3.254648438e-005
	,3.648832696e-005
	,4.077765694e-005
	,4.544089979e-005
	,5.049225478e-005
	,5.594955227e-005
	,6.183081302e-005
	,6.815373339e-005
	,7.475887621e-005
	,8.161948158e-005
	,8.890036061e-005
	,9.661442205e-005
	,1.046856339e-004
	,1.131481773e-004
	,1.213712496e-004
	,1.297771401e-004
	,1.385887999e-004
	,1.478153094e-004
	,1.574670122e-004
	,1.675555767e-004
	,1.774331446e-004
	,1.875810073e-004
	,1.981883484e-004
	,2.093063780e-004
	,2.199541435e-004
	,2.308383133e-004
	,2.421500188e-004
	,2.539017823e-004
	,2.661097640e-004
	,2.787942002e-004
	,2.913296219e-004
	,3.026909255e-004
	,3.147472710e-004
	,3.275389914e-004
	,3.400520242e-004
	,3.522981266e-004
	,3.649049199e-004
	,3.775742386e-004
	,3.903678334e-004
	,4.033883123e-004
	,4.144734350e-004
	,4.258807759e-004
	,4.376277297e-004
	,4.496691706e-004
	,4.619883818e-004
	,4.745608369e-004
	,4.857562695e-004
	,4.968449446e-004
	,5.082528458e-004
	,5.199454408e-004
	,5.318985396e-004
	,5.440933025e-004
	,5.565238553e-004
	,5.691873935e-004
	,5.820576468e-004
	,5.951356901e-004
	,6.084075529e-004
	,6.218656467e-004
	,6.355044287e-004
	,6.493190417e-004
	,6.633138817e-004
	,6.774434196e-004
	,6.915892754e-004
	,7.058922947e-004
	,7.203496875e-004
	,7.349589096e-004
	,7.497176347e-004
	,7.646288901e-004
	,7.796955495e-004
	,7.949083892e-004
	,8.102659282e-004
	,8.257668156e-004
	,8.414254336e-004
	,8.572502464e-004
	,8.732130051e-004
	,8.888401184e-004
	,9.038951550e-004
	,9.190738964e-004
	,9.344234423e-004
	,9.498964456e-004
	,9.654917983e-004
	,9.812085374e-004
	,9.970458387e-004
	,1.013002997e-003
	,1.029079410e-003
	,1.045274567e-003
	,1.061588033e-003
	,1.078018778e-003
	,1.094584926e-003
	,1.111281765e-003
	,1.128099697e-003
	,1.145035768e-003
	,1.162086728e-003
	,1.179255231e-003
	,1.196387684e-003
	,1.213611762e-003
	,1.230982535e-003
	,1.248453726e-003
	,1.266023638e-003
	,1.283698636e-003
	,-8.704307939e-008
	,-6.547250671e-008
	,-4.903712157e-008
	,-3.662416024e-008
	,-2.731841878e-008
	,-2.036850562e-008
	,-1.518892762e-008
	,-1.133483051e-008
	,-8.465649328e-009
	,-6.324667677e-009
	,-4.723527611e-009
	,-3.526804654e-009
	,-2.633695524e-009
	,-1.967839519e-009
	,-1.471345198e-009
	,-1.100664310e-009
	,-8.233190660e-010
	,-6.153169262e-010
	,-4.591451446e-010
	,-3.420507331e-010
	,-2.544831133e-010
	,-1.891079363e-010
	,-1.403304660e-010
	,-1.039702734e-010
	,-7.694099045e-011
	,-5.694654246e-011
	,-4.220473176e-011
	,-3.134642378e-011
	,-2.334205494e-011
	,-1.743150936e-011
	,-1.305443491e-011
	,-9.800303349e-012
	,-7.365830781e-012
	,-5.536850461e-012
	,-4.150996059e-012
	,-3.083274900e-012
	,-2.246833723e-012
	,-1.570649962e-012
	,-1.000532894e-012
	,-4.906493406e-013
	,-4.490777517e-018
	,5.111450486e-013
	,1.084461100e-012
	,1.768396068e-012
	,2.622715138e-012
	,3.722846057e-012
	,5.166812527e-012
	,7.094015180e-012
	,9.690876166e-012
	,1.321345480e-011
	,1.801442200e-011
	,2.458016031e-011
	,3.358295135e-011
	,4.595373728e-011
	,6.298263702e-011
	,8.635842123e-011
	,1.180824416e-010
	,1.614083185e-010
	,2.209233949e-010
	,3.027586492e-010
	,4.140235310e-010
	,5.657739206e-010
	,7.738094280e-010
	,1.059028895e-009
	,1.450268623e-009
	,1.987769732e-009
	,2.725742058e-009
	,3.740633054e-009
	,5.136997082e-009
	,7.058850915e-009
	,9.703875796e-009
	,1.334434405e-008
	,1.835340180e-008
	,2.523827309e-008
	,3.468870738e-008
	,4.764450078e-008
	,6.534789044e-008
	,8.945445647e-008
	,1.221850792e-007
	,1.663526284e-007
	,2.255287378e-007
	,3.045095318e-007
	,4.092269997e-007
	,5.466864520e-007
	,7.255408352e-007
	,9.572923196e-007
	,1.254905038e-006
	,1.626801740e-006
	,2.092621335e-006
	,2.670393237e-006
	,3.379898057e-006
	,4.246684838e-006
	,5.296095082e-006
	,6.549869753e-006
	,7.936105870e-006
	,9.521709054e-006
	,1.124036652e-005
	,1.319549636e-005
	,1.539301342e-005
	,1.786008803e-005
	,2.061841276e-005
	,2.368483396e-005
	,2.707603073e-005
	,3.080872686e-005
	,3.489951108e-005
	,3.934641830e-005
	,4.417532085e-005
	,4.936242584e-005
	,5.479018980e-005
	,6.059799853e-005
	,6.679657722e-005
	,7.339908224e-005
	,8.035419408e-005
	,8.731980886e-005
	,9.444384872e-005
	,1.019332418e-004
	,1.097952034e-004
	,1.180360693e-004
	,1.261442139e-004
	,1.344810765e-004
	,1.432501434e-004
	,1.524653030e-004
	,1.620842056e-004
	,1.721535252e-004
	,1.821985283e-004
	,1.920285518e-004
	,2.021478933e-004
	,2.127061284e-004
	,2.236940580e-004
	,2.349712822e-004
	,2.452897426e-004
	,2.559973825e-004
	,2.672347056e-004
	,2.790351733e-004
	,2.914442195e-004
	,3.035816434e-004
	,3.156878350e-004
	,3.283294554e-004
	,3.415307326e-004
	,3.549273947e-004
	,3.663395777e-004
	,3.776750518e-004
	,3.892407659e-004
	,4.003688446e-004
	,4.106709295e-004
	,4.213324868e-004
	,4.323158207e-004
	,4.435851970e-004
	,4.551136201e-004
	,4.668799695e-004
	,4.788814272e-004
	,4.911002190e-004
	,5.035255826e-004
	,5.161486179e-004
	,5.289604539e-004
	,5.419735183e-004
	,5.551708036e-004
	,5.685459513e-004
	,5.821010037e-004
	,5.958252661e-004
	,6.097151981e-004
	,6.237676021e-004
	,6.379795739e-004
	,6.522413799e-004
	,6.664864663e-004
	,6.808972951e-004
	,6.954536027e-004
	,7.101535156e-004
	,7.249952827e-004
	,7.395910757e-004
	,7.536673872e-004
	,7.678757259e-004
	,7.822091382e-004
	,7.966656123e-004
	,8.112434131e-004
	,8.259720111e-004
	,8.408342784e-004
	,8.558136106e-004
	,8.709087766e-004
	,8.861187381e-004
	,9.014434383e-004
	,9.169288665e-004
	,9.325305929e-004
	,9.482481076e-004
	,9.640809706e-004
	,9.800288169e-004
	,9.960913467e-004
	,1.012268318e-003
	,1.028559539e-003
	,1.044964863e-003
	,1.061484176e-003
	,1.078138236e-003
	,1.094917643e-003
	,1.111811147e-003
	,1.128819110e-003
	,1.145942066e-003
	,1.163179993e-003
	,1.180401119e-003
	,1.197693710e-003
	,1.215131310e-003
	,1.232676765e-003
	,-3.065752215e-007
	,-2.327948847e-007
	,-1.766990830e-007
	,-1.340071395e-007
	,-1.014160824e-007
	,-7.653838341e-008
	,-5.762261174e-008
	,-4.327230325e-008
	,-3.238680481e-008
	,-2.414675484e-008
	,-1.794428970e-008
	,-1.330537078e-008
	,-9.850941376e-009
	,-7.280964445e-009
	,-5.374862103e-009
	,-3.964373483e-009
	,-2.922575506e-009
	,-2.154972511e-009
	,-1.589619078e-009
	,-1.172936413e-009
	,-8.655378547e-010
	,-6.386372907e-010
	,-4.711981275e-010
	,-3.477134564e-010
	,-2.566680223e-010
	,-1.895180883e-010
	,-1.399485875e-010
	,-1.033080149e-010
	,-7.618388238e-011
	,-5.608031472e-011
	,-4.116803229e-011
	,-3.010478044e-011
	,-2.189713526e-011
	,-1.580370770e-011
	,-1.127076816e-011
	,-7.889389227e-012
	,-5.356418885e-012
	,-3.447681247e-012
	,-1.997470639e-012
	,-8.801778698e-013
	,-1.002571268e-017
	,7.177792166e-013
	,1.332281086e-012
	,1.892167139e-012
	,2.438655673e-012
	,3.009240704e-012
	,3.645008630e-012
	,4.387226047e-012
	,5.293888686e-012
	,6.434800746e-012
	,7.902906009e-012
	,9.824036837e-012
	,1.237096482e-011
	,1.577708309e-011
	,2.036182737e-011
	,2.656350260e-011
	,3.498529798e-011
	,4.645827246e-011
	,6.212921639e-011
	,8.358189401e-011
	,1.130058975e-010
	,1.534312517e-010
	,2.090312847e-010
	,2.854333442e-010
	,3.907728045e-010
	,5.361788352e-010
	,7.360750818e-010
	,1.011246487e-009
	,1.390340113e-009
	,1.913910824e-009
	,2.637531629e-009
	,3.638277297e-009
	,5.014759227e-009
	,6.911693800e-009
	,9.531006088e-009
	,1.314816298e-008
	,1.814304442e-008
	,2.503889156e-008
	,3.455444411e-008
	,4.767483302e-008
	,6.574027318e-008
	,9.030054258e-008
	,1.234889820e-007
	,1.686016097e-007
	,2.296818401e-007
	,3.116158753e-007
	,4.194487354e-007
	,5.620943757e-007
	,7.491173937e-007
	,9.915257395e-007
	,1.302350347e-006
	,1.697159750e-006
	,2.192445121e-006
	,2.804929701e-006
	,3.555653959e-006
	,4.465200102e-006
	,5.554752160e-006
	,6.844486643e-006
	,8.348648280e-006
	,1.009396235e-005
	,1.210049774e-005
	,1.438757874e-005
	,1.697372151e-005
	,1.987663982e-005
	,2.308268212e-005
	,2.656458829e-005
	,3.038148935e-005
	,3.454436316e-005
	,3.906374379e-005
	,4.394475607e-005
	,4.903072193e-005
	,5.431526676e-005
	,5.993260244e-005
	,6.588773113e-005
	,7.187343276e-005
	,7.798693490e-005
	,8.443884315e-005
	,9.120480355e-005
	,9.810153427e-005
	,1.053888660e-004
	,1.130788433e-004
	,1.211639889e-004
	,1.296581148e-004
	,1.382445625e-004
	,1.470991582e-004
	,1.563317699e-004
	,1.659516702e-004
	,1.759691649e-004
	,1.855786118e-004
	,1.954015212e-004
	,2.056268784e-004
	,2.162773491e-004
	,2.271739202e-004
	,2.384793357e-004
	,2.502841633e-004
	,2.620991052e-004
	,2.738647637e-004
	,2.860663391e-004
	,2.987261212e-004
	,3.100495325e-004
	,3.203172625e-004
	,3.308398850e-004
	,3.414707292e-004
	,3.522175554e-004
	,3.631245324e-004
	,3.742397559e-004
	,3.855947766e-004
	,3.971763410e-004
	,4.089738306e-004
	,4.209767465e-004
	,4.331756491e-004
	,4.455651650e-004
	,4.581453552e-004
	,4.709073847e-004
	,4.838463093e-004
	,4.969577632e-004
	,5.102358192e-004
	,5.236950916e-004
	,5.373185279e-004
	,5.511055522e-004
	,5.650581246e-004
	,5.791680726e-004
	,5.928995825e-004
	,6.063531043e-004
	,6.197091865e-004
	,6.330911812e-004
	,6.466136167e-004
	,6.602799630e-004
	,6.740696916e-004
	,6.879806828e-004
	,7.020111711e-004
	,7.161594799e-004
	,7.304277188e-004
	,7.448200205e-004
	,7.593281018e-004
	,7.739509495e-004
	,7.886894440e-004
	,8.035648364e-004
	,8.185674913e-004
	,8.336818045e-004
	,8.489070737e-004
	,8.642426574e-004
	,8.796879699e-004
	,8.952770014e-004
	,9.109884089e-004
	,9.268121305e-004
	,9.427479400e-004
	,9.587956622e-004
	,9.749551668e-004
	,9.912263646e-004
	,1.007609203e-003
	,1.024103659e-003
	,1.040709736e-003
	,1.057445491e-003
	,1.074306831e-003
	,1.091279186e-003
	,1.108363628e-003
	,1.125560148e-003
	,1.142869837e-003
	,1.160222676e-003
	,1.177598390e-003
	,-1.208939414e-006
	,-9.192333962e-007
	,-6.972026212e-007
	,-5.269429384e-007
	,-3.970727949e-007
	,-2.987022058e-007
	,-2.244877933e-007
	,-1.685742358e-007
	,-1.265394173e-007
	,-9.499099403e-008
	,-7.130173321e-008
	,-5.349134186e-008
	,-4.009468329e-008
	,-3.001473803e-008
	,-2.241541132e-008
	,-1.666980980e-008
	,-1.233229004e-008
	,-9.082316687e-009
	,-6.665747072e-009
	,-4.878496622e-009
	,-3.560096946e-009
	,-2.589491473e-009
	,-1.882008175e-009
	,-1.368982201e-009
	,-9.967912560e-010
	,-7.262667953e-010
	,-5.292581867e-010
	,-3.855444555e-010
	,-2.805578661e-010
	,-2.037751928e-010
	,-1.475878342e-010
	,-1.064798207e-010
	,-7.641284912e-011
	,-5.441362292e-011
	,-3.829694274e-011
	,-2.646154273e-011
	,-1.773739280e-011
	,-1.127105253e-011
	,-6.440723232e-012
	,-2.793748551e-012
	,-9.922807656e-019
	,2.181224272e-012
	,3.925925335e-012
	,5.363810530e-012
	,6.591842835e-012
	,7.683241350e-012
	,8.694634883e-012
	,9.670196186e-012
	,1.064511048e-011
	,1.165136853e-011
	,1.272076954e-011
	,1.388771094e-011
	,1.518787598e-011
	,1.667826275e-011
	,1.842363908e-011
	,2.052324488e-011
	,2.310064295e-011
	,2.632467986e-011
	,3.044404518e-011
	,3.576828557e-011
	,4.275081081e-011
	,5.199755323e-011
	,6.433294759e-011
	,8.089816169e-011
	,1.032699505e-010
	,1.335964478e-010
	,1.748245802e-010
	,2.310041464e-010
	,3.077036456e-010
	,4.114879125e-010
	,5.531787622e-010
	,7.470700989e-010
	,1.012696349e-009
	,1.376958136e-009
	,1.876912668e-009
	,2.563619757e-009
	,3.507439646e-009
	,4.805338963e-009
	,6.574081538e-009
	,8.950939561e-009
	,1.218850549e-008
	,1.659963029e-008
	,2.260808051e-008
	,3.078771649e-008
	,4.191471460e-008
	,5.703609257e-008
	,7.755947558e-008
	,1.053693289e-007
	,1.429756421e-007
	,1.936875820e-007
	,2.618221256e-007
	,3.530593359e-007
	,4.746613997e-007
	,6.357039600e-007
	,8.470533996e-007
	,1.122828809e-006
	,1.479278472e-006
	,1.935455293e-006
	,2.512510637e-006
	,3.232006356e-006
	,4.117821826e-006
	,5.194554801e-006
	,6.486850891e-006
	,8.011763038e-006
	,9.782356049e-006
	,1.181895041e-005
	,1.413609729e-005
	,1.668093630e-005
	,1.947329387e-005
	,2.254993250e-005
	,2.591013616e-005
	,2.957022981e-005
	,3.353588452e-005
	,3.781259270e-005
	,4.240424262e-005
	,4.730573879e-005
	,5.253412798e-005
	,5.809693885e-005
	,6.400256052e-005
	,7.025825090e-005
	,7.686486087e-005
	,8.377287242e-005
	,9.093564902e-005
	,9.844104141e-005
	,1.062952758e-004
	,1.143763731e-004
	,1.225215742e-004
	,1.309864536e-004
	,1.397790760e-004
	,1.489099397e-004
	,1.583923815e-004
	,1.682429823e-004
	,1.784752668e-004
	,1.891108945e-004
	,1.996965036e-004
	,2.104466136e-004
	,2.209090325e-004
	,2.312864872e-004
	,2.413142369e-004
	,2.516431454e-004
	,2.622460081e-004
	,2.731071216e-004
	,2.842172472e-004
	,2.955546633e-004
	,3.070656095e-004
	,3.186769656e-004
	,3.303665820e-004
	,3.421453256e-004
	,3.541000234e-004
	,3.662461962e-004
	,3.785797877e-004
	,3.910886178e-004
	,4.037671863e-004
	,4.166180774e-004
	,4.296452012e-004
	,4.423006563e-004
	,4.548978166e-004
	,4.676415902e-004
	,4.805273983e-004
	,4.935720124e-004
	,5.067615804e-004
	,5.200851143e-004
	,5.335469240e-004
	,5.471401768e-004
	,5.608611668e-004
	,5.745316531e-004
	,5.879822695e-004
	,6.015628961e-004
	,6.152673238e-004
	,6.291132445e-004
	,6.430776619e-004
	,6.571566758e-004
	,6.713497546e-004
	,6.856557694e-004
	,7.000736535e-004
	,7.146091809e-004
	,7.292601188e-004
	,7.440222981e-004
	,7.588950785e-004
	,7.738874841e-004
	,7.890144820e-004
	,8.038726546e-004
	,8.186526977e-004
	,8.335313957e-004
	,8.485081149e-004
	,8.635844443e-004
	,8.787930110e-004
	,8.941013057e-004
	,9.095090123e-004
	,9.250158521e-004
	,9.406215896e-004
	,9.563260272e-004
	,9.721290022e-004
	,9.880303830e-004
	,1.004030066e-003
	,1.020133413e-003
	,1.036352263e-003
	,1.052675102e-003
	,1.069096154e-003
	,1.085615066e-003
	,1.102232663e-003
	,-4.915574679e-006
	,-3.864321751e-006
	,-3.008112191e-006
	,-2.318935059e-006
	,-1.770699478e-006
	,-1.337115768e-006
	,-9.995631893e-007
	,-7.458176777e-007
	,-5.576312778e-007
	,-4.177354339e-007
	,-3.130754815e-007
	,-2.343449294e-007
	,-1.749480944e-007
	,-1.301317781e-007
	,-9.643704221e-008
	,-7.126377722e-008
	,-5.256528176e-008
	,-3.872003784e-008
	,-2.847589981e-008
	,-2.090456624e-008
	,-1.532042497e-008
	,-1.120558195e-008
	,-8.173812719e-009
	,-5.942099503e-009
	,-4.303410224e-009
	,-3.104966066e-009
	,-2.232286038e-009
	,-1.599193878e-009
	,-1.141964613e-009
	,-8.133591250e-010
	,-5.779750259e-010
	,-4.093809197e-010
	,-2.885127519e-010
	,-2.017691199e-010
	,-1.394480300e-010
	,-9.459922668e-011
	,-6.224143104e-011
	,-3.881006078e-011
	,-2.175480038e-011
	,-9.252249838e-012
	,-1.242766568e-017
	,6.932352517e-012
	,1.221079717e-011
	,1.631324861e-011
	,1.958246997e-011
	,2.226505723e-011
	,2.453883476e-011
	,2.653211728e-011
	,2.833729816e-011
	,3.002087479e-011
	,3.163095302e-011
	,3.320210389e-011
	,3.476164822e-011
	,3.633137442e-011
	,3.792925349e-011
	,3.957666277e-011
	,4.129526192e-011
	,4.311019107e-011
	,4.505292125e-011
	,4.716451400e-011
	,4.950055125e-011
	,5.213724168e-011
	,5.517889972e-011
	,5.876950307e-011
	,6.311415664e-011
	,6.847590541e-011
	,7.522721646e-011
	,8.386075762e-011
	,9.507589446e-011
	,1.098377604e-010
	,1.293716611e-010
	,1.554012056e-010
	,1.903920863e-010
	,2.376496509e-010
	,3.016934422e-010
	,3.870295911e-010
	,5.014824476e-010
	,6.566931420e-010
	,8.674801668e-010
	,1.154074622e-009
	,1.544093569e-009
	,2.075199918e-009
	,2.799025515e-009
	,3.786042800e-009
	,5.132535119e-009
	,6.864121265e-009
	,9.179747843e-009
	,1.228421915e-008
	,1.644522391e-008
	,2.202034365e-008
	,2.948659379e-008
	,3.947925320e-008
	,5.284263300e-008
	,7.069601987e-008
	,9.451863045e-008
	,1.262579473e-007
	,1.684661300e-007
	,2.244453589e-007
	,2.983916803e-007
	,3.958848841e-007
	,5.239097750e-007
	,6.912319590e-007
	,9.087039158e-007
	,1.189537882e-006
	,1.549517852e-006
	,2.007108672e-006
	,2.583345999e-006
	,3.301619796e-006
	,4.187038899e-006
	,5.265930050e-006
	,6.564439004e-006
	,8.108672116e-006
	,9.922133439e-006
	,1.202666847e-005
	,1.444188494e-005
	,1.718350462e-005
	,2.025804117e-005
	,2.367619531e-005
	,2.744765122e-005
	,3.156827659e-005
	,3.602641693e-005
	,4.083521261e-005
	,4.599498857e-005
	,5.150448705e-005
	,5.730712442e-005
	,6.341447768e-005
	,6.984921362e-005
	,7.661070880e-005
	,8.369979174e-005
	,9.111911665e-005
	,9.887351757e-005
	,1.069704732e-004
	,1.154203485e-004
	,1.242365708e-004
	,1.334353981e-004
	,1.427718860e-004
	,1.521472661e-004
	,1.618159822e-004
	,1.717711351e-004
	,1.820074863e-004
	,1.923680091e-004
	,2.027680856e-004
	,2.134226647e-004
	,2.243273979e-004
	,2.354786491e-004
	,2.468735432e-004
	,2.585101036e-004
	,2.700919596e-004
	,2.815706889e-004
	,2.930653206e-004
	,3.046718827e-004
	,3.164238864e-004
	,3.283313547e-004
	,3.403878280e-004
	,3.525887582e-004
	,3.649294833e-004
	,3.774168350e-004
	,3.900438687e-004
	,4.028025820e-004
	,4.156895909e-004
	,4.287021880e-004
	,4.418374770e-004
	,4.551132723e-004
	,4.685166289e-004
	,4.820375522e-004
	,4.956771796e-004
	,5.094335608e-004
	,5.233023091e-004
	,5.367675797e-004
	,5.501538853e-004
	,5.636610919e-004
	,5.772816979e-004
	,5.910207984e-004
	,6.048734824e-004
	,6.188312820e-004
	,6.328931246e-004
	,6.470579897e-004
	,6.613249061e-004
	,6.756934061e-004
	,6.901694115e-004
	,7.047461585e-004
	,7.194240365e-004
	,7.342114745e-004
	,7.491139092e-004
	,7.641198063e-004
	,7.792240052e-004
	,7.944259489e-004
	,8.097251132e-004
	,8.251210046e-004
	,8.406292663e-004
	,8.562509265e-004
	,8.719712135e-004
	,8.877898979e-004
	,9.037067845e-004
	,9.197217098e-004
	,9.358345405e-004
	,9.520451704e-004
	,9.683535183e-004
	,9.847663209e-004
	,1.001284577e-003
	,1.017907698e-003
	,-1.664713326e-005
	,-1.355864662e-005
	,-1.091211801e-005
	,-8.672933831e-006
	,-6.829733404e-006
	,-5.344713261e-006
	,-4.153696269e-006
	,-3.201406964e-006
	,-2.446654586e-006
	,-1.852385925e-006
	,-1.389849653e-006
	,-1.032684584e-006
	,-7.614526170e-007
	,-5.592468427e-007
	,-4.095054000e-007
	,-2.988337188e-007
	,-2.172314287e-007
	,-1.572745453e-007
	,-1.134227237e-007
	,-8.149886746e-008
	,-5.837014243e-008
	,-4.169042955e-008
	,-2.969696146e-008
	,-2.110621273e-008
	,-1.498042744e-008
	,-1.061822988e-008
	,-7.509482172e-009
	,-5.292357605e-009
	,-3.714856382e-009
	,-2.598101492e-009
	,-1.810494658e-009
	,-1.256146114e-009
	,-8.663103964e-010
	,-5.922781395e-010
	,-3.997886628e-010
	,-2.646260032e-010
	,-1.697160928e-010
	,-1.030768734e-010
	,-5.625355751e-011
	,-2.328887288e-011
	,2.662865095e-018
	,1.654577520e-011
	,2.840110990e-011
	,3.699885089e-011
	,4.333687852e-011
	,4.810820990e-011
	,5.179268455e-011
	,5.472117567e-011
	,5.712159711e-011
	,5.915121982e-011
	,6.091863631e-011
	,6.249809679e-011
	,6.394026341e-011
	,6.528037424e-011
	,6.654417622e-011
	,6.775083261e-011
	,6.891482905e-011
	,7.004820149e-011
	,7.116165682e-011
	,7.226517455e-011
	,7.336694668e-011
	,7.447879537e-011
	,7.561246685e-011
	,7.678167183e-011
	,7.800358020e-011
	,7.930041441e-011
	,8.070171906e-011
	,8.224716710e-011
	,8.399040214e-011
	,8.600427363e-011
	,8.838808211e-011
	,9.127708758e-011
	,9.485531032e-011
	,9.937227008e-011
	,1.051721897e-010
	,1.127216514e-010
	,1.226561997e-010
	,1.358364824e-010
	,1.534357190e-010
	,1.770642562e-010
	,2.089048072e-010
	,2.511526453e-010
	,3.068169844e-010
	,3.818467946e-010
	,4.831250993e-010
	,6.201472703e-010
	,8.057869273e-010
	,1.057488211e-009
	,1.399180530e-009
	,1.863387079e-009
	,2.494427482e-009
	,3.315635295e-009
	,4.382355278e-009
	,5.803360153e-009
	,7.696385994e-009
	,1.021814881e-008
	,1.357712309e-008
	,1.805042083e-008
	,2.400602874e-008
	,3.193201131e-008
	,4.247470807e-008
	,5.648844921e-008
	,7.509986798e-008
	,9.979046832e-008
	,1.325016479e-007
	,1.757461706e-007
	,2.326786799e-007
	,3.076122825e-007
	,4.059371020e-007
	,5.344840866e-007
	,7.018162345e-007
	,9.185309593e-007
	,1.197549404e-006
	,1.554355994e-006
	,2.007143307e-006
	,2.576811638e-006
	,3.286780550e-006
	,4.162548151e-006
	,5.231086989e-006
	,6.519979529e-006
	,8.056454863e-006
	,9.866509049e-006
	,1.197406800e-005
	,1.439991043e-005
	,1.716226706e-005
	,2.027511374e-005
	,2.374507671e-005
	,2.758004443e-005
	,3.178655657e-005
	,3.636699512e-005
	,4.132177703e-005
	,4.664989098e-005
	,5.234322023e-005
	,5.839688250e-005
	,6.481114109e-005
	,7.158154042e-005
	,7.870338768e-005
	,8.617185440e-005
	,9.398203203e-005
	,1.021289712e-004
	,1.106077462e-004
	,1.194133962e-004
	,1.285408809e-004
	,1.379851477e-004
	,1.477411409e-004
	,1.577850291e-004
	,1.681172480e-004
	,1.783322616e-004
	,1.887905217e-004
	,1.995086086e-004
	,2.104777551e-004
	,2.216893451e-004
	,2.331295583e-004
	,2.447918397e-004
	,2.566641287e-004
	,2.687407168e-004
	,2.810242008e-004
	,2.934988298e-004
	,3.060570018e-004
	,3.187887551e-004
	,3.316915228e-004
	,3.447574798e-004
	,3.579799797e-004
	,3.713530689e-004
	,3.848723077e-004
	,3.985346125e-004
	,4.123458973e-004
	,4.262936306e-004
	,4.403723410e-004
	,4.545807831e-004
	,4.689157006e-004
	,4.832728017e-004
	,4.968701720e-004
	,5.105839872e-004
	,5.244208642e-004
	,5.383714138e-004
	,5.524422798e-004
	,5.666292298e-004
	,5.809259114e-004
	,5.953309539e-004
	,6.098430544e-004
	,6.244609735e-004
	,6.391835314e-004
	,6.540147950e-004
	,6.689511918e-004
	,6.839943840e-004
	,6.991421616e-004
	,7.144053968e-004
	,7.297712619e-004
	,7.452372768e-004
	,7.608024439e-004
	,7.764665135e-004
	,7.922288391e-004
	,8.080990242e-004
	,8.240838238e-004
	,8.401681071e-004
	,8.563515205e-004
	,8.726337483e-004
	,8.890145117e-004
	,9.054935665e-004
	,9.220707026e-004
	,-3.167766183e-005
	,-2.651002439e-005
	,-2.193990101e-005
	,-1.793330359e-005
	,-1.447223048e-005
	,-1.153500406e-005
	,-9.080418519e-006
	,-7.060171217e-006
	,-5.423410691e-006
	,-4.117675981e-006
	,-3.091067434e-006
	,-2.294955211e-006
	,-1.685973744e-006
	,-1.227062116e-006
	,-8.860775694e-007
	,-6.354525125e-007
	,-4.527910222e-007
	,-3.207939763e-007
	,-2.263320667e-007
	,-1.591663853e-007
	,-1.116123083e-007
	,-7.808600280e-008
	,-5.453287151e-008
	,-3.802238723e-008
	,-2.646588537e-008
	,-1.838816618e-008
	,-1.275149471e-008
	,-8.826830808e-009
	,-6.098979268e-009
	,-4.204842248e-009
	,-2.890551266e-009
	,-1.979180205e-009
	,-1.347544518e-009
	,-9.099768293e-010
	,-6.069974932e-010
	,-3.972792102e-010
	,-2.521069761e-010
	,-1.515790256e-010
	,-8.191642664e-011
	,-3.358746932e-011
	,1.556030835e-017
	,2.340506041e-011
	,3.977975427e-011
	,5.130225207e-011
	,5.947765881e-011
	,6.534638889e-011
	,6.962641875e-011
	,7.281243453e-011
	,7.524469709e-011
	,7.715665345e-011
	,7.870782305e-011
	,8.000676043e-011
	,8.112716060e-011
	,8.211964392e-011
	,8.301938591e-011
	,8.385142618e-011
	,8.463538140e-011
	,8.538678916e-011
	,8.611690371e-011
	,8.683359897e-011
	,8.754238282e-011
	,8.824721728e-011
	,8.895108491e-011
	,8.965629549e-011
	,9.036486922e-011
	,9.107882782e-011
	,9.179896868e-011
	,9.252861266e-011
	,9.327105079e-011
	,9.403091275e-011
	,9.481473162e-011
	,9.563157736e-011
	,9.649403602e-011
	,9.741899903e-011
	,9.842912653e-011
	,9.955469450e-011
	,1.008363624e-010
	,1.023289460e-010
	,1.041068742e-010
	,1.062707297e-010
	,1.089574843e-010
	,1.123530376e-010
	,1.167107079e-010
	,1.223760408e-010
	,1.298207523e-010
	,1.396884305e-010
	,1.528557183e-010
	,1.703585836e-010
	,1.929283617e-010
	,2.231618003e-010
	,2.637872710e-010
	,3.185152216e-010
	,3.923864468e-010
	,4.922725729e-010
	,6.275132003e-010
	,8.108358290e-010
	,1.059572235e-009
	,1.392076863e-009
	,1.814148464e-009
	,2.375576947e-009
	,3.122541875e-009
	,4.116519280e-009
	,5.439328851e-009
	,7.199831523e-009
	,9.542804147e-009
	,1.266068143e-008
	,1.680906277e-008
	,2.232714223e-008
	,2.966454635e-008
	,3.941646299e-008
	,5.236942083e-008
	,6.955197181e-008
	,9.232874388e-008
	,1.224751025e-007
	,1.621922934e-007
	,2.145828310e-007
	,2.835288706e-007
	,3.740058427e-007
	,4.923358073e-007
	,6.464704761e-007
	,8.462919417e-007
	,1.103910164e-006
	,1.433925882e-006
	,1.853617458e-006
	,2.383002421e-006
	,3.044724707e-006
	,3.863729267e-006
	,4.866707888e-006
	,6.081339818e-006
	,7.535380026e-006
	,9.255696321e-006
	,1.126736865e-005
	,1.359291627e-005
	,1.625174632e-005
	,1.925995984e-005
	,2.263024147e-005
	,2.637203339e-005
	,3.049193707e-005
	,3.499405675e-005
	,3.988044670e-005
	,4.515153320e-005
	,5.080650846e-005
	,5.684366268e-005
	,6.326065227e-005
	,7.005471845e-005
	,7.722285027e-005
	,8.476190095e-005
	,9.266865983e-005
	,1.009398750e-004
	,1.095723531e-004
	,1.185628751e-004
	,1.279081562e-004
	,1.376048676e-004
	,1.476496803e-004
	,1.577497601e-004
	,1.679920098e-004
	,1.785456895e-004
	,1.894031118e-004
	,2.005579782e-004
	,2.120030113e-004
	,2.237316863e-004
	,2.357372930e-004
	,2.480136353e-004
	,2.605558016e-004
	,2.733598460e-004
	,2.863190242e-004
	,2.994794579e-004
	,3.128608137e-004
	,3.264565723e-004
	,3.402607415e-004
	,3.542721185e-004
	,3.684832062e-004
	,3.828857066e-004
	,3.974747570e-004
	,4.122474613e-004
	,4.271970853e-004
	,4.419529953e-004
	,4.558114610e-004
	,4.698149527e-004
	,4.839614571e-004
	,4.982463725e-004
	,5.126760454e-004
	,5.272426949e-004
	,5.419440911e-004
	,5.567788853e-004
	,5.717458589e-004
	,5.868439211e-004
	,6.020721546e-004
	,6.174337960e-004
	,6.329266193e-004
	,6.485510255e-004
	,6.643064089e-004
	,6.801982221e-004
	,6.962188236e-004
	,7.123681979e-004
	,7.286264298e-004
	,7.447794267e-004
	,7.610371211e-004
	,7.774083916e-004
	,7.938937770e-004
	,8.104835323e-004
	,-4.166994882e-005
	,-3.546027174e-005
	,-2.982460101e-005
	,-2.478890573e-005
	,-2.034942545e-005
	,-1.648619279e-005
	,-1.317027928e-005
	,-1.036600173e-005
	,-8.032818799e-006
	,-6.127501618e-006
	,-4.603779369e-006
	,-3.409420812e-006
	,-2.490699085e-006
	,-1.798301041e-006
	,-1.286021042e-006
	,-9.123926653e-007
	,-6.431439591e-007
	,-4.510159704e-007
	,-3.149604893e-007
	,-2.191917625e-007
	,-1.521044454e-007
	,-1.052881588e-007
	,-7.272023564e-008
	,-5.013534417e-008
	,-3.451581194e-008
	,-2.373316263e-008
	,-1.629995776e-008
	,-1.118080603e-008
	,-7.657873401e-009
	,-5.234883204e-009
	,-3.569255299e-009
	,-2.424759214e-009
	,-1.638613151e-009
	,-1.098735932e-009
	,-7.280213550e-010
	,-4.734636927e-010
	,-2.986402820e-010
	,-1.785324135e-010
	,-9.596409799e-011
	,-3.914881845e-011
	,-5.117373960e-018
	,2.703190260e-011
	,4.575609748e-011
	,5.878683274e-011
	,6.791705841e-011
	,7.437586098e-011
	,7.900574240e-011
	,8.238363798e-011
	,8.490467808e-011
	,8.683950574e-011
	,8.837352905e-011
	,8.963360847e-011
	,9.070667021e-011
	,9.165218940e-011
	,9.251101516e-011
	,9.331103140e-011
	,9.407131177e-011
	,9.480492315e-011
	,9.552092288e-011
	,9.622541183e-011
	,9.692262641e-011
	,9.761565063e-011
	,9.830650030e-011
	,9.899660949e-011
	,9.968720821e-011
	,1.003788914e-010
	,1.010723840e-010
	,1.017682328e-010
	,1.024667713e-010
	,1.031686095e-010
	,1.038741678e-010
	,1.045841030e-010
	,1.052983832e-010
	,1.060183883e-010
	,1.067452858e-010
	,1.074801599e-010
	,1.082242534e-010
	,1.089789953e-010
	,1.097475713e-010
	,1.105372994e-010
	,1.113600746e-010
	,1.122302959e-010
	,1.131661731e-010
	,1.141905037e-010
	,1.153337886e-010
	,1.166368267e-010
	,1.181548260e-010
	,1.199624165e-010
	,1.221613157e-010
	,1.248896837e-010
	,1.283350094e-010
	,1.327524113e-010
	,1.384885938e-010
	,1.460158149e-010
	,1.554588531e-010
	,1.678717388e-010
	,1.843382421e-010
	,2.062909331e-010
	,2.356756905e-010
	,2.751370825e-010
	,3.282711833e-010
	,3.999699370e-010
	,4.968906736e-010
	,6.280958947e-010
	,7.946573506e-010
	,1.013597361e-009
	,1.304345658e-009
	,1.690607480e-009
	,2.203920300e-009
	,2.886266884e-009
	,3.793510309e-009
	,4.999951410e-009
	,6.604397804e-009
	,8.738198567e-009
	,1.157587714e-008
	,1.534917793e-008
	,2.036558444e-008
	,2.703266966e-008
	,3.589001395e-008
	,4.765088216e-008
	,6.325638938e-008
	,8.393817495e-008
	,1.111985592e-007
	,1.472300905e-007
	,1.947704454e-007
	,2.573603773e-007
	,3.395487850e-007
	,4.471331333e-007
	,5.874319890e-007
	,7.695804523e-007
	,1.004831103e-006
	,1.306833129e-006
	,1.691851862e-006
	,2.178882428e-006
	,2.789608102e-006
	,3.548160454e-006
	,4.480657424e-006
	,5.614526290e-006
	,6.977653573e-006
	,8.597443867e-006
	,1.049989200e-005
	,1.270877532e-005
	,1.524504472e-005
	,1.812646472e-005
	,2.136750329e-005
	,2.497944124e-005
	,2.897064627e-005
	,3.334695980e-005
	,3.811212661e-005
	,4.326822643e-005
	,4.881608081e-005
	,5.475563134e-005
	,6.108623448e-005
	,6.780692073e-005
	,7.491659776e-005
	,8.241420819e-005
	,9.029887910e-005
	,9.856996326e-005
	,1.072270848e-004
	,1.162705637e-004
	,1.256507512e-004
	,1.353843855e-004
	,1.450940480e-004
	,1.550519423e-004
	,1.653397777e-004
	,1.759500237e-004
	,1.868757391e-004
	,1.981105069e-004
	,2.096468435e-004
	,2.214778711e-004
	,2.335968682e-004
	,2.459973590e-004
	,2.586729824e-004
	,2.716175948e-004
	,2.848280205e-004
	,2.982983208e-004
	,3.120204437e-004
	,3.259887918e-004
	,3.401980893e-004
	,3.546446425e-004
	,3.693218002e-004
	,3.842255621e-004
	,3.993529678e-004
	,4.140683901e-004
	,4.280951969e-004
	,4.422960200e-004
	,4.566734151e-004
	,4.712220872e-004
	,4.859398983e-004
	,5.008252942e-004
	,5.158768771e-004
	,5.310939303e-004
	,5.464755271e-004
	,5.620204797e-004
	,5.777310886e-004
	,5.936045780e-004
	,6.096397097e-004
	,6.258422398e-004
	,6.422062932e-004
	,6.587318823e-004
	,6.754191809e-004
	,-4.712785542e-005
	,-4.035669928e-005
	,-3.418681425e-005
	,-2.861276679e-005
	,-2.363022113e-005
	,-1.922874403e-005
	,-1.538295099e-005
	,-1.207646350e-005
	,-9.318500211e-006
	,-7.081346259e-006
	,-5.305759023e-006
	,-3.923647379e-006
	,-2.866697260e-006
	,-2.070641291e-006
	,-1.480596150e-006
	,-1.050526161e-006
	,-7.401684287e-007
	,-5.180075694e-007
	,-3.608123333e-007
	,-2.504900577e-007
	,-1.734484606e-007
	,-1.198442378e-007
	,-8.265583506e-008
	,-5.691727875e-008
	,-3.913810510e-008
	,-2.687693777e-008
	,-1.843266948e-008
	,-1.262362634e-008
	,-8.631332034e-009
	,-5.890021114e-009
	,-4.008957508e-009
	,-2.718816098e-009
	,-1.834268989e-009
	,-1.227941064e-009
	,-8.123685789e-010
	,-5.275345714e-010
	,-3.322774648e-010
	,-1.983795822e-010
	,-1.065037599e-010
	,-4.340210465e-011
	,9.398776754e-018
	,2.991706374e-011
	,5.060406913e-011
	,6.497371481e-011
	,7.501940507e-011
	,8.210458733e-011
	,8.716103487e-011
	,9.082520988e-011
	,9.353404621e-011
	,9.558997271e-011
	,9.720137598e-011
	,9.851092833e-011
	,9.961581271e-011
	,1.005824108e-010
	,1.014560230e-010
	,1.022675123e-010
	,1.030380208e-010
	,1.037819422e-010
	,1.045091900e-010
	,1.052264927e-010
	,1.059383118e-010
	,1.066479891e-010
	,1.073574944e-010
	,1.080683074e-010
	,1.087815718e-010
	,1.094977858e-010
	,1.102174649e-010
	,1.109409075e-010
	,1.116683213e-010
	,1.123998869e-010
	,1.131355959e-010
	,1.138755609e-010
	,1.146198933e-010
	,1.153685455e-010
	,1.161217038e-010
	,1.168793929e-010
	,1.176417682e-010
	,1.184090137e-010
	,1.191811291e-010
	,1.199587437e-010
	,1.207424688e-010
	,1.215330571e-010
	,1.223316555e-010
	,1.231398063e-010
	,1.239594708e-010
	,1.247935707e-010
	,1.256458013e-010
	,1.265211963e-010
	,1.274266065e-010
	,1.283711569e-010
	,1.293672752e-010
	,1.304317344e-010
	,1.315871484e-010
	,1.328641008e-010
	,1.343040991e-010
	,1.359633653e-010
	,1.379180353e-010
	,1.402713998e-010
	,1.431640051e-010
	,1.467863566e-010
	,1.512122425e-010
	,1.567706143e-010
	,1.639407103e-010
	,1.732847879e-010
	,1.855649621e-010
	,2.018150528e-010
	,2.234383954e-010
	,2.523406135e-010
	,2.911112761e-010
	,3.432702354e-010
	,4.111252167e-010
	,4.981018521e-010
	,6.131951213e-010
	,7.656337628e-010
	,9.676866554e-010
	,1.235665921e-009
	,1.591260846e-009
	,2.063310812e-009
	,2.690161575e-009
	,3.522794317e-009
	,4.628979563e-009
	,6.098772463e-009
	,8.051838698e-009
	,1.064710302e-008
	,1.409551111e-008
	,1.867687367e-008
	,2.476203218e-008
	,3.284195818e-008
	,4.356583289e-008
	,5.778772176e-008
	,7.652082441e-008
	,1.013095758e-007
	,1.340683305e-007
	,1.772897221e-007
	,2.342027456e-007
	,3.089644639e-007
	,4.068870316e-007
	,5.346984559e-007
	,7.008303285e-007
	,9.157184097e-007
	,1.192092600e-006
	,1.545222444e-006
	,1.993074862e-006
	,2.556335417e-006
	,3.258247244e-006
	,4.124241468e-006
	,5.181332676e-006
	,6.457332752e-006
	,7.979946674e-006
	,9.775835183e-006
	,1.186975705e-005
	,1.428388212e-005
	,1.703733552e-005
	,2.014599102e-005
	,2.362249530e-005
	,2.747647659e-005
	,3.171488103e-005
	,3.634239198e-005
	,4.136183534e-005
	,4.677458897e-005
	,5.258098543e-005
	,5.878060695e-005
	,6.537269891e-005
	,7.235605814e-005
	,7.972936393e-005
	,8.749135624e-005
	,9.564144192e-005
	,1.041782765e-004
	,1.131009717e-004
	,1.224097212e-004
	,1.317659618e-004
	,1.413399848e-004
	,1.512665026e-004
	,1.615399733e-004
	,1.721547480e-004
	,1.831060557e-004
	,1.943895233e-004
	,2.060017179e-004
	,2.179399803e-004
	,2.302010272e-004
	,2.427811175e-004
	,2.556779432e-004
	,2.688897488e-004
	,2.824156473e-004
	,2.960165853e-004
	,3.098779648e-004
	,3.239989401e-004
	,3.383742397e-004
	,3.529988765e-004
	,3.678656601e-004
	,3.829693040e-004
	,3.967313430e-004
	,4.106688949e-004
	,4.247880095e-004
	,4.390860337e-004
	,4.535615116e-004
	,4.682116130e-004
	,4.830341317e-004
	,4.980276233e-004
	,5.131917263e-004
	,5.285237609e-004
	,-5.155232487e-005
	,-4.430596265e-005
	,-3.764281071e-005
	,-3.154882234e-005
	,-2.599676469e-005
	,-2.102661270e-005
	,-1.671845048e-005
	,-1.308102102e-005
	,-1.007688306e-005
	,-7.646883613e-006
	,-5.718903893e-006
	,-4.214801783e-006
	,-3.065680429e-006
	,-2.202889818e-006
	,-1.567182619e-006
	,-1.107023446e-006
	,-7.778595274e-007
	,-5.443152955e-007
	,-3.796323722e-007
	,-2.640650289e-007
	,-1.832734541e-007
	,-1.269646265e-007
	,-8.781534511e-008
	,-6.065059317e-008
	,-4.183247738e-008
	,-2.881383455e-008
	,-1.981588047e-008
	,-1.360000035e-008
	,-9.314374232e-009
	,-6.365688338e-009
	,-4.338647275e-009
	,-2.945940126e-009
	,-1.989499004e-009
	,-1.332927992e-009
	,-8.823604387e-010
	,-5.732324605e-010
	,-3.611617215e-010
	,-2.156576722e-010
	,-1.157865433e-010
	,-4.718416240e-011
	,6.109145476e-018
	,3.251814036e-011
	,5.499664678e-011
	,7.060419277e-011
	,8.151063971e-011
	,8.920117678e-011
	,9.469249504e-011
	,9.868039462e-011
	,1.016409259e-010
	,1.038998679e-010
	,1.056801705e-010
	,1.071341861e-010
	,1.083663733e-010
	,1.094481487e-010
	,1.104283000e-010
	,1.113402085e-010
	,1.122067560e-010
	,1.130435467e-010
	,1.138613437e-010
	,1.146673695e-010
	,1.154666155e-010
	,1.162624597e-010
	,1.170572856e-010
	,1.178525974e-010
	,1.186494093e-010
	,1.194484452e-010
	,1.202501992e-010
	,1.210550353e-010
	,1.218632025e-010
	,1.226748049e-010
	,1.234900380e-010
	,1.243089784e-010
	,1.251318066e-010
	,1.259586043e-010
	,1.267894113e-010
	,1.276244106e-010
	,1.284635811e-010
	,1.293070753e-010
	,1.301549896e-010
	,1.310073485e-010
	,1.318643051e-010
	,1.327259615e-010
	,1.335924247e-010
	,1.344638177e-010
	,1.353401595e-010
	,1.362218233e-010
	,1.371090577e-010
	,1.380023080e-010
	,1.389020020e-010
	,1.398088154e-010
	,1.407236805e-010
	,1.416476745e-010
	,1.425825658e-010
	,1.435303084e-010
	,1.444938835e-010
	,1.454770142e-010
	,1.464849620e-010
	,1.475246774e-010
	,1.486056645e-010
	,1.497405438e-010
	,1.509465740e-010
	,1.522469922e-010
	,1.536732697e-010
	,1.552677951e-010
	,1.570883834e-010
	,1.592133868e-010
	,1.616900789e-010
	,1.645975961e-010
	,1.681572602e-010
	,1.725926176e-010
	,1.782052895e-010
	,1.854046873e-010
	,1.947443787e-010
	,2.069753466e-010
	,2.231159683e-010
	,2.445483630e-010
	,2.729321363e-010
	,3.083327351e-010
	,3.548588359e-010
	,4.161330965e-010
	,4.969624471e-010
	,6.037287069e-010
	,7.449121811e-010
	,9.317742090e-010
	,1.179273769e-009
	,1.507283769e-009
	,1.942207299e-009
	,2.519123137e-009
	,3.284635141e-009
	,4.300653667e-009
	,5.649407841e-009
	,7.440088742e-009
	,9.817642197e-009
	,1.297439234e-008
	,1.716538767e-008
	,2.272863024e-008
	,3.011164672e-008
	,3.990646724e-008
	,5.278835614e-008
	,6.984388555e-008
	,9.240404489e-008
	,1.222100797e-007
	,1.615314955e-007
	,2.133123649e-007
	,2.813500083e-007
	,3.705085324e-007
	,4.869670505e-007
	,6.384979806e-007
	,8.347642921e-007
	,1.087615934e-006
	,1.411355587e-006
	,1.822934062e-006
	,2.342027825e-006
	,2.990952602e-006
	,3.794374477e-006
	,4.778795837e-006
	,5.971841355e-006
	,7.401396913e-006
	,9.094680452e-006
	,1.107735230e-005
	,1.337276155e-005
	,1.600140144e-005
	,1.898060801e-005
	,2.232450093e-005
	,2.604413467e-005
	,3.014773275e-005
	,3.464111807e-005
	,3.952810473e-005
	,4.481090719e-005
	,5.049058812e-005
	,5.656739248e-005
	,6.304087335e-005
	,6.991019866e-005
	,7.717434259e-005
	,8.483264323e-005
	,9.288376014e-005
	,1.013266944e-004
	,1.101609361e-004
	,1.190991275e-004
	,1.282174982e-004
	,1.376939493e-004
	,1.475224351e-004
	,1.576970446e-004
	,1.682116499e-004
	,1.790608712e-004
	,1.902395487e-004
	,2.017427216e-004
	,2.135657177e-004
	,2.257044208e-004
	,2.381548254e-004
	,2.509126549e-004
	,2.639746781e-004
	,2.773371986e-004
	,2.909961345e-004
	,3.049484603e-004
	,3.191922530e-004
	,3.337274373e-004
	,3.485499965e-004
	,3.636210848e-004
	,3.773152256e-004
	,3.912227594e-004
	,-5.538670780e-005
	,-4.761643714e-005
	,-4.036191039e-005
	,-3.364668346e-005
	,-2.758704408e-005
	,-2.225810502e-005
	,-1.767693065e-005
	,-1.381831106e-005
	,-1.063218782e-005
	,-8.049786866e-006
	,-5.991389340e-006
	,-4.388428094e-006
	,-3.174441676e-006
	,-2.272821406e-006
	,-1.614454027e-006
	,-1.139812746e-006
	,-8.008306509e-007
	,-5.604995083e-007
	,-3.910885626e-007
	,-2.722105124e-007
	,-1.890882125e-007
	,-1.311267587e-007
	,-9.078334909e-008
	,-6.270306876e-008
	,-4.323852445e-008
	,-2.979250480e-008
	,-2.051106494e-008
	,-1.410682205e-008
	,-9.689233167e-009
	,-6.642868326e-009
	,-4.542639578e-009
	,-3.095043172e-009
	,-2.097493471e-009
	,-1.410200930e-009
	,-9.367344226e-010
	,-6.105915132e-010
	,-3.859226281e-010
	,-2.311265120e-010
	,-1.244283791e-010
	,-5.082927013e-011
	,-2.114779939e-017
	,3.517040725e-011
	,5.957612322e-011
	,7.658461310e-011
	,8.851203626e-011
	,9.695095552e-011
	,1.029960349e-010
	,1.073992542e-010
	,1.106770238e-010
	,1.131837543e-010
	,1.151627522e-010
	,1.167808035e-010
	,1.181523657e-010
	,1.193559303e-010
	,1.204453911e-010
	,1.214575813e-010
	,1.224180112e-010
	,1.233440028e-010
	,1.242476198e-010
	,1.251371725e-010
	,1.260183177e-010
	,1.268950112e-010
	,1.277700407e-010
	,1.286453614e-010
	,1.295222675e-010
	,1.304018059e-010
	,1.312845026e-010
	,1.321709761e-010
	,1.330615141e-010
	,1.339564142e-010
	,1.348558511e-010
	,1.357599163e-010
	,1.366687780e-010
	,1.375825646e-010
	,1.385012720e-010
	,1.394249405e-010
	,1.403536931e-010
	,1.412875107e-010
	,1.422264086e-010
	,1.431704840e-010
	,1.441196853e-010
	,1.450741044e-010
	,1.460337010e-010
	,1.469985564e-010
	,1.479686112e-010
	,1.489440530e-010
	,1.499247518e-010
	,1.509107943e-010
	,1.519022622e-010
	,1.528992052e-010
	,1.539015977e-010
	,1.549095918e-010
	,1.559232862e-010
	,1.569428623e-010
	,1.579685878e-010
	,1.590007250e-010
	,1.600396096e-010
	,1.610858289e-010
	,1.621399776e-010
	,1.632030674e-010
	,1.642762934e-010
	,1.653613505e-010
	,1.664603798e-010
	,1.675764171e-010
	,1.687134630e-010
	,1.698769279e-010
	,1.710739516e-010
	,1.723144416e-010
	,1.736116048e-010
	,1.749832627e-010
	,1.764537936e-010
	,1.780556440e-010
	,1.798197334e-010
	,1.817479123e-010
	,1.839460258e-010
	,1.865044604e-010
	,1.895447933e-010
	,1.932309247e-010
	,1.977844224e-010
	,2.035048548e-010
	,2.107975691e-010
	,2.202119109e-010
	,2.324928668e-010
	,2.478033679e-010
	,2.673463362e-010
	,2.927809433e-010
	,3.260101857e-010
	,3.695559289e-010
	,4.267619044e-010
	,5.020621088e-010
	,6.013379621e-010
	,7.323854753e-010
	,9.055614238e-010
	,1.134607815e-009
	,1.437764453e-009
	,1.839244714e-009
	,2.371193999e-009
	,3.076288220e-009
	,4.011181360e-009
	,5.251076776e-009
	,6.895784150e-009
	,9.077741716e-009
	,1.197262735e-008
	,1.581338116e-008
	,2.090869248e-008
	,2.766745598e-008
	,3.653967555e-008
	,4.828465503e-008
	,6.382655471e-008
	,8.437539673e-008
	,1.115152829e-007
	,1.473126296e-007
	,1.944512912e-007
	,2.563986317e-007
	,3.376056418e-007
	,4.437420773e-007
	,5.819638876e-007
	,7.612045034e-007
	,9.924736411e-007
	,1.289137793e-006
	,1.667146446e-006
	,2.145158723e-006
	,2.744524494e-006
	,3.489074272e-006
	,4.404698448e-006
	,5.518706031e-006
	,6.859021834e-006
	,8.453280172e-006
	,1.032791899e-005
	,1.250737335e-005
	,1.501345797e-005
	,1.786495786e-005
	,2.107749702e-005
	,2.466360148e-005
	,2.863287860e-005
	,3.299240836e-005
	,3.774712493e-005
	,4.290022012e-005
	,4.845358845e-005
	,5.440814294e-005
	,6.076394736e-005
	,6.752067893e-005
	,7.467778939e-005
	,8.223504111e-005
	,9.019167672e-005
	,9.854680507e-005
	,1.070668668e-004
	,1.157282523e-004
	,1.247558642e-004
	,1.341429126e-004
	,1.438831907e-004
	,1.539708730e-004
	,1.644003998e-004
	,1.751663593e-004
	,1.862630603e-004
	,1.976860365e-004
	,2.094292344e-004
	,2.214875825e-004
	,2.338561430e-004
	,2.465301239e-004
	,2.595073881e-004
	,-5.879480221e-005
	,-5.036323013e-005
	,-4.250045775e-005
	,-3.532412101e-005
	,-2.890831057e-005
	,-2.329395117e-005
	,-1.847618019e-005
	,-1.441966540e-005
	,-1.106306147e-005
	,-8.323724775e-006
	,-6.158247428e-006
	,-4.497088375e-006
	,-3.245854557e-006
	,-2.320936313e-006
	,-1.647508057e-006
	,-1.162693722e-006
	,-8.167500467e-007
	,-5.716267031e-007
	,-3.988987111e-007
	,-2.777069929e-007
	,-1.929346250e-007
	,-1.336549790e-007
	,-9.239982864e-008
	,-6.383426976e-008
	,-4.407474645e-008
	,-3.041310086e-008
	,-2.097080700e-008
	,-1.444658956e-008
	,-9.939716409e-009
	,-6.827039345e-009
	,-4.677628212e-009
	,-3.193580347e-009
	,-2.169015316e-009
	,-1.461686938e-009
	,-9.733386983e-010
	,-6.361155302e-010
	,-4.031675290e-010
	,-2.421550625e-010
	,-1.307595619e-010
	,-5.358191793e-011
	,-3.237584662e-018
	,3.731133636e-011
	,6.340211650e-011
	,8.175294408e-011
	,9.476210217e-011
	,1.040816783e-010
	,1.108498095e-010
	,1.158506776e-010
	,1.196249280e-010
	,1.225456953e-010
	,1.248712768e-010
	,1.267808959e-010
	,1.283994114e-010
	,1.298141530e-010
	,1.310864664e-010
	,1.322594944e-010
	,1.333637869e-010
	,1.344208097e-010
	,1.354458022e-010
	,1.364495401e-010
	,1.374396282e-010
	,1.384214480e-010
	,1.393988867e-010
	,1.403746404e-010
	,1.413507477e-010
	,1.423285483e-010
	,1.433090788e-010
	,1.442931270e-010
	,1.452811815e-010
	,1.462737287e-010
	,1.472709754e-010
	,1.482732296e-010
	,1.492806719e-010
	,1.502934194e-010
	,1.513116267e-010
	,1.523353690e-010
	,1.533646846e-010
	,1.543996593e-010
	,1.554403930e-010
	,1.564868817e-010
	,1.575391499e-010
	,1.585972864e-010
	,1.596612655e-010
	,1.607311950e-010
	,1.618070136e-010
	,1.628887829e-010
	,1.639764791e-010
	,1.650701846e-010
	,1.661698322e-010
	,1.672755672e-010
	,1.683873085e-010
	,1.695050713e-010
	,1.706288397e-010
	,1.717587987e-010
	,1.728948104e-010
	,1.740370063e-010
	,1.751851973e-010
	,1.763396923e-010
	,1.775004013e-010
	,1.786674158e-010
	,1.798409101e-010
	,1.810210106e-010
	,1.822078093e-010
	,1.834015249e-010
	,1.846025703e-010
	,1.858112682e-010
	,1.870282388e-010
	,1.882541852e-010
	,1.894900885e-010
	,1.907372609e-010
	,1.919974148e-010
	,1.932730058e-010
	,1.945670215e-010
	,1.958836287e-010
	,1.972286626e-010
	,1.986096915e-010
	,2.000371347e-010
	,2.015247856e-010
	,2.030916587e-010
	,2.047238556e-010
	,2.064720677e-010
	,2.083740449e-010
	,2.104787427e-010
	,2.128530908e-010
	,2.155871941e-010
	,2.188022914e-010
	,2.226623148e-010
	,2.273883963e-010
	,2.332803820e-010
	,2.405688584e-010
	,2.494495809e-010
	,2.607189347e-010
	,2.751391148e-010
	,2.937126319e-010
	,3.177752169e-010
	,3.490910902e-010
	,3.899954960e-010
	,4.435813623e-010
	,5.139459436e-010
	,6.065176517e-010
	,7.284922708e-010
	,8.894111067e-010
	,1.101925455e-009
	,1.382803950e-009
	,1.754278682e-009
	,2.245884447e-009
	,2.896780885e-009
	,3.758920859e-009
	,4.901229653e-009
	,6.415144269e-009
	,8.421953914e-009
	,1.108252121e-008
	,1.461014472e-008
	,1.928763149e-008
	,2.541190638e-008
	,3.351385739e-008
	,4.423474187e-008
	,5.841285270e-008
	,7.714903683e-008
	,1.018850292e-007
	,1.345028011e-007
	,1.774491292e-007
	,2.338895745e-007
	,3.078954001e-007
	,4.046653421e-007
	,5.307810830e-007
	,6.944902976e-007
	,9.060044699e-007
	,1.177788527e-006
	,1.524810690e-006
	,1.964714710e-006
	,2.517857496e-006
	,3.207177852e-006
	,4.057858044e-006
	,5.096771876e-006
	,6.351741369e-006
	,7.850668691e-006
	,9.620630680e-006
	,1.168703272e-005
	,1.407291488e-005
	,1.679847144e-005
	,1.988080681e-005
	,2.333391600e-005
	,2.716889244e-005
	,3.139417034e-005
	,3.601589935e-005
	,4.103833102e-005
	,4.646423080e-005
	,5.229533869e-005
	,5.853247752e-005
	,6.517592126e-005
	,7.222564548e-005
	,7.968151991e-005
	,8.754316178e-005
	,9.564031698e-005
	,1.038305719e-004
	,1.123963660e-004
	,1.213309941e-004
	,1.306281531e-004
	,1.402814564e-004
	,1.502849731e-004
	,-6.154957969e-005
	,-5.256644548e-005
	,-4.428200729e-005
	,-3.675520660e-005
	,-3.004959267e-005
	,-2.418900494e-005
	,-1.915890490e-005
	,-1.490963952e-005
	,-1.136512861e-005
	,-8.511081212e-006
	,-6.284565275e-006
	,-4.580256787e-006
	,-3.301093334e-006
	,-2.358407114e-006
	,-1.673121281e-006
	,-1.180287565e-006
	,-8.288919425e-007
	,-5.800427964e-007
	,-4.047452790e-007
	,-2.816951138e-007
	,-1.953496524e-007
	,-1.352373237e-007
	,-9.356079509e-008
	,-6.469298544e-008
	,-4.470842872e-008
	,-3.087930435e-008
	,-2.131282763e-008
	,-1.469685468e-008
	,-1.012238017e-008
	,-6.960006562e-009
	,-4.774118516e-009
	,-3.263322729e-009
	,-2.219150980e-009
	,-1.497445620e-009
	,-9.985427696e-010
	,-6.535536791e-010
	,-4.148708820e-010
	,-2.496003672e-010
	,-1.350186595e-010
	,-5.543113747e-011
	,-1.441188773e-017
	,3.875718220e-011
	,6.600561069e-011
	,8.531010409e-011
	,9.913060672e-011
	,1.091639108e-010
	,1.165798638e-010
	,1.221843361e-010
	,1.265321769e-010
	,1.300048896e-010
	,1.328644164e-010
	,1.352904516e-010
	,1.374059965e-010
	,1.392950539e-010
	,1.410153825e-010
	,1.426067173e-010
	,1.440966630e-010
	,1.455053245e-010
	,1.468476053e-010
	,1.481354976e-010
	,1.493789726e-010
	,1.505866545e-010
	,1.517660624e-010
	,1.529237996e-010
	,1.540654929e-010
	,1.551957976e-010
	,1.563185879e-010
	,1.574369495e-010
	,1.585533212e-010
	,1.596696838e-010
	,1.607874101e-010
	,1.619077686e-010
	,1.630315773e-010
	,1.641595145e-010
	,1.652921949e-010
	,1.664300172e-010
	,1.675732776e-010
	,1.687222344e-010
	,1.698770953e-010
	,1.710380522e-010
	,1.722052688e-010
	,1.733788024e-010
	,1.745587494e-010
	,1.757452456e-010
	,1.769383272e-010
	,1.781379863e-010
	,1.793443266e-010
	,1.805574140e-010
	,1.817772663e-010
	,1.830038771e-010
	,1.842373275e-010
	,1.854776049e-010
	,1.867247563e-010
	,1.879788124e-010
	,1.892397484e-010
	,1.905075844e-010
	,1.917823476e-010
	,1.930640317e-010
	,1.943526303e-010
	,1.956482846e-010
	,1.969508405e-010
	,1.982604601e-010
	,1.995770331e-010
	,2.009005926e-010
	,2.022312465e-010
	,2.035690214e-010
	,2.049140042e-010
	,2.062660893e-010
	,2.076255616e-010
	,2.089923686e-010
	,2.103667944e-010
	,2.117488835e-010
	,2.131391232e-010
	,2.145376006e-010
	,2.159448497e-010
	,2.173616084e-010
	,2.187884006e-010
	,2.202264283e-010
	,2.216770682e-010
	,2.231421739e-010
	,2.246242514e-010
	,2.261267124e-010
	,2.276540072e-010
	,2.292123032e-010
	,2.308097780e-010
	,2.324427752e-010
	,2.341258876e-010
	,2.358789164e-010
	,2.377221787e-010
	,2.396829707e-010
	,2.417988287e-010
	,2.441197930e-010
	,2.467131262e-010
	,2.496696800e-010
	,2.531121117e-010
	,2.572057694e-010
	,2.619029521e-010
	,2.675870831e-010
	,2.745661687e-010
	,2.832446831e-010
	,2.941631780e-010
	,3.080307433e-010
	,3.257865631e-010
	,3.486705788e-010
	,3.783217335e-010
	,4.169078134e-010
	,4.672966048e-010
	,5.332832158e-010
	,6.198914741e-010
	,7.337746785e-010
	,8.837448823e-010
	,1.081477025e-009
	,1.342409841e-009
	,1.687054071e-009
	,2.142589473e-009
	,2.745043149e-009
	,3.542185706e-009
	,4.597365317e-009
	,5.994594579e-009
	,7.845289491e-009
	,1.029726751e-008
	,1.354663955e-008
	,1.778706500e-008
	,2.339036881e-008
	,3.080175889e-008
	,4.060142441e-008
	,5.355259869e-008
	,7.065755971e-008
	,9.322928107e-008
	,1.229825353e-007
	,1.621485624e-007
	,2.136175324e-007
	,2.811126389e-007
	,3.693984434e-007
	,4.845230748e-007
	,6.340928062e-007
	,8.275644236e-007
	,1.076540576e-006
	,1.395038537e-006
	,1.799694422e-006
	,2.309857236e-006
	,2.947527774e-006
	,3.737101658e-006
	,4.704902575e-006
	,5.878512937e-006
	,7.285952583e-006
	,8.954787703e-006
	,1.091126752e-005
	,1.317957376e-005
	,1.578123713e-005
	,1.873483752e-005
	,2.205588276e-005
	,2.575689615e-005
	,2.984768016e-005
	,3.433566395e-005
	,3.922625311e-005
	,4.452321891e-005
	,5.022910046e-005
	,5.634564324e-005
	,6.287387861e-005
	,6.981440487e-005
	,-6.359940467e-005
	,-5.431926681e-005
	,-4.575489937e-005
	,-3.797283655e-005
	,-3.103541928e-005
	,-2.496106866e-005
	,-1.972077341e-005
	,-1.526153311e-005
	,-1.158766019e-005
	,-8.663738184e-006
	,-6.386933559e-006
	,-4.647381246e-006
	,-3.346134626e-006
	,-2.388914777e-006
	,-1.693877754e-006
	,-1.194472086e-006
	,-8.386294256e-007
	,-5.867456466e-007
	,-4.092761469e-007
	,-2.843218611e-007
	,-1.970917190e-007
	,-1.365186784e-007
	,-9.450670213e-008
	,-6.538909308e-008
	,-4.521897131e-008
	,-3.125260900e-008
	,-2.158503919e-008
	,-1.489484142e-008
	,-1.026601124e-008
	,-7.063913708e-009
	,-4.849039519e-009
	,-3.317115403e-009
	,-2.257551954e-009
	,-1.524634475e-009
	,-1.017558945e-009
	,-6.666038685e-010
	,-4.235546857e-010
	,-2.550757213e-010
	,-1.381221827e-010
	,-5.676610665e-011
	,3.393894261e-018
	,3.978283905e-011
	,6.783847580e-011
	,8.779832245e-011
	,1.021705715e-010
	,1.126870601e-010
	,1.205429449e-010
	,1.265627302e-010
	,1.313147343e-010
	,1.351903175e-010
	,1.384586859e-010
	,1.413047372e-010
	,1.438550552e-010
	,1.461959767e-010
	,1.483860296e-010
	,1.504646266e-010
	,1.524578756e-010
	,1.543826655e-010
	,1.562496766e-010
	,1.580653338e-010
	,1.598331216e-010
	,1.615547929e-010
	,1.632309547e-010
	,1.648618713e-010
	,1.664478806e-010
	,1.679898131e-010
	,1.694892227e-010
	,1.709486243e-010
	,1.723716442e-010
	,1.737625630e-010
	,1.751262261e-010
	,1.764677776e-010
	,1.777922014e-010
	,1.791039025e-010
	,1.804070056e-010
	,1.817047930e-010
	,1.830000125e-010
	,1.842949907e-010
	,1.855914508e-010
	,1.868907902e-010
	,1.881940728e-010
	,1.895021121e-010
	,1.908156369e-010
	,1.921351349e-010
	,1.934609479e-010
	,1.947934216e-010
	,1.961328158e-010
	,1.974793330e-010
	,1.988330847e-010
	,2.001942881e-010
	,2.015629616e-010
	,2.029392385e-010
	,2.043231610e-010
	,2.057148149e-010
	,2.071142202e-010
	,2.085214833e-010
	,2.099365459e-010
	,2.113595695e-010
	,2.127904587e-010
	,2.142293067e-010
	,2.156760837e-010
	,2.171308435e-010
	,2.185936083e-010
	,2.200643378e-010
	,2.215431153e-010
	,2.230298988e-010
	,2.245247467e-010
	,2.260276337e-010
	,2.275385679e-010
	,2.290575267e-010
	,2.305846903e-010
	,2.321198697e-010
	,2.336632031e-010
	,2.352147076e-010
	,2.367743905e-010
	,2.383424218e-010
	,2.399187123e-010
	,2.415034632e-010
	,2.430967938e-010
	,2.446987814e-010
	,2.463097336e-010
	,2.479299108e-010
	,2.495597022e-010
	,2.511996006e-010
	,2.528502472e-010
	,2.545125795e-010
	,2.561876169e-010
	,2.578770137e-010
	,2.595826904e-010
	,2.613074263e-010
	,2.630549119e-010
	,2.648251160e-010
	,2.666203536e-010
	,2.684511648e-010
	,2.703261982e-010
	,2.722573204e-010
	,2.742602037e-010
	,2.763558926e-010
	,2.785726758e-010
	,2.809484998e-010
	,2.835345336e-010
	,2.863998865e-010
	,2.895613315e-010
	,2.931085366e-010
	,2.972019047e-010
	,3.020042104e-010
	,3.077390312e-010
	,3.146968442e-010
	,3.232594352e-010
	,3.339311658e-010
	,3.473766773e-010
	,3.644730565e-010
	,3.863781323e-010
	,4.146207539e-010
	,4.512209098e-010
	,4.988350948e-010
	,5.609798924e-010
	,6.423287147e-010
	,7.490464799e-010
	,8.892868301e-010
	,1.073856121e-009
	,1.317055399e-009
	,1.637825217e-009
	,2.061256955e-009
	,2.620598241e-009
	,3.359914869e-009
	,4.337625880e-009
	,5.631206863e-009
	,7.343441468e-009
	,9.610767489e-009
	,1.255764274e-008
	,1.644489848e-008
	,2.158306969e-008
	,2.837353216e-008
	,3.734502942e-008
	,4.919317090e-008
	,6.483139248e-008
	,8.545643685e-008
	,1.126318067e-007
	,1.483932746e-007
	,1.953804596e-007
	,2.569985339e-007
	,3.376133336e-007
	,4.427810134e-007
	,5.795077752e-007
	,7.565402252e-007
	,9.846615505e-007
	,1.276970301e-006
	,1.649113912e-006
	,2.119429357e-006
	,2.708946253e-006
	,3.441207718e-006
	,4.341888218e-006
	,5.438203436e-006
	,6.758148031e-006
	,8.329638555e-006
	,1.017962046e-005
	,1.233328304e-005
	,1.481342432e-005
	,1.764004987e-005
	,2.083015459e-005
	,-6.517716065e-005
	,-5.567230823e-005
	,-4.689702843e-005
	,-3.892730994e-005
	,-3.181158347e-005
	,-2.554303801e-005
	,-2.010232353e-005
	,-1.550896396e-005
	,-1.176134168e-005
	,-8.785784893e-006
	,-6.468317077e-006
	,-4.701947972e-006
	,-3.383186739e-006
	,-2.414118933e-006
	,-1.711048022e-006
	,-1.206201093e-006
	,-8.466616760e-007
	,-5.921985735e-007
	,-4.124560268e-007
	,-2.863242559e-007
	,-1.985606265e-007
	,-1.376028604e-007
	,-9.530423672e-008
	,-6.597357798e-008
	,-4.564590604e-008
	,-3.156356356e-008
	,-2.181093323e-008
	,-1.505853829e-008
	,-1.038433750e-008
	,-7.149205904e-009
	,-4.910314278e-009
	,-3.360945926e-009
	,-2.288719881e-009
	,-1.546611800e-009
	,-1.032862831e-009
	,-6.770566240e-010
	,-4.304741207e-010
	,-2.594138902e-010
	,-1.405661518e-010
	,-5.781078551e-011
	,1.749231402e-017
	,4.057518784e-011
	,6.924514772e-011
	,8.969488287e-011
	,1.044713539e-010
	,1.153341165e-010
	,1.234987186e-010
	,1.298043306e-010
	,1.348303114e-010
	,1.389762131e-010
	,1.425175637e-010
	,1.456439422e-010
	,1.484857165e-010
	,1.511322718e-010
	,1.536445654e-010
	,1.560639384e-010
	,1.584182311e-010
	,1.607257627e-010
	,1.629983489e-010
	,1.652432533e-010
	,1.674646337e-010
	,1.696642397e-010
	,1.718424395e-010
	,1.739984347e-010
	,1.761304968e-010
	,1.782364686e-010
	,1.803136895e-010
	,1.823593710e-010
	,1.843704994e-010
	,1.863441901e-010
	,1.882777716e-010
	,1.901688106e-010
	,1.920157233e-010
	,1.938174968e-010
	,1.955742513e-010
	,1.972871111e-010
	,1.989586533e-010
	,2.005924505e-010
	,2.021932092e-010
	,2.037660191e-010
	,2.053163776e-010
	,2.068495732e-010
	,2.083703869e-010
	,2.098830467e-010
	,2.113912351e-010
	,2.128977852e-010
	,2.144051202e-010
	,2.159150408e-010
	,2.174290455e-010
	,2.189482524e-010
	,2.204735738e-010
	,2.220056318e-010
	,2.235449766e-010
	,2.250919935e-010
	,2.266469935e-010
	,2.282102640e-010
	,2.297819797e-010
	,2.313622752e-010
	,2.329512830e-010
	,2.345491494e-010
	,2.361558437e-010
	,2.377715228e-010
	,2.393962670e-010
	,2.410300359e-010
	,2.426729007e-010
	,2.443249544e-010
	,2.459862511e-010
	,2.476566542e-010
	,2.493363186e-010
	,2.510252260e-010
	,2.527233890e-010
	,2.544308987e-010
	,2.561476885e-010
	,2.578737705e-010
	,2.596091259e-010
	,2.613538520e-010
	,2.631079185e-010
	,2.648712516e-010
	,2.666440402e-010
	,2.684261908e-010
	,2.702177548e-010
	,2.720187730e-010
	,2.738293127e-010
	,2.756493782e-010
	,2.774791242e-010
	,2.793185532e-010
	,2.811678107e-010
	,2.830270598e-010
	,2.848964687e-010
	,2.867764133e-010
	,2.886670634e-010
	,2.905689207e-010
	,2.924826185e-010
	,2.944088325e-010
	,2.963483704e-010
	,2.983026438e-010
	,3.002733748e-010
	,3.022615955e-010
	,3.042658109e-010
	,3.062920632e-010
	,3.083441467e-010
	,3.104270725e-010
	,3.125477396e-010
	,3.147150834e-010
	,3.169413861e-010
	,3.192430994e-010
	,3.216423512e-010
	,3.241695067e-010
	,3.268502223e-010
	,3.296812752e-010
	,3.327493847e-010
	,3.361253779e-010
	,3.399010170e-010
	,3.441967182e-010
	,3.491707026e-010
	,3.550309015e-010
	,3.620509438e-010
	,3.705905049e-010
	,3.811237497e-010
	,3.942747917e-010
	,4.108665799e-010
	,4.319735417e-010
	,4.590188480e-010
	,4.938958510e-010
	,5.390927718e-010
	,5.978948936e-010
	,6.746435753e-010
	,7.750778113e-010
	,9.067849608e-010
	,1.079800347e-009
	,1.307402156e-009
	,1.607165465e-009
	,2.002266678e-009
	,2.523491855e-009
	,3.211702750e-009
	,4.121010049e-009
	,5.323197565e-009
	,6.913549781e-009
	,8.970479187e-009
	,1.167763936e-008
	,1.525255454e-008
	,1.997318851e-008
	,2.620603414e-008
	,3.443375405e-008
	,4.529112025e-008
	,5.961153870e-008
	,7.848689556e-008
	,1.033440451e-007
	,1.360416873e-007
	,1.789917343e-007
	,2.353085370e-007
	,3.089916329e-007
	,4.051435904e-007
	,5.302175543e-007
	,6.922959424e-007
	,9.013843495e-007
	,1.169700843e-006
	,1.511930205e-006
	,1.945403949e-006
	,2.490160051e-006
	,3.168837888e-006
	,-6.652189010e-005
	,-5.682396154e-005
	,-4.786864848e-005
	,-3.972729421e-005
	,-3.241601053e-005
	,-2.594727519e-005
	,-2.036982684e-005
	,-1.569199998e-005
	,-1.189377034e-005
	,-8.877987337e-006
	,-6.530169085e-006
	,-4.744450616e-006
	,-3.412562403e-006
	,-2.434398108e-006
	,-1.725034034e-006
	,-1.215843839e-006
	,-8.532817259e-007
	,-5.963711580e-007
	,-4.148046240e-007
	,-2.880332927e-007
	,-1.998274311e-007
	,-1.385378461e-007
	,-9.599088882e-008
	,-6.647573212e-008
	,-4.601185625e-008
	,-3.182946639e-008
	,-2.200363522e-008
	,-1.519784666e-008
	,-1.048479380e-008
	,-7.221444324e-009
	,-4.962087306e-009
	,-3.397890948e-009
	,-2.314927590e-009
	,-1.565045304e-009
	,-1.045665333e-009
	,-6.857764896e-010
	,-4.362292195e-010
	,-2.630107905e-010
	,-1.425862702e-010
	,-5.867168802e-011
	,-1.315869486e-017
	,4.122419638e-011
	,7.039342824e-011
	,9.123728612e-011
	,1.063344007e-010
	,1.174674508e-010
	,1.258684476e-010
	,1.323886665e-010
	,1.376162387e-010
	,1.419572769e-010
	,1.456923470e-010
	,1.490148440e-010
	,1.520582193e-010
	,1.549142744e-010
	,1.576461617e-010
	,1.602970276e-010
	,1.628963282e-010
	,1.654638332e-010
	,1.680127465e-010
	,1.705516308e-010
	,1.730856466e-010
	,1.756177984e-010
	,1.781493772e-010
	,1.806805315e-010
	,1.832105677e-010
	,1.857381914e-010
	,1.882616920e-010
	,1.907789441e-010
	,1.932876948e-010
	,1.957852312e-010
	,1.982688350e-010
	,2.007354969e-010
	,2.031820511e-010
	,2.056051781e-010
	,2.080013194e-010
	,2.103670152e-010
	,2.126986477e-010
	,2.149928852e-010
	,2.172463898e-010
	,2.194561680e-010
	,2.216198596e-010
	,2.237356285e-010
	,2.258025989e-010
	,2.278209474e-010
	,2.297921376e-010
	,2.317191041e-010
	,2.336057803e-010
	,2.354572688e-010
	,2.372794218e-010
	,2.390781005e-010
	,2.408590316e-010
	,2.426275553e-010
	,2.443882633e-010
	,2.461450345e-010
	,2.479010458e-010
	,2.496588543e-010
	,2.514204334e-010
	,2.531874214e-010
	,2.549609414e-010
	,2.567420011e-010
	,2.585312434e-010
	,2.603292918e-010
	,2.621365130e-010
	,2.639533062e-010
	,2.657798855e-010
	,2.676164563e-010
	,2.694631361e-010
	,2.713201197e-010
	,2.731874364e-010
	,2.750652485e-010
	,2.769535766e-010
	,2.788524486e-010
	,2.807619800e-010
	,2.826821042e-010
	,2.846129202e-010
	,2.865545078e-010
	,2.885067514e-010
	,2.904697464e-010
	,2.924434968e-010
	,2.944280394e-010
	,2.964233529e-010
	,2.984294614e-010
	,3.004463574e-010
	,3.024740818e-010
	,3.045126444e-010
	,3.065620491e-010
	,3.086223486e-010
	,3.106935336e-010
	,3.127756034e-010
	,3.148686430e-010
	,3.169727579e-010
	,3.190879215e-010
	,3.212142462e-010
	,3.233517619e-010
	,3.255006902e-010
	,3.276610919e-010
	,3.298332528e-010
	,3.320172541e-010
	,3.342135032e-010
	,3.364223877e-010
	,3.386443969e-010
	,3.408802605e-010
	,3.431307553e-010
	,3.453970272e-010
	,3.476773541e-010
	,3.499749842e-010
	,3.522918014e-010
	,3.546297613e-010
	,3.569915634e-010
	,3.593816106e-010
	,3.618050742e-010
	,3.642689778e-010
	,3.667827695e-010
	,3.693591770e-010
	,3.720154073e-010
	,3.747463702e-010
	,3.775862078e-010
	,3.805673511e-010
	,3.837288580e-010
	,3.871219785e-010
	,3.908135517e-010
	,3.948913821e-010
	,3.994704468e-010
	,4.046906098e-010
	,4.107555823e-010
	,4.179242849e-010
	,4.265319901e-010
	,4.370275954e-010
	,4.499979519e-010
	,4.662155833e-010
	,4.866979748e-010
	,5.127856991e-010
	,5.462459672e-010
	,5.894094393e-010
	,6.453510328e-010
	,7.181302409e-010
	,8.131078112e-010
	,9.373660127e-010
	,1.100163004e-009
	,1.313925050e-009
	,1.595009548e-009
	,1.965066184e-009
	,2.452767715e-009
	,3.096116708e-009
	,3.945542132e-009
	,5.068031163e-009
	,6.511603434e-009
	,8.405861544e-009
	,1.090428834e-008
	,1.419928259e-008
	,1.854537278e-008
	,2.427799551e-008
	,3.183841329e-008
	,4.180670594e-008
	,5.494424753e-008
	,7.224817478e-008
	,9.502207232e-008
	,1.249643901e-007
	,1.642804164e-007
	,2.158210895e-007
	,2.832525975e-007
	,-6.765594639e-005
	,-5.780071161e-005
	,-4.869216738e-005
	,-4.036552633e-005
	,-3.285567367e-005
	,-2.625614418e-005
	,-2.057690339e-005
	,-1.584191461e-005
	,-1.200309330e-005
	,-8.952816354e-006
	,-6.581130276e-006
	,-4.779856077e-006
	,-3.437168263e-006
	,-2.451453658e-006
	,-1.736834975e-006
	,-1.223990135e-006
	,-8.587731876e-007
	,-5.992991863e-007
	,-4.168054948e-007
	,-2.895242735e-007
	,-2.009348892e-007
	,-1.393550744e-007
	,-9.659059138e-008
	,-6.691383488e-008
	,-4.633073553e-008
	,-3.206085424e-008
	,-2.217108276e-008
	,-1.531871585e-008
	,-1.057181768e-008
	,-7.283923270e-009
	,-5.006792401e-009
	,-3.429738912e-009
	,-2.337480647e-009
	,-1.580879917e-009
	,-1.056642255e-009
	,-6.932383336e-010
	,-4.411442946e-010
	,-2.660769455e-010
	,-1.443054716e-010
	,-5.940331998e-011
	,4.647087127e-018
	,4.177430356e-011
	,7.136531549e-011
	,9.254047089e-011
	,1.079056037e-010
	,1.192626884e-010
	,1.278576987e-010
	,1.345520000e-010
	,1.399410654e-010
	,1.444363921e-010
	,1.483223420e-010
	,1.517953883e-010
	,1.549912914e-010
	,1.580037247e-010
	,1.608972436e-010
	,1.637165357e-010
	,1.664921119e-010
	,1.692448962e-010
	,1.719891973e-010
	,1.747346924e-010
	,1.774876352e-010
	,1.802520756e-010
	,1.830303694e-010
	,1.858237961e-010
	,1.886326950e-010
	,1.914567034e-010
	,1.942951103e-010
	,1.971466867e-010
	,2.000099277e-010
	,2.028830265e-010
	,2.057641179e-010
	,2.086509530e-010
	,2.115413910e-010
	,2.144329135e-010
	,2.173231494e-010
	,2.202094643e-010
	,2.230891384e-010
	,2.259592781e-010
	,2.288169008e-010
	,2.316587710e-010
	,2.344815586e-010
	,2.372817961e-010
	,2.400556898e-010
	,2.427995972e-010
	,2.455096480e-010
	,2.481819963e-010
	,2.508130446e-010
	,2.533992846e-010
	,2.559376838e-010
	,2.584256722e-010
	,2.608613131e-010
	,2.632439399e-010
	,2.655738179e-010
	,2.678526328e-010
	,2.700836311e-010
	,2.722712407e-010
	,2.744210658e-010
	,2.765394764e-010
	,2.786329469e-010
	,2.807078475e-010
	,2.827699088e-010
	,2.848242466e-010
	,2.868750941e-010
	,2.889260506e-010
	,2.909798493e-010
	,2.930387070e-010
	,2.951042788e-010
	,2.971780130e-010
	,2.992607884e-010
	,3.013534932e-010
	,3.034566129e-010
	,3.055706891e-010
	,3.076960309e-010
	,3.098329955e-010
	,3.119815610e-010
	,3.141421962e-010
	,3.163148265e-010
	,3.184995775e-010
	,3.206966110e-010
	,3.229059306e-010
	,3.251275349e-010
	,3.273615889e-010
	,3.296079695e-010
	,3.318668576e-010
	,3.341381551e-010
	,3.364219350e-010
	,3.387182570e-010
	,3.410270374e-010
	,3.433484149e-010
	,3.456822322e-010
	,3.480286298e-010
	,3.503876253e-010
	,3.527591514e-010
	,3.551432747e-010
	,3.575399570e-010
	,3.599492355e-010
	,3.623712387e-010
	,3.648058978e-010
	,3.672533015e-010
	,3.697135739e-010
	,3.721868027e-010
	,3.746731293e-010
	,3.771727449e-010
	,3.796856161e-010
	,3.822121614e-010
	,3.847524895e-010
	,3.873069177e-010
	,3.898758327e-010
	,3.924596808e-010
	,3.950590739e-010
	,3.976736980e-010
	,4.003043771e-010
	,4.029523979e-010
	,4.056188297e-010
	,4.083050698e-010
	,4.110130321e-010
	,4.137450733e-010
	,4.165043981e-010
	,4.192951862e-010
	,4.221231194e-010
	,4.249959331e-010
	,4.279165340e-010
	,4.308902470e-010
	,4.339356389e-010
	,4.370696663e-010
	,4.403141925e-010
	,4.436978265e-010
	,4.472579729e-010
	,4.510433768e-010
	,4.551177101e-010
	,4.595643995e-010
	,4.644922335e-010
	,4.700442094e-010
	,4.764080345e-010
	,4.838297010e-010
	,4.926322849e-010
	,5.032401199e-010
	,5.161821870e-010
	,5.322035805e-010
	,5.522655614e-010
	,5.776305374e-010
	,6.099611882e-010
	,6.514340301e-010
	,7.049397320e-010
	,7.742855902e-010
	,8.644920518e-010
	,9.821880792e-010
	,1.136130124e-009
	,1.337892643e-009
	,1.602785742e-009
	,1.951076204e-009
	,2.409620895e-009
	,3.014053247e-009
	,3.811731284e-009
	,4.830637281e-009
	,6.162168767e-009
	,7.915670197e-009
	,1.022543822e-008
	,1.326855582e-008
	,1.727837203e-008
	,2.256211582e-008
	,-6.861143778e-005
	,-5.861600908e-005
	,-4.933846927e-005
	,-4.081994601e-005
	,-3.319126176e-005
	,-2.649140122e-005
	,-2.074180031e-005
	,-1.596640783e-005
	,-1.209400388e-005
	,-9.014943646e-006
	,-6.624384484e-006
	,-4.810243658e-006
	,-3.458422810e-006
	,-2.466248035e-006
	,-1.747094533e-006
	,-1.231049963e-006
	,-8.631129872e-007
	,-6.017049724e-007
	,-4.185856546e-007
	,-2.908549147e-007
	,-2.019220690e-007
	,-1.400823078e-007
	,-9.712332611e-008
	,-6.730235522e-008
	,-4.661306067e-008
	,-3.226539071e-008
	,-2.231886899e-008
	,-1.542523088e-008
	,-1.064839248e-008
	,-7.338819292e-009
	,-5.046014354e-009
	,-3.457639536e-009
	,-2.357208982e-009
	,-1.594710068e-009
	,-1.066214417e-009
	,-6.997347203e-010
	,-4.454167474e-010
	,-2.687387109e-010
	,-1.457964167e-010
	,-6.003732028e-011
	,-7.884841548e-018
	,4.225029816e-011
	,7.220561249e-011
	,9.366636474e-011
	,1.092618572e-010
	,1.208109599e-010
	,1.295716711e-010
	,1.364140397e-010
	,1.419397195e-010
	,1.465647441e-010
	,1.505767641e-010
	,1.541746016e-010
	,1.574958599e-010
	,1.606355278e-010
	,1.636593212e-010
	,1.666127285e-010
	,1.695271218e-010
	,1.724241865e-010
	,1.753188238e-010
	,1.782213264e-010
	,1.811388112e-010
	,1.840759415e-010
	,1.870359280e-010
	,1.900207974e-010
	,1.930317919e-010
	,1.960695117e-010
	,1.991342080e-010
	,2.022255767e-010
	,2.053430775e-010
	,2.084860937e-010
	,2.116535445e-010
	,2.148442167e-010
	,2.180567875e-010
	,2.212895678e-010
	,2.245408408e-010
	,2.278086551e-010
	,2.310909478e-010
	,2.343856461e-010
	,2.376905610e-010
	,2.410033174e-010
	,2.443216080e-010
	,2.476428803e-010
	,2.509647480e-010
	,2.542844883e-010
	,2.575994639e-010
	,2.609066379e-010
	,2.642030018e-010
	,2.674852280e-010
	,2.707496922e-010
	,2.739927343e-010
	,2.772104901e-010
	,2.803988944e-010
	,2.835537672e-010
	,2.866711358e-010
	,2.897468855e-010
	,2.927770700e-010
	,2.957580053e-010
	,2.986864694e-010
	,3.015596046e-010
	,3.043755706e-010
	,3.071335008e-010
	,3.098338503e-010
	,3.124784464e-010
	,3.150708432e-010
	,3.176160033e-010
	,3.201200157e-010
	,3.225899456e-010
	,3.250328617e-010
	,3.274559161e-010
	,3.298653989e-010
	,3.322671159e-010
	,3.346657427e-010
	,3.370651999e-010
	,3.394685408e-010
	,3.418783644e-010
	,3.442963459e-010
	,3.467242017e-010
	,3.491629050e-010
	,3.516132674e-010
	,3.540759938e-010
	,3.565515403e-010
	,3.590403194e-010
	,3.615426222e-010
	,3.640586863e-010
	,3.665886771e-010
	,3.691328444e-010
	,3.716912471e-010
	,3.742638886e-010
	,3.768509087e-010
	,3.794523936e-010
	,3.820683189e-010
	,3.846987608e-010
	,3.873437602e-010
	,3.900032726e-010
	,3.926773750e-010
	,3.953660876e-010
	,3.980694680e-010
	,4.007874166e-010
	,4.035201315e-010
	,4.062673985e-010
	,4.090294677e-010
	,4.118062365e-010
	,4.145978565e-010
	,4.174043307e-010
	,4.202256630e-010
	,4.230619104e-010
	,4.259132551e-010
	,4.287797186e-010
	,4.316614656e-010
	,4.345585309e-010
	,4.374710886e-010
	,4.403993336e-010
	,4.433435001e-010
	,4.463038111e-010
	,4.492805928e-010
	,4.522741582e-010
	,4.552846445e-010
	,4.583122934e-010
	,4.613579438e-010
	,4.644220775e-010
	,4.675054659e-010
	,4.706090972e-010
	,4.737341673e-010
	,4.768821777e-010
	,4.800550188e-010
	,4.832552617e-010
	,4.864861820e-010
	,4.897515858e-010
	,4.930521864e-010
	,4.963965788e-010
	,4.997924074e-010
	,5.032495068e-010
	,5.067806619e-010
	,5.104023886e-010
	,5.141357220e-010
	,5.180071767e-010
	,5.220503223e-010
	,5.263144003e-010
	,5.308604309e-010
	,5.357677330e-010
	,5.411405700e-010
	,5.471152919e-010
	,5.538701093e-010
	,5.616388642e-010
	,5.707280778e-010
	,5.815398781e-010
	,5.946022195e-010
	,6.106067927e-010
	,6.304653700e-010
	,6.553768263e-010
	,6.869178626e-010
	,7.270855951e-010
	,7.786385415e-010
	,8.451723676e-010
	,9.314165243e-010
	,1.043611865e-009
	,1.190000767e-009
	,1.381477331e-009
	,1.632416482e-009
	,1.961902661e-009
	,2.395279403e-009
	,-6.944475754e-005
	,-5.928354352e-005
	,-4.981110937e-005
	,-4.117568251e-005
	,-3.345864726e-005
	,-2.667383082e-005
	,-2.087774831e-005
	,-1.607117213e-005
	,-1.216977208e-005
	,-9.067309377e-006
	,-6.661535568e-006
	,-4.836607255e-006
	,-3.476987418e-006
	,-2.479231074e-006
	,-1.756117394e-006
	,-1.237178700e-006
	,-8.662977135e-007
	,-6.038442726e-007
	,-4.201946570e-007
	,-2.920580993e-007
	,-2.028137415e-007
	,-1.407383140e-007
	,-9.760321907e-008
	,-6.765184966e-008
	,-4.686667120e-008
	,-3.244886605e-008
	,-2.245125043e-008
	,-1.552050727e-008
	,-1.071678892e-008
	,-7.387780609e-009
	,-5.080943833e-009
	,-3.482448713e-009
	,-2.374723650e-009
	,-1.606968069e-009
	,-1.074683888e-009
	,-7.054729147e-010
	,-4.491846757e-010
	,-2.710830799e-010
	,-1.471081746e-010
	,-6.059457212e-011
	,2.339276377e-017
	,4.266799555e-011
	,7.294236917e-011
	,9.465282208e-011
	,1.104493997e-010
	,1.221658591e-010
	,1.310708522e-010
	,1.380419793e-010
	,1.436864206e-010
	,1.484240697e-010
	,1.525453499e-010
	,1.562512466e-010
	,1.596807642e-010
	,1.629299259e-010
	,1.660653887e-010
	,1.691331565e-010
	,1.721651856e-010
	,1.751835369e-010
	,1.782035393e-010
	,1.812359396e-010
	,1.842880557e-010
	,1.873650922e-010
	,1.904707241e-010
	,1.936073887e-010
	,1.967768263e-010
	,1.999802288e-010
	,2.032184051e-010
	,2.064917610e-010
	,2.098005356e-010
	,2.131447949e-010
	,2.165243365e-010
	,2.199388483e-010
	,2.233879382e-010
	,2.268708108e-010
	,2.303868358e-010
	,2.339351144e-010
	,2.375146544e-010
	,2.411242734e-010
	,2.447625494e-010
	,2.484279626e-010
	,2.521186873e-010
	,2.558330168e-010
	,2.595688240e-010
	,2.633240894e-010
	,2.670965295e-010
	,2.708839400e-010
	,2.746839242e-010
	,2.784942359e-010
	,2.823123784e-010
	,2.861360314e-010
	,2.899626723e-010
	,2.937895963e-010
	,2.976140418e-010
	,3.014330374e-010
	,3.052432434e-010
	,3.090413509e-010
	,3.128234673e-010
	,3.165857031e-010
	,3.203239042e-010
	,3.240337919e-010
	,3.277110252e-010
	,3.313511772e-010
	,3.349498276e-010
	,3.385025321e-010
	,3.420051390e-010
	,3.454535327e-010
	,3.488440519e-010
	,3.521737400e-010
	,3.554405319e-010
	,3.586435307e-010
	,3.617832034e-010
	,3.648616647e-010
	,3.678827831e-010
	,3.708519058e-010
	,3.737758934e-010
	,3.766622989e-010
	,3.795191208e-010
	,3.823543202e-010
	,3.851750701e-010
	,3.879875527e-010
	,3.907973311e-010
	,3.936087204e-010
	,3.964253399e-010
	,3.992497843e-010
	,4.020843989e-010
	,4.049307023e-010
	,4.077900458e-010
	,4.106633488e-010
	,4.135512885e-010
	,4.164545542e-010
	,4.193734573e-010
	,4.223083391e-010
	,4.252594948e-010
	,4.282270863e-010
	,4.312111893e-010
	,4.342119984e-010
	,4.372295391e-010
	,4.402639374e-010
	,4.433152149e-010
	,4.463833871e-010
	,4.494685403e-010
	,4.525706642e-010
	,4.556897796e-010
	,4.588260065e-010
	,4.619792809e-010
	,4.651496947e-010
	,4.683371847e-010
	,4.715418710e-010
	,4.747637881e-010
	,4.780029146e-010
	,4.812594429e-010
	,4.845332429e-010
	,4.878245360e-010
	,4.911333039e-010
	,4.944597135e-010
	,4.978038940e-010
	,5.011659063e-010
	,5.045459877e-010
	,5.079443215e-010
	,5.113611621e-010
	,5.147965921e-010
	,5.182511594e-010
	,5.217248613e-010
	,5.252179812e-010
	,5.287310195e-010
	,5.322643155e-010
	,5.358185103e-010
	,5.393941102e-010
	,5.429918513e-010
	,5.466125082e-010
	,5.502571415e-010
	,5.539270924e-010
	,5.576239242e-010
	,5.613495489e-010
	,5.651050369e-010
	,5.688935389e-010
	,5.727189430e-010
	,5.765858104e-010
	,5.804998347e-010
	,5.844684316e-010
	,5.885012912e-010
	,5.926105876e-010
	,5.968122878e-010
	,6.011271710e-010
	,6.055820579e-010
	,6.102117603e-010
	,6.150611683e-010
	,6.201900751e-010
	,6.256755564e-010
	,6.316154412e-010
	,6.381314243e-010
	,6.454020437e-010
	,6.536501961e-010
	,6.631682516e-010
	,6.743390939e-010
	,6.876644630e-010
	,7.038036065e-010
	,7.236216329e-010
	,7.482550782e-010
	,7.791984123e-010
	,8.184173710e-010
	,-7.016125392e-005
	,-5.979657546e-005
	,-5.019972700e-005
	,-4.148136857e-005
	,-3.368061033e-005
	,-2.682807607e-005
	,-2.099759437e-005
	,-1.616353678e-005
	,-1.223538915e-005
	,-9.113316252e-006
	,-6.694481628e-006
	,-4.860081063e-006
	,-3.493558955e-006
	,-2.490837668e-006
	,-1.764170094e-006
	,-1.242366120e-006
	,-8.689373585e-007
	,-6.057951323e-007
	,-4.216673668e-007
	,-2.931585451e-007
	,-2.036283056e-007
	,-1.413368671e-007
	,-9.804056927e-008
	,-6.796999796e-008
	,-4.709727715e-008
	,-3.261551350e-008
	,-2.257135637e-008
	,-1.560685125e-008
	,-1.077870161e-008
	,-7.432047806e-009
	,-5.112485119e-009
	,-3.504821900e-009
	,-2.390496266e-009
	,-1.617990131e-009
	,-1.082287190e-009
	,-7.106159843e-010
	,-4.525567492e-010
	,-2.731783666e-010
	,-1.482791148e-010
	,-6.109145918e-011
	,-1.749265353e-017
	,4.303951256e-011
	,7.359695483e-011
	,9.552822153e-011
	,1.115021150e-010
	,1.233657187e-010
	,1.323972988e-010
	,1.394813380e-010
	,1.452297843e-010
	,1.500661018e-010
	,1.542833513e-010
	,1.580841263e-010
	,1.616088023e-010
	,1.649545178e-010
	,1.681883167e-010
	,1.713569312e-010
	,1.744925650e-010
	,1.776176118e-010
	,1.807476830e-010
	,1.838935861e-010
	,1.870629483e-010
	,1.902611406e-010
	,1.934920255e-010
	,1.967582787e-010
	,2.000619389e-010
	,2.034044056e-010
	,2.067867621e-010
	,2.102099260e-010
	,2.136744706e-010
	,2.171808654e-010
	,2.207295105e-010
	,2.243204940e-010
	,2.279540939e-010
	,2.316303179e-010
	,2.353491883e-010
	,2.391107382e-010
	,2.429146896e-010
	,2.467606981e-010
	,2.506483626e-010
	,2.545771396e-010
	,2.585462487e-010
	,2.625549040e-010
	,2.666021502e-010
	,2.706867170e-010
	,2.748073778e-010
	,2.789626515e-010
	,2.831508220e-010
	,2.873700502e-010
	,2.916184960e-010
	,2.958940335e-010
	,3.001944515e-010
	,3.045175343e-010
	,3.088609702e-010
	,3.132224881e-010
	,3.175996967e-010
	,3.219904162e-010
	,3.263922124e-010
	,3.308026760e-010
	,3.352192900e-010
	,3.396393862e-010
	,3.440598386e-010
	,3.484775679e-010
	,3.528890522e-010
	,3.572907747e-010
	,3.616787812e-010
	,3.660489597e-010
	,3.703969026e-010
	,3.747181151e-010
	,3.790080658e-010
	,3.832618879e-010
	,3.874749892e-010
	,3.916426228e-010
	,3.957599081e-010
	,3.998221872e-010
	,4.038250954e-010
	,4.077645498e-010
	,4.116372118e-010
	,4.154408206e-010
	,4.191742234e-010
	,4.228377656e-010
	,4.264336502e-010
	,4.299659812e-010
	,4.334406493e-010
	,4.368651121e-010
	,4.402477093e-010
	,4.435974305e-010
	,4.469231213e-010
	,4.502328460e-010
	,4.535338001e-010
	,4.568321286e-010
	,4.601328653e-010
	,4.634399544e-010
	,4.667566418e-010
	,4.700853981e-010
	,4.734281104e-010
	,4.767861976e-010
	,4.801607236e-010
	,4.835526064e-010
	,4.869623369e-010
	,4.903905263e-010
	,4.938373998e-010
	,4.973032674e-010
	,5.007883310e-010
	,5.042927820e-010
	,5.078167404e-010
	,5.113603357e-010
	,5.149235926e-010
	,5.185065793e-010
	,5.221094942e-010
	,5.257322465e-010
	,5.293748937e-010
	,5.330375449e-010
	,5.367202471e-010
	,5.404229384e-010
	,5.441458291e-010
	,5.478888244e-010
	,5.516521664e-010
	,5.554357512e-010
	,5.592397795e-010
	,5.630642672e-010
	,5.669094714e-010
	,5.707753773e-010
	,5.746621899e-010
	,5.785700783e-010
	,5.824991810e-010
	,5.864497373e-010
	,5.904219760e-010
	,5.944161192e-010
	,5.984325228e-010
	,6.024712548e-010
	,6.065327682e-010
	,6.106174724e-010
	,6.147256735e-010
	,6.188579178e-010
	,6.230146390e-010
	,6.271963880e-010
	,6.314039212e-010
	,6.356379826e-010
	,6.398994661e-010
	,6.441895013e-010
	,6.485091866e-010
	,6.528597659e-010
	,6.572431573e-010
	,6.616617908e-010
	,6.661185375e-010
	,6.706168977e-010
	,6.751614240e-010
	,6.797572898e-010
	,6.844118683e-010
	,6.891347670e-010
	,6.939378154e-010
	,6.988365076e-010
	,7.038509112e-010
	,7.090069074e-010
	,7.143382433e-010
	,7.198887325e-010
	,7.257152208e-010
	,7.318922487e-010
	,7.385157054e-010
	,7.457126321e-010
	,7.536482165e-010
	,-7.073154603e-005
	,-6.022794332e-005
	,-5.054756522e-005
	,-4.175380854e-005
	,-3.387074867e-005
	,-2.696765967e-005
	,-2.110808014e-005
	,-1.624769491e-005
	,-1.229440764e-005
	,-9.155221510e-006
	,-6.724578177e-006
	,-4.881518192e-006
	,-3.508677998e-006
	,-2.501409072e-006
	,-1.771446345e-006
	,-1.246418227e-006
	,-8.713244460e-007
	,-6.076017154e-007
	,-4.230303967e-007
	,-2.941752727e-007
	,-2.043797036e-007
	,-1.418882478e-007
	,-9.844296887e-008
	,-6.826240729e-008
	,-4.730901675e-008
	,-3.276838404e-008
	,-2.268143346e-008
	,-1.568591509e-008
	,-1.083534315e-008
	,-7.472508815e-009
	,-5.141286707e-009
	,-3.525230750e-009
	,-2.404867950e-009
	,-1.628021025e-009
	,-1.089197848e-009
	,-7.152844857e-010
	,-4.556141528e-010
	,-2.750761667e-010
	,-1.493386500e-010
	,-6.154054731e-011
	,-1.206215111e-017
	,4.337452668e-011
	,7.418647372e-011
	,9.631560590e-011
	,1.124478034e-010
	,1.244422814e-010
	,1.335860099e-010
	,1.407696423e-010
	,1.466097256e-010
	,1.515328569e-010
	,1.558343437e-010
	,1.597186040e-010
	,1.633271433e-010
	,1.667578781e-010
	,1.700787176e-010
	,1.733366601e-010
	,1.765642836e-010
	,1.797842972e-010
	,1.830124022e-010
	,1.862596889e-010
	,1.895338232e-010
	,1.928402263e-010
	,1.961829078e-010
	,1.995645815e-010
	,2.029874328e-010
	,2.064529393e-010
	,2.099623857e-010
	,2.135167794e-010
	,2.171168733e-010
	,2.207633629e-010
	,2.244568814e-010
	,2.281978290e-010
	,2.319869053e-010
	,2.358245193e-010
	,2.397111093e-010
	,2.436470779e-010
	,2.476326684e-010
	,2.516681747e-010
	,2.557537389e-010
	,2.598894857e-010
	,2.640754398e-010
	,2.683115510e-010
	,2.725976828e-010
	,2.769336087e-010
	,2.813189752e-010
	,2.857532701e-010
	,2.902359501e-010
	,2.947661723e-010
	,2.993431197e-010
	,3.039656734e-010
	,3.086326410e-010
	,3.133425722e-010
	,3.180938770e-010
	,3.228848217e-010
	,3.277134762e-010
	,3.325777565e-010
	,3.374754819e-010
	,3.424041996e-010
	,3.473615861e-010
	,3.523452766e-010
	,3.573532963e-010
	,3.623833940e-010
	,3.674334658e-010
	,3.725012206e-010
	,3.775844582e-010
	,3.826808098e-010
	,3.877877442e-010
	,3.929024635e-010
	,3.980219464e-010
	,4.031427911e-010
	,4.082612774e-010
	,4.133734202e-010
	,4.184748463e-010
	,4.235611238e-010
	,4.286274587e-010
	,4.336691425e-010
	,4.386812598e-010
	,4.436588679e-010
	,4.485969629e-010
	,4.534904036e-010
	,4.583338459e-010
	,4.631221399e-010
	,4.678498736e-010
	,4.725122471e-010
	,4.771047084e-010
	,4.816235399e-010
	,4.860659015e-010
	,4.904304879e-010
	,4.947174593e-010
	,4.989291814e-010
	,5.030699250e-010
	,5.071459909e-010
	,5.111656462e-010
	,5.151382211e-010
	,5.190737898e-010
	,5.229821700e-010
	,5.268726556e-010
	,5.307534020e-010
	,5.346314953e-010
	,5.385127065e-010
	,5.424016879e-010
	,5.463020890e-010
	,5.502168508e-010
	,5.541481199e-010
	,5.580975975e-010
	,5.620664975e-010
	,5.660558250e-010
	,5.700662827e-010
	,5.740984833e-010
	,5.781527087e-010
	,5.822293215e-010
	,5.863286140e-010
	,5.904507300e-010
	,5.945958423e-010
	,5.987640036e-010
	,6.029553650e-010
	,6.071700162e-010
	,6.114079360e-010
	,6.156693478e-010
	,6.199541141e-010
	,6.242624830e-010
	,6.285944759e-010
	,6.329501333e-010
	,6.373296210e-010
	,6.417329430e-010
	,6.461602889e-010
	,6.506117869e-010
	,6.550875168e-010
	,6.595876751e-010
	,6.641124989e-010
	,6.686621169e-010
	,6.732367774e-010
	,6.778366213e-010
	,6.824620590e-010
	,6.871133303e-010
	,6.917906761e-010
	,6.964944579e-010
	,7.012250167e-010
	,7.059827270e-010
	,7.107680780e-010
	,7.155814936e-010
	,7.204234093e-010
	,7.252943269e-010
	,7.301950046e-010
	,7.351260276e-010
	,7.400880589e-010
	,7.450819904e-010
	,7.501085370e-010
	,7.551690629e-010
	,7.602645467e-010
	,7.653968186e-010
	,7.705674100e-010
	,7.757788423e-010
	,7.810337361e-010
	,7.863355851e-010
	,7.916890130e-010
	,7.970994004e-010
	,8.025740798e-010
	,8.081221784e-010
	,8.137556860e-010
	,8.194899597e-010
	,-5.792733177e-008
	,-4.377936015e-008
	,-3.295117798e-008
	,-2.474907172e-008
	,-1.858099742e-008
	,-1.395946080e-008
	,-1.049900217e-008
	,-7.905487720e-009
	,-5.957838130e-009
	,-4.491552512e-009
	,-3.386394947e-009
	,-2.553761988e-009
	,-1.926514756e-009
	,-1.453656276e-009
	,-1.096808220e-009
	,-8.272444045e-010
	,-6.233808253e-010
	,-4.691459382e-010
	,-3.526406770e-010
	,-2.648005955e-010
	,-1.986020859e-010
	,-1.487041993e-010
	,-1.111353107e-010
	,-8.300666386e-011
	,-6.204551031e-011
	,-4.646046383e-011
	,-3.487131231e-011
	,-2.623482970e-011
	,-1.978825332e-011
	,-1.496994188e-011
	,-1.136099654e-011
	,-8.644256530e-012
	,-6.593873321e-012
	,-5.032521372e-012
	,-3.831585081e-012
	,-2.893637004e-012
	,-2.145073522e-012
	,-1.526474861e-012
	,-9.898037878e-013
	,-4.936551237e-013
	,-6.944946879e-018
	,5.288548046e-013
	,1.134207113e-012
	,1.866005642e-012
	,2.787287297e-012
	,3.980306543e-012
	,5.554876596e-012
	,7.659579450e-012
	,1.049762602e-011
	,1.431026883e-011
	,1.946340239e-011
	,2.639034874e-011
	,3.579165375e-011
	,4.858976018e-011
	,6.582458431e-011
	,8.908735141e-011
	,1.206825677e-010
	,1.637059041e-010
	,2.223304389e-010
	,3.022894556e-010
	,4.114466568e-010
	,5.605517200e-010
	,7.643249607e-010
	,1.042915564e-009
	,1.423855257e-009
	,1.944708866e-009
	,2.656606761e-009
	,3.628932572e-009
	,4.955440086e-009
	,6.762293772e-009
	,9.218276001e-009
	,1.254790642e-008
	,1.704810537e-008
	,2.310919216e-008
	,3.124135749e-008
	,4.211343714e-008
	,5.653122399e-008
	,7.558400770e-008
	,1.005098681e-007
	,1.329846462e-007
	,1.753138069e-007
	,2.302897884e-007
	,3.014438808e-007
	,3.932278033e-007
	,5.110840900e-007
	,6.594051551e-007
	,8.404285765e-007
	,1.062750982e-006
	,1.325357729e-006
	,1.644560989e-006
	,2.032717552e-006
	,2.504990621e-006
	,3.076953712e-006
	,3.766002475e-006
	,4.591181071e-006
	,5.575356701e-006
	,6.742842810e-006
	,8.120183931e-006
	,9.736114958e-006
	,1.162151255e-005
	,1.378023419e-005
	,1.617581929e-005
	,1.889476359e-005
	,2.196270194e-005
	,2.540267882e-005
	,2.923963928e-005
	,3.324994367e-005
	,3.737430204e-005
	,4.145362662e-005
	,4.574957040e-005
	,5.042329995e-005
	,5.548235431e-005
	,6.088298991e-005
	,6.666290352e-005
	,7.283093086e-005
	,7.932742020e-005
	,8.618679824e-005
	,9.346285623e-005
	,1.011196522e-004
	,1.088666877e-004
	,1.170119024e-004
	,1.255682002e-004
	,1.345004953e-004
	,1.437581044e-004
	,1.533702960e-004
	,1.624493115e-004
	,1.719161607e-004
	,1.817783078e-004
	,1.920457543e-004
	,2.027305719e-004
	,2.138199875e-004
	,2.247353066e-004
	,2.355663581e-004
	,2.468613174e-004
	,2.586669339e-004
	,2.700981894e-004
	,2.816366989e-004
	,2.935995651e-004
	,3.059968774e-004
	,3.188425316e-004
	,3.321537046e-004
	,3.459531132e-004
	,3.588796857e-004
	,3.715749074e-004
	,3.845416418e-004
	,3.983264585e-004
	,4.111741371e-004
	,4.239537982e-004
	,4.373799466e-004
	,4.513211269e-004
	,4.654109130e-004
	,4.799488555e-004
	,4.927408455e-004
	,5.047759165e-004
	,5.172212151e-004
	,5.299961869e-004
	,5.429125315e-004
	,5.559695456e-004
	,5.692880526e-004
	,5.809504050e-004
	,5.924259064e-004
	,6.042482711e-004
	,6.163502395e-004
	,6.287384927e-004
	,6.413897371e-004
	,6.542962321e-004
	,6.674704148e-004
	,6.808636381e-004
	,6.943823872e-004
	,7.080165226e-004
	,7.218392216e-004
	,7.358444148e-004
	,7.500192890e-004
	,7.643633467e-004
	,7.788937431e-004
	,7.936222268e-004
	,8.085440435e-004
	,8.236285672e-004
	,8.388725896e-004
	,8.542726685e-004
	,8.698274955e-004
	,8.855378910e-004
	,9.014196831e-004
	,9.174552567e-004
	,9.335851224e-004
	,9.498506367e-004
	,9.662619193e-004
	,9.828584648e-004
	,9.995964135e-004
	,1.016471413e-003
	,1.033482262e-003
	,1.050054036e-003
	,1.066000983e-003
	,1.082107293e-003
	,1.098336652e-003
	,1.114685488e-003
	,1.131153964e-003
	,1.147741058e-003
	,1.164445703e-003
	,1.181266972e-003
	,1.198197312e-003
	,-1.873278428e-007
	,-1.427213486e-007
	,-1.087542638e-007
	,-8.287821414e-008
	,-6.311307667e-008
	,-4.798685410e-008
	,-3.642689433e-008
	,-2.761212684e-008
	,-2.089232169e-008
	,-1.575812153e-008
	,-1.183180238e-008
	,-8.841606037e-009
	,-6.581455031e-009
	,-4.887164856e-009
	,-3.625423542e-009
	,-2.689557463e-009
	,-1.996642143e-009
	,-1.483668873e-009
	,-1.103589113e-009
	,-8.215795057e-010
	,-6.119728232e-010
	,-4.559624294e-010
	,-3.398130705e-010
	,-2.533660445e-010
	,-1.890152414e-010
	,-1.410717679e-010
	,-1.053068008e-010
	,-7.859259980e-011
	,-5.861462023e-011
	,-4.365086918e-011
	,-3.242336227e-011
	,-2.399137813e-011
	,-1.765847434e-011
	,-1.289959546e-011
	,-9.315903211e-012
	,-6.606703823e-012
	,-4.546385719e-012
	,-2.966828324e-012
	,-1.742994110e-012
	,-7.791706813e-013
	,5.534918191e-017
	,6.555940111e-013
	,1.238329739e-012
	,1.789402922e-012
	,2.349005597e-012
	,2.954457743e-012
	,3.649720948e-012
	,4.484979164e-012
	,5.525252892e-012
	,6.853292182e-012
	,8.579550005e-012
	,1.085337599e-011
	,1.387636584e-011
	,1.792337707e-011
	,2.337047219e-011
	,3.073327170e-011
	,4.072016335e-011
	,5.430585831e-011
	,7.283111937e-011
	,9.812678263e-011
	,1.325801027e-010
	,1.797418222e-010
	,2.442827668e-010
	,3.324600139e-010
	,4.534414903e-010
	,6.196036969e-010
	,8.480322288e-010
	,1.162309045e-009
	,1.594730891e-009
	,2.190350587e-009
	,3.011156098e-009
	,4.142665556e-009
	,5.702744475e-009
	,7.853601186e-009
	,1.081797808e-008
	,1.490088714e-008
	,2.037889679e-008
	,2.781677313e-008
	,3.791870692e-008
	,5.159269083e-008
	,6.980110068e-008
	,9.373893151e-008
	,1.253844673e-007
	,1.670107828e-007
	,2.214772333e-007
	,2.923213921e-007
	,3.839378016e-007
	,5.017279089e-007
	,6.522922053e-007
	,8.436342861e-007
	,1.085289229e-006
	,1.388721632e-006
	,1.767478445e-006
	,2.237337079e-006
	,2.816521993e-006
	,3.525855031e-006
	,4.388868386e-006
	,5.424446554e-006
	,6.627359291e-006
	,8.045309438e-006
	,9.705942407e-006
	,1.163644026e-005
	,1.386309520e-005
	,1.639888055e-005
	,1.904630722e-005
	,2.191762353e-005
	,2.483353333e-005
	,2.805535791e-005
	,3.159956857e-005
	,3.546880731e-005
	,3.968635164e-005
	,4.426471810e-005
	,4.921632107e-005
	,5.452392186e-005
	,6.022504294e-005
	,6.633213909e-005
	,7.283638224e-005
	,7.960519447e-005
	,8.661532157e-005
	,9.392233834e-005
	,1.015544568e-004
	,1.095676431e-004
	,1.178996429e-004
	,1.262612805e-004
	,1.346188151e-004
	,1.433301409e-004
	,1.524028788e-004
	,1.618463095e-004
	,1.716653512e-004
	,1.809258141e-004
	,1.906455453e-004
	,2.008364551e-004
	,2.114506792e-004
	,2.224623022e-004
	,2.335830103e-004
	,2.444459500e-004
	,2.556866362e-004
	,2.672077838e-004
	,2.788269817e-004
	,2.908972291e-004
	,3.034299490e-004
	,3.146148482e-004
	,3.262466195e-004
	,3.383605278e-004
	,3.511147222e-004
	,3.645583859e-004
	,3.773501671e-004
	,3.901001179e-004
	,4.034048929e-004
	,4.172795409e-004
	,4.316236345e-004
	,4.448891668e-004
	,4.569339423e-004
	,4.693959768e-004
	,4.821286766e-004
	,4.947389013e-004
	,5.054264206e-004
	,5.165452749e-004
	,5.280275134e-004
	,5.397206619e-004
	,5.517061981e-004
	,5.639670363e-004
	,5.764821293e-004
	,5.892300667e-004
	,6.021663292e-004
	,6.152973835e-004
	,6.286285437e-004
	,6.421803515e-004
	,6.559300716e-004
	,6.697789764e-004
	,6.836588799e-004
	,6.977059162e-004
	,7.119163685e-004
	,7.262853900e-004
	,7.408012997e-004
	,7.554734514e-004
	,7.703227720e-004
	,7.853614881e-004
	,8.005585558e-004
	,8.159053339e-004
	,8.314002471e-004
	,8.470418790e-004
	,8.628278469e-004
	,8.787663834e-004
	,8.948147728e-004
	,9.098056275e-004
	,9.248772387e-004
	,9.400743139e-004
	,9.554165887e-004
	,9.709147956e-004
	,9.865312198e-004
	,1.002264290e-003
	,1.018112534e-003
	,1.034074605e-003
	,1.050187903e-003
	,1.066443539e-003
	,1.082813669e-003
	,1.099297455e-003
	,1.115892120e-003
	,1.132598860e-003
	,1.149417187e-003
	,-6.649823360e-007
	,-5.097658558e-007
	,-3.887885408e-007
	,-2.950630073e-007
	,-2.229751300e-007
	,-1.681513685e-007
	,-1.267442467e-007
	,-9.551442986e-008
	,-7.197635611e-008
	,-5.426180206e-008
	,-4.092855929e-008
	,-3.087961311e-008
	,-2.330029575e-008
	,-1.757780590e-008
	,-1.324722186e-008
	,-9.969288596e-009
	,-7.493173280e-009
	,-5.622247720e-009
	,-4.208591038e-009
	,-3.143067632e-009
	,-2.341140889e-009
	,-1.738668185e-009
	,-1.287301414e-009
	,-9.500314065e-010
	,-6.988069879e-010
	,-5.126195937e-010
	,-3.754030670e-010
	,-2.746732482e-010
	,-2.008601483e-010
	,-1.467810177e-010
	,-1.071253791e-010
	,-7.799819993e-011
	,-5.655496480e-011
	,-4.072395499e-011
	,-2.899848392e-011
	,-2.028109914e-011
	,-1.376794894e-011
	,-8.866165135e-012
	,-5.138468438e-012
	,-2.262384228e-012
	,1.461888603e-018
	,1.825518270e-012
	,3.346329378e-012
	,4.662353367e-012
	,5.849641448e-012
	,6.967211382e-012
	,8.062694156e-012
	,9.175543260e-012
	,1.034628742e-011
	,1.161794243e-011
	,1.303799647e-011
	,1.466197871e-011
	,1.654737511e-011
	,1.878480999e-011
	,2.147840400e-011
	,2.476801888e-011
	,2.885388024e-011
	,3.399065634e-011
	,4.058504206e-011
	,4.910387759e-011
	,6.021732175e-011
	,7.493961961e-011
	,9.458743398e-011
	,1.209652965e-010
	,1.565341028e-010
	,2.044956935e-010
	,2.695152929e-010
	,3.578366647e-010
	,4.781183252e-010
	,6.422156027e-010
	,8.664333166e-010
	,1.173208811e-009
	,1.593435795e-009
	,2.169668787e-009
	,2.959124391e-009
	,4.041424261e-009
	,5.527492071e-009
	,7.568930249e-009
	,1.037418602e-008
	,1.422956452e-008
	,1.952769086e-008
	,2.680578393e-008
	,3.679639297e-008
	,5.049416567e-008
	,6.924411636e-008
	,9.485013138e-008
	,1.297118767e-007
	,1.769893667e-007
	,2.407960448e-007
	,3.264192499e-007
	,4.398428918e-007
	,5.881338841e-007
	,7.816543706e-007
	,1.031946729e-006
	,1.352668577e-006
	,1.759737078e-006
	,2.271307954e-006
	,2.907650655e-006
	,3.691733808e-006
	,4.629898200e-006
	,5.703344553e-006
	,6.954408609e-006
	,8.340104314e-006
	,9.930428481e-006
	,1.174519385e-005
	,1.380606385e-005
	,1.613058728e-005
	,1.873567147e-005
	,2.163733568e-005
	,2.484913250e-005
	,2.838685325e-005
	,3.226529504e-005
	,3.649824225e-005
	,4.109909704e-005
	,4.607035862e-005
	,5.137778660e-005
	,5.697092828e-005
	,6.292822858e-005
	,6.924390040e-005
	,7.594357678e-005
	,8.298786056e-005
	,9.015887390e-005
	,9.740986998e-005
	,1.049185414e-004
	,1.127096161e-004
	,1.208346570e-004
	,1.285637630e-004
	,1.366436374e-004
	,1.451008124e-004
	,1.539479306e-004
	,1.631590670e-004
	,1.724226758e-004
	,1.819579295e-004
	,1.919716764e-004
	,2.017942021e-004
	,2.119808390e-004
	,2.225099675e-004
	,2.332896674e-004
	,2.444671791e-004
	,2.553030189e-004
	,2.659328700e-004
	,2.769960723e-004
	,2.885130153e-004
	,3.005126302e-004
	,3.130299990e-004
	,3.261155744e-004
	,3.390052487e-004
	,3.516813319e-004
	,3.648193453e-004
	,3.784341958e-004
	,3.917055359e-004
	,4.040394544e-004
	,4.156305185e-004
	,4.264369244e-004
	,4.373897483e-004
	,4.486782605e-004
	,4.602899921e-004
	,4.720543461e-004
	,4.840147186e-004
	,4.962241395e-004
	,5.086648474e-004
	,5.212660916e-004
	,5.340279349e-004
	,5.469973636e-004
	,5.601600476e-004
	,5.735095520e-004
	,5.870170227e-004
	,6.006787941e-004
	,6.145154318e-004
	,6.285473005e-004
	,6.425612265e-004
	,6.565961869e-004
	,6.707922640e-004
	,6.851393451e-004
	,6.996344717e-004
	,7.142646705e-004
	,7.290401084e-004
	,7.439664478e-004
	,7.580398746e-004
	,7.721966769e-004
	,7.864927313e-004
	,8.009195423e-004
	,8.154747324e-004
	,8.301562343e-004
	,8.449622387e-004
	,8.598967201e-004
	,8.749653348e-004
	,8.901570800e-004
	,9.054222782e-004
	,9.207962666e-004
	,9.363125131e-004
	,9.519640203e-004
	,9.677262485e-004
	,9.835983130e-004
	,9.995793145e-004
	,1.015669231e-003
	,1.031897827e-003
	,1.048266616e-003
	,1.064745304e-003
	,1.081333361e-003
	,1.098030321e-003
	,-2.341684853e-006
	,-1.822108732e-006
	,-1.414167517e-006
	,-1.094880083e-006
	,-8.457744523e-007
	,-6.514170599e-007
	,-4.997638532e-007
	,-3.814360282e-007
	,-2.895673360e-007
	,-2.187153288e-007
	,-1.643818439e-007
	,-1.229842306e-007
	,-9.173389964e-008
	,-6.833853852e-008
	,-5.090519768e-008
	,-3.793160661e-008
	,-2.827341186e-008
	,-2.108387187e-008
	,-1.573540002e-008
	,-1.175361127e-008
	,-8.782136080e-009
	,-6.558455152e-009
	,-4.886157563e-009
	,-3.629338289e-009
	,-2.689853762e-009
	,-1.991858773e-009
	,-1.474427503e-009
	,-1.090821721e-009
	,-8.062100886e-010
	,-5.948253656e-010
	,-4.376003495e-010
	,-3.204697056e-010
	,-2.331242389e-010
	,-1.679835838e-010
	,-1.193921798e-010
	,-8.310330576e-011
	,-5.595012850e-011
	,-3.559169607e-011
	,-2.029760249e-011
	,-8.766540271e-012
	,3.247841207e-017
	,6.768568511e-012
	,1.211832934e-011
	,1.647981898e-011
	,2.016972278e-011
	,2.341997701e-011
	,2.640074580e-011
	,2.923742801e-011
	,3.202477864e-011
	,3.483802348e-011
	,3.773937159e-011
	,4.078474346e-011
	,4.402604327e-011
	,4.751305415e-011
	,5.129905428e-011
	,5.544630377e-011
	,6.002824800e-011
	,6.513526923e-011
	,7.088064367e-011
	,7.741026418e-011
	,8.490862052e-011
	,9.361687605e-011
	,1.038948393e-010
	,1.162169315e-010
	,1.311985809e-010
	,1.495633091e-010
	,1.726249376e-010
	,2.018000327e-010
	,2.393887912e-010
	,2.884431630e-010
	,3.532256541e-010
	,4.392591248e-010
	,5.545559147e-010
	,7.102403271e-010
	,9.214593606e-010
	,1.209154339e-009
	,1.602212052e-009
	,2.140614556e-009
	,2.879661243e-009
	,3.895901964e-009
	,5.285688879e-009
	,7.143891878e-009
	,9.681176833e-009
	,1.314789094e-008
	,1.788570912e-008
	,2.430641411e-008
	,3.300266258e-008
	,4.483649223e-008
	,6.092792245e-008
	,8.276591370e-008
	,1.123556248e-007
	,1.523008056e-007
	,2.061413457e-007
	,2.784337416e-007
	,3.750341462e-007
	,5.033486239e-007
	,6.725667424e-007
	,8.938451708e-007
	,1.180405785e-006
	,1.547519475e-006
	,2.012362163e-006
	,2.593746559e-006
	,3.311752055e-006
	,4.187324957e-006
	,5.241810535e-006
	,6.496534582e-006
	,7.971477911e-006
	,9.687422381e-006
	,1.166363073e-005
	,1.391843654e-005
	,1.646909063e-005
	,1.933183546e-005
	,2.248117425e-005
	,2.594798674e-005
	,2.974942965e-005
	,3.389491227e-005
	,3.839032420e-005
	,4.324503580e-005
	,4.832656349e-005
	,5.362586232e-005
	,5.925932877e-005
	,6.509644028e-005
	,7.095281850e-005
	,7.712282517e-005
	,8.334327265e-005
	,8.985609693e-005
	,9.670854295e-005
	,1.038372939e-004
	,1.112968300e-004
	,1.190907286e-004
	,1.272586784e-004
	,1.358015043e-004
	,1.447376396e-004
	,1.537547384e-004
	,1.630630663e-004
	,1.727265177e-004
	,1.827535543e-004
	,1.929258270e-004
	,2.028474830e-004
	,2.131124267e-004
	,2.234996978e-004
	,2.342141870e-004
	,2.453036607e-004
	,2.567940460e-004
	,2.687162501e-004
	,2.811056394e-004
	,2.939078157e-004
	,3.062202294e-004
	,3.183424186e-004
	,3.298503814e-004
	,3.403029505e-004
	,3.511678915e-004
	,3.623681317e-004
	,3.738618309e-004
	,3.855828120e-004
	,3.975243345e-004
	,4.096659918e-004
	,4.218729715e-004
	,4.342959517e-004
	,4.469262283e-004
	,4.596024594e-004
	,4.724649964e-004
	,4.855138054e-004
	,4.987366174e-004
	,5.120488129e-004
	,5.255412887e-004
	,5.392042146e-004
	,5.530330133e-004
	,5.670018397e-004
	,5.811103831e-004
	,5.953786953e-004
	,6.085164451e-004
	,6.216914312e-004
	,6.350053795e-004
	,6.484625133e-004
	,6.620510608e-004
	,6.757638936e-004
	,6.895990196e-004
	,7.035582877e-004
	,7.176463225e-004
	,7.318742392e-004
	,7.462570342e-004
	,7.607706385e-004
	,7.754033539e-004
	,7.901540460e-004
	,8.050217052e-004
	,8.200054313e-004
	,8.351044538e-004
	,8.503351702e-004
	,8.656812603e-004
	,8.811240690e-004
	,8.966482699e-004
	,9.123013125e-004
	,9.280884869e-004
	,9.439827864e-004
	,9.599835052e-004
	,9.760900132e-004
	,9.923031314e-004
	,1.008629296e-003
	,1.025109778e-003
	,1.041697670e-003
	,-8.758880391e-006
	,-6.943679225e-006
	,-5.429651977e-006
	,-4.214951691e-006
	,-3.266663712e-006
	,-2.535983695e-006
	,-1.974695613e-006
	,-1.540529411e-006
	,-1.198300318e-006
	,-9.249555084e-007
	,-7.063710030e-007
	,-5.351472288e-007
	,-4.036596252e-007
	,-3.035821768e-007
	,-2.276274934e-007
	,-1.701486270e-007
	,-1.268554214e-007
	,-9.437934826e-008
	,-7.009003893e-008
	,-5.197087280e-008
	,-3.847958554e-008
	,-2.844519199e-008
	,-2.098761842e-008
	,-1.545223147e-008
	,-1.135825588e-008
	,-8.341013028e-009
	,-6.121947854e-009
	,-4.491171728e-009
	,-3.291510053e-009
	,-2.405375742e-009
	,-1.750524698e-009
	,-1.269366999e-009
	,-9.159175334e-010
	,-6.558537265e-010
	,-4.641287987e-010
	,-3.223834246e-010
	,-2.171502752e-010
	,-1.385843766e-010
	,-7.949508429e-011
	,-3.459811960e-011
	,-8.407005233e-018
	,2.715708419e-011
	,4.896376525e-011
	,6.695059090e-011
	,8.224427489e-011
	,9.567369800e-011
	,1.078354263e-010
	,1.191421756e-010
	,1.298647892e-010
	,1.401671924e-010
	,1.501386852e-010
	,1.598353623e-010
	,1.693199220e-010
	,1.786790761e-010
	,1.880157982e-010
	,1.974385386e-010
	,2.070573076e-010
	,2.169891207e-010
	,2.273403797e-010
	,2.381999950e-010
	,2.496450636e-010
	,2.617531867e-010
	,2.746124606e-010
	,2.883287565e-010
	,3.030321757e-010
	,3.188878008e-010
	,3.361096989e-010
	,3.549824229e-010
	,3.758773364e-010
	,3.993163261e-010
	,4.260113697e-010
	,4.569287688e-010
	,4.933904788e-010
	,5.372194199e-010
	,5.905522551e-010
	,6.570088683e-010
	,7.413220745e-010
	,8.489821749e-010
	,9.877473244e-010
	,1.170082574e-009
	,1.411699784e-009
	,1.734728579e-009
	,2.169317975e-009
	,2.756857367e-009
	,3.554278754e-009
	,4.639742199e-009
	,6.120374378e-009
	,8.078569311e-009
	,1.070726250e-008
	,1.426012301e-008
	,1.906298722e-008
	,2.555524062e-008
	,3.432840369e-008
	,4.617714159e-008
	,6.216625110e-008
	,8.371466897e-008
	,1.126126696e-007
	,1.513352427e-007
	,2.031545307e-007
	,2.722320210e-007
	,3.640770758e-007
	,4.856661466e-007
	,6.457996264e-007
	,8.554067182e-007
	,1.127813941e-006
	,1.478929812e-006
	,1.927291388e-006
	,2.493922251e-006
	,3.200829732e-006
	,4.069198357e-006
	,5.124995496e-006
	,6.380318839e-006
	,7.852739426e-006
	,9.568988409e-006
	,1.154641807e-005
	,1.379914471e-005
	,1.633881535e-005
	,1.917478186e-005
	,2.231459748e-005
	,2.576428843e-005
	,2.952855927e-005
	,3.361146387e-005
	,3.801696132e-005
	,4.274697894e-005
	,4.780219043e-005
	,5.318387249e-005
	,5.889876081e-005
	,6.494893735e-005
	,7.133449682e-005
	,7.806595780e-005
	,8.512416843e-005
	,9.250753497e-005
	,1.001139432e-004
	,1.080490431e-004
	,1.162958583e-004
	,1.247082928e-004
	,1.333163650e-004
	,1.422280780e-004
	,1.514482467e-004
	,1.609834727e-004
	,1.708424813e-004
	,1.810364992e-004
	,1.912057382e-004
	,2.015165241e-004
	,2.119232027e-004
	,2.227376741e-004
	,2.339907856e-004
	,2.453093354e-004
	,2.560995842e-004
	,2.667537949e-004
	,2.776953726e-004
	,2.888946498e-004
	,3.003339870e-004
	,3.120017996e-004
	,3.238901767e-004
	,3.359936109e-004
	,3.483081864e-004
	,3.608034622e-004
	,3.734871890e-004
	,3.863591318e-004
	,3.993055772e-004
	,4.124381429e-004
	,4.257550602e-004
	,4.391331940e-004
	,4.521070495e-004
	,4.649889249e-004
	,4.780010264e-004
	,4.911362683e-004
	,5.044204688e-004
	,5.178438325e-004
	,5.314026697e-004
	,5.450688495e-004
	,5.586106905e-004
	,5.719680704e-004
	,5.854687627e-004
	,5.990913279e-004
	,6.128382114e-004
	,6.267096243e-004
	,6.406926985e-004
	,6.547934565e-004
	,6.689759918e-004
	,6.832702998e-004
	,6.976928511e-004
	,7.121357309e-004
	,7.263216063e-004
	,7.406134530e-004
	,7.550098290e-004
	,7.695098252e-004
	,7.841126229e-004
	,7.988174760e-004
	,8.136247669e-004
	,8.285456393e-004
	,8.435689684e-004
	,8.586827219e-004
	,8.738707930e-004
	,8.891860719e-004
	,9.046068714e-004
	,9.201223502e-004
	,9.357319165e-004
	,9.514383102e-004
	,9.672382673e-004
	,-2.755840553e-005
	,-2.306497589e-005
	,-1.901612991e-005
	,-1.547752703e-005
	,-1.248256266e-005
	,-9.990456777e-006
	,-7.947590905e-006
	,-6.295095475e-006
	,-4.969659312e-006
	,-3.910884360e-006
	,-3.068533484e-006
	,-2.401989277e-006
	,-1.871013302e-006
	,-1.441008007e-006
	,-1.095199700e-006
	,-8.241952229e-007
	,-6.159247851e-007
	,-4.581061068e-007
	,-3.395737181e-007
	,-2.510121418e-007
	,-1.851807516e-007
	,-1.364540101e-007
	,-1.004433575e-007
	,-7.381181027e-008
	,-5.408251880e-008
	,-3.945601243e-008
	,-2.864920854e-008
	,-2.071942790e-008
	,-1.493525101e-008
	,-1.073254940e-008
	,-7.687176511e-009
	,-5.484440527e-009
	,-3.892379907e-009
	,-2.741232401e-009
	,-1.907439504e-009
	,-1.301788446e-009
	,-8.609509860e-010
	,-5.391171033e-010
	,-3.032273949e-010
	,-1.293348857e-010
	,2.193070543e-017
	,9.736160181e-011
	,1.718536920e-010
	,2.300557033e-010
	,2.767084301e-010
	,3.152237366e-010
	,3.480635898e-010
	,3.770128547e-010
	,4.033684024e-010
	,4.280676772e-010
	,4.517748889e-010
	,4.749371682e-010
	,4.978271827e-010
	,5.205927206e-010
	,5.433111995e-010
	,5.660183306e-010
	,5.887015547e-010
	,6.112930314e-010
	,6.336917775e-010
	,6.558049197e-010
	,6.775633718e-010
	,6.989160000e-010
	,7.198334772e-010
	,7.403271311e-010
	,7.604316943e-010
	,7.801909074e-010
	,7.996529382e-010
	,8.188628549e-010
	,8.378600663e-010
	,8.566919863e-010
	,8.754339198e-010
	,8.942166371e-010
	,9.132345988e-010
	,9.327574054e-010
	,9.531408811e-010
	,9.748246605e-010
	,9.983525456e-010
	,1.024414550e-009
	,1.053912825e-009
	,1.088052983e-009
	,1.128467072e-009
	,1.177379162e-009
	,1.237811844e-009
	,1.313399610e-009
	,1.407875964e-009
	,1.529845086e-009
	,1.689262318e-009
	,1.899446130e-009
	,2.178783944e-009
	,2.552752113e-009
	,3.055226507e-009
	,3.733315025e-009
	,4.650491851e-009
	,5.859617606e-009
	,7.422885379e-009
	,9.507322594e-009
	,1.228838284e-008
	,1.600007363e-008
	,2.095414185e-008
	,2.756569178e-008
	,3.638649702e-008
	,4.814876844e-008
	,6.382207226e-008
	,8.468680203e-008
	,1.124282844e-007
	,1.492559653e-007
	,1.980405368e-007
	,2.623834949e-007
	,3.471680732e-007
	,4.584995408e-007
	,6.040840682e-007
	,7.935293760e-007
	,1.038642232e-006
	,1.353690369e-006
	,1.755585609e-006
	,2.263937591e-006
	,2.900927855e-006
	,3.690966386e-006
	,4.660119457e-006
	,5.835335854e-006
	,7.243540338e-006
	,8.910696446e-006
	,1.086095201e-005
	,1.311596763e-005
	,1.569449242e-005
	,1.861203427e-005
	,2.187551902e-005
	,2.549762412e-005
	,2.947511589e-005
	,3.381408916e-005
	,3.850960940e-005
	,4.354318343e-005
	,4.893069417e-005
	,5.466845917e-005
	,6.075348207e-005
	,6.717825844e-005
	,7.394220688e-005
	,8.103512049e-005
	,8.845718812e-005
	,9.620335799e-005
	,1.042705633e-004
	,1.126712787e-004
	,1.214115282e-004
	,1.304995216e-004
	,1.399463493e-004
	,1.497661512e-004
	,1.598293391e-004
	,1.700952904e-004
	,1.804036902e-004
	,1.905810296e-004
	,2.010199258e-004
	,2.117128495e-004
	,2.226533263e-004
	,2.338356125e-004
	,2.452545111e-004
	,2.569052670e-004
	,2.684513227e-004
	,2.800844020e-004
	,2.918895794e-004
	,3.038608600e-004
	,3.159924460e-004
	,3.282672297e-004
	,3.406930997e-004
	,3.532535706e-004
	,3.659320164e-004
	,3.787502278e-004
	,3.916992182e-004
	,4.047508220e-004
	,4.179288981e-004
	,4.312305242e-004
	,4.446517172e-004
	,4.581910527e-004
	,4.718480368e-004
	,4.856201093e-004
	,4.995020154e-004
	,5.132957481e-004
	,5.266183302e-004
	,5.400709862e-004
	,5.536352539e-004
	,5.673065378e-004
	,5.810901800e-004
	,5.949778669e-004
	,6.089698166e-004
	,6.230657970e-004
	,6.372648777e-004
	,6.515729520e-004
	,6.659925048e-004
	,6.805336279e-004
	,6.951882784e-004
	,7.099448759e-004
	,7.248027619e-004
	,7.397613269e-004
	,7.548200084e-004
	,7.699782857e-004
	,7.852390933e-004
	,8.006073781e-004
	,8.160759845e-004
	,8.316338102e-004
	,8.472821938e-004
	,8.630434210e-004
	,8.788991033e-004
	,-6.030761800e-005
	,-5.276542118e-005
	,-4.562742935e-005
	,-3.900579507e-005
	,-3.301647377e-005
	,-2.771112583e-005
	,-2.308470854e-005
	,-1.909387703e-005
	,-1.567832994e-005
	,-1.277682217e-005
	,-1.033051128e-005
	,-8.281259229e-006
	,-6.580596882e-006
	,-5.183488319e-006
	,-4.044907783e-006
	,-3.124020366e-006
	,-2.385719068e-006
	,-1.800693250e-006
	,-1.341728175e-006
	,-9.870339717e-007
	,-7.207038824e-007
	,-5.245699202e-007
	,-3.808770050e-007
	,-2.755796485e-007
	,-1.984285127e-007
	,-1.422960497e-007
	,-1.017282873e-007
	,-7.250137429e-008
	,-5.147729756e-008
	,-3.638218300e-008
	,-2.557274626e-008
	,-1.786161097e-008
	,-1.238624808e-008
	,-8.508994932e-009
	,-5.768919930e-009
	,-3.834831705e-009
	,-2.469873792e-009
	,-1.506422912e-009
	,-8.256675039e-010
	,-3.433160583e-010
	,1.811891046e-017
	,2.457399935e-010
	,4.227298543e-010
	,5.513466786e-010
	,6.462219267e-010
	,7.176728693e-010
	,7.729130223e-010
	,8.169080860e-010
	,8.530391973e-010
	,8.835993234e-010
	,9.101603546e-010
	,9.338398801e-010
	,9.554166727e-010
	,9.754279719e-010
	,9.942693569e-010
	,1.012244541e-009
	,1.029595392e-009
	,1.046511662e-009
	,1.063133412e-009
	,1.079555788e-009
	,1.095837103e-009
	,1.112007064e-009
	,1.128071675e-009
	,1.144015359e-009
	,1.159806885e-009
	,1.175413836e-009
	,1.190817237e-009
	,1.206006530e-009
	,1.220965260e-009
	,1.235671776e-009
	,1.250107773e-009
	,1.264272160e-009
	,1.278183765e-009
	,1.291875322e-009
	,1.305392882e-009
	,1.318796837e-009
	,1.332158165e-009
	,1.345557136e-009
	,1.359085319e-009
	,1.372850086e-009
	,1.386982855e-009
	,1.401650182e-009
	,1.417069994e-009
	,1.433532268e-009
	,1.451426979e-009
	,1.471282445e-009
	,1.493816822e-009
	,1.520009268e-009
	,1.551200082e-009
	,1.589228901e-009
	,1.635023329e-009
	,1.692633170e-009
	,1.766431217e-009
	,1.862269371e-009
	,1.988104086e-009
	,2.154753881e-009
	,2.376967456e-009
	,2.674815012e-009
	,3.075629335e-009
	,3.614953710e-009
	,4.291562914e-009
	,5.188632973e-009
	,6.379641553e-009
	,7.961721912e-009
	,1.006464114e-008
	,1.286076956e-008
	,1.657936066e-008
	,2.152488781e-008
	,2.810131623e-008
	,3.684387586e-008
	,4.846060444e-008
	,6.388633112e-008
	,8.435230225e-008
	,1.114753467e-007
	,1.473648932e-007
	,1.946259754e-007
	,2.569073964e-007
	,3.387648700e-007
	,4.460078560e-007
	,5.859733803e-007
	,7.678226177e-007
	,1.002842551e-006
	,1.304724903e-006
	,1.689783903e-006
	,2.177065692e-006
	,2.788299096e-006
	,3.547644050e-006
	,4.481213495e-006
	,5.616376699e-006
	,6.980472807e-006
	,8.600794020e-006
	,1.050294146e-005
	,1.271013173e-005
	,1.524263393e-005
	,1.811743088e-005
	,2.134814197e-005
	,2.494379795e-005
	,2.891087199e-005
	,3.325470804e-005
	,3.797753437e-005
	,4.307977400e-005
	,4.856040846e-005
	,5.441741807e-005
	,6.064797791e-005
	,6.724788844e-005
	,7.420123903e-005
	,8.151117279e-005
	,8.917487815e-005
	,9.718714185e-005
	,1.055441132e-004
	,1.142411121e-004
	,1.232733829e-004
	,1.326359758e-004
	,1.423240014e-004
	,1.523323552e-004
	,1.625900465e-004
	,1.727703708e-004
	,1.832354178e-004
	,1.939766053e-004
	,2.049857261e-004
	,2.162548896e-004
	,2.277764857e-004
	,2.395431662e-004
	,2.514985090e-004
	,2.636731614e-004
	,2.760631421e-004
	,2.886637875e-004
	,3.014681158e-004
	,3.144633863e-004
	,3.276520753e-004
	,3.410279567e-004
	,3.545783215e-004
	,3.683034698e-004
	,3.822008101e-004
	,3.962709319e-004
	,4.105058890e-004
	,4.247716185e-004
	,4.391156322e-004
	,4.535875310e-004
	,4.679119892e-004
	,4.815572693e-004
	,4.953337092e-004
	,5.092289767e-004
	,5.232396161e-004
	,5.373660035e-004
	,5.516069874e-004
	,5.659597830e-004
	,5.804229033e-004
	,5.949949508e-004
	,6.096792666e-004
	,6.244770568e-004
	,6.393900956e-004
	,6.544203974e-004
	,6.695563950e-004
	,6.847971340e-004
	,7.001417225e-004
	,7.155893283e-004
	,7.311391747e-004
	,7.467905340e-004
	,7.625514170e-004
	,7.784147677e-004
	,-8.333985974e-005
	,-7.529608189e-005
	,-6.747718844e-005
	,-5.990570383e-005
	,-5.266233387e-005
	,-4.584283826e-005
	,-3.952763944e-005
	,-3.374535211e-005
	,-2.849632152e-005
	,-2.378765177e-005
	,-1.962275023e-005
	,-1.598755746e-005
	,-1.285722562e-005
	,-1.019921940e-005
	,-7.974770888e-006
	,-6.147914630e-006
	,-4.678302241e-006
	,-3.516767825e-006
	,-2.613261408e-006
	,-1.921386700e-006
	,-1.399476578e-006
	,-1.010943278e-006
	,-7.249376441e-007
	,-5.163348943e-007
	,-3.654105369e-007
	,-2.571844507e-007
	,-1.802616682e-007
	,-1.259028429e-007
	,-8.763590198e-008
	,-6.078284956e-008
	,-4.199176817e-008
	,-2.887095068e-008
	,-1.972474870e-008
	,-1.335880633e-008
	,-8.933874532e-009
	,-5.860576745e-009
	,-3.726663625e-009
	,-2.244812368e-009
	,-1.215221204e-009
	,-4.990862569e-010
	,-2.234877589e-017
	,3.489701590e-010
	,5.941721735e-010
	,7.676418005e-010
	,8.914970565e-010
	,9.809897669e-010
	,1.046642668e-009
	,1.095770548e-009
	,1.133470558e-009
	,1.163268259e-009
	,1.187600929e-009
	,1.208157937e-009
	,1.226100767e-009
	,1.242224136e-009
	,1.257081566e-009
	,1.271048676e-009
	,1.284374714e-009
	,1.297218774e-009
	,1.309679631e-009
	,1.321820080e-009
	,1.333683870e-009
	,1.345310126e-009
	,1.356743225e-009
	,1.368032774e-009
	,1.379222935e-009
	,1.390343487e-009
	,1.401412378e-009
	,1.412440325e-009
	,1.423433840e-009
	,1.434394842e-009
	,1.445319335e-009
	,1.456203550e-009
	,1.467056147e-009
	,1.477896561e-009
	,1.488742658e-009
	,1.499607316e-009
	,1.510498885e-009
	,1.521423319e-009
	,1.532385595e-009
	,1.543391238e-009
	,1.554446893e-009
	,1.565561407e-009
	,1.576746576e-009
	,1.588018223e-009
	,1.599398240e-009
	,1.610917466e-009
	,1.622619528e-009
	,1.634564805e-009
	,1.646836940e-009
	,1.659550858e-009
	,1.672863008e-009
	,1.686984447e-009
	,1.702200995e-009
	,1.718901399e-009
	,1.737620248e-009
	,1.759096075e-009
	,1.783776721e-009
	,1.812997534e-009
	,1.848622384e-009
	,1.892930153e-009
	,1.949011212e-009
	,2.021063948e-009
	,2.114797474e-009
	,2.237981202e-009
	,2.401192727e-009
	,2.618836986e-009
	,2.896089462e-009
	,3.254334037e-009
	,3.727149700e-009
	,4.352442868e-009
	,5.180663372e-009
	,6.278949651e-009
	,7.736561929e-009
	,9.672290354e-009
	,1.224398509e-008
	,1.566133907e-008
	,2.020270125e-008
	,2.623736296e-008
	,3.425459926e-008
	,4.490164001e-008
	,5.903316755e-008
	,7.777532055e-008
	,1.026075659e-007
	,1.353243021e-007
	,1.785293476e-007
	,2.354700089e-007
	,3.103292423e-007
	,4.084542731e-007
	,5.366197045e-007
	,7.033185940e-007
	,9.190636358e-007
	,1.196679135e-006
	,1.551547111e-006
	,2.001764082e-006
	,2.568159125e-006
	,3.274126390e-006
	,4.145239476e-006
	,5.208642292e-006
	,6.492247716e-006
	,8.023813752e-006
	,9.829725789e-006
	,1.193384798e-005
	,1.435858075e-005
	,1.712258329e-005
	,2.024115046e-005
	,2.372624779e-005
	,2.758673307e-005
	,3.182870677e-005
	,3.645593425e-005
	,4.147027087e-005
	,4.687204794e-005
	,5.266041907e-005
	,5.883367606e-005
	,6.538955258e-005
	,7.232554486e-005
	,7.963892803e-005
	,8.732681130e-005
	,9.538623928e-005
	,1.038142506e-004
	,1.126079059e-004
	,1.217642339e-004
	,1.312801299e-004
	,1.411525315e-004
	,1.510950561e-004
	,1.611786905e-004
	,1.715817640e-004
	,1.822966207e-004
	,1.933159310e-004
	,2.046326256e-004
	,2.162400665e-004
	,2.281313952e-004
	,2.403001061e-004
	,2.527414131e-004
	,2.654488968e-004
	,2.784159320e-004
	,2.916373330e-004
	,3.051092745e-004
	,3.188245517e-004
	,3.327804960e-004
	,3.469759110e-004
	,3.614033300e-004
	,3.760568552e-004
	,3.909150997e-004
	,4.057790963e-004
	,4.208270604e-004
	,4.349928068e-004
	,4.489970876e-004
	,4.631528502e-004
	,4.774580305e-004
	,4.919124999e-004
	,5.065130876e-004
	,5.212574460e-004
	,5.360765940e-004
	,5.509780057e-004
	,5.660166460e-004
	,5.811904529e-004
	,5.964994519e-004
	,6.119453259e-004
	,6.275209497e-004
	,6.432254351e-004
	,6.590581336e-004
	,-9.886087872e-005
	,-8.942149499e-005
	,-8.033959980e-005
	,-7.167775181e-005
	,-6.347887072e-005
	,-5.576060184e-005
	,-4.854642685e-005
	,-4.186249607e-005
	,-3.572246761e-005
	,-3.014898287e-005
	,-2.515954265e-005
	,-2.074945757e-005
	,-1.689824594e-005
	,-1.357766011e-005
	,-1.075463549e-005
	,-8.391649857e-006
	,-6.447063834e-006
	,-4.877042288e-006
	,-3.635071710e-006
	,-2.671468068e-006
	,-1.937661986e-006
	,-1.389978694e-006
	,-9.884306648e-007
	,-6.979116434e-007
	,-4.898687694e-007
	,-3.421091247e-007
	,-2.378625988e-007
	,-1.647335060e-007
	,-1.136815607e-007
	,-7.817115555e-008
	,-5.353901149e-008
	,-3.649589837e-008
	,-2.472917975e-008
	,-1.661721659e-008
	,-1.103008599e-008
	,-7.184057208e-009
	,-4.537121733e-009
	,-2.715345786e-009
	,-1.461002799e-009
	,-5.965904304e-010
	,-3.190437150e-017
	,4.127109261e-010
	,6.992175907e-010
	,8.991293338e-010
	,1.039637661e-009
	,1.139400242e-009
	,1.211212239e-009
	,1.263843690e-009
	,1.303303227e-009
	,1.333701938e-009
	,1.357850919e-009
	,1.377684677e-009
	,1.394545624e-009
	,1.409368021e-009
	,1.422801990e-009
	,1.435295008e-009
	,1.447152664e-009
	,1.458583342e-009
	,1.469729344e-009
	,1.480688289e-009
	,1.491527116e-009
	,1.502292345e-009
	,1.513016773e-009
	,1.523723222e-009
	,1.534427377e-009
	,1.545140181e-009
	,1.555869440e-009
	,1.566620644e-009
	,1.577397908e-009
	,1.588204446e-009
	,1.599042305e-009
	,1.609913172e-009
	,1.620818108e-009
	,1.631758050e-009
	,1.642733855e-009
	,1.653746447e-009
	,1.664796822e-009
	,1.675886020e-009
	,1.687015062e-009
	,1.698185084e-009
	,1.709396881e-009
	,1.720651709e-009
	,1.731950986e-009
	,1.743296213e-009
	,1.754689061e-009
	,1.766131835e-009
	,1.777626999e-009
	,1.789177675e-009
	,1.800787977e-009
	,1.812463198e-009
	,1.824209452e-009
	,1.836033257e-009
	,1.847939861e-009
	,1.859935595e-009
	,1.872041792e-009
	,1.884314317e-009
	,1.896841925e-009
	,1.909733545e-009
	,1.923120566e-009
	,1.937169929e-009
	,1.952102438e-009
	,1.968214836e-009
	,1.985729302e-009
	,2.005010778e-009
	,2.026869558e-009
	,2.052187683e-009
	,2.082164686e-009
	,2.118428327e-009
	,2.163189314e-009
	,2.219451627e-009
	,2.291299888e-009
	,2.384289872e-009
	,2.503439602e-009
	,2.651953477e-009
	,2.845088174e-009
	,3.097516698e-009
	,3.428756591e-009
	,3.864771069e-009
	,4.440096545e-009
	,5.200670001e-009
	,6.207584611e-009
	,7.542073233e-009
	,9.312116473e-009
	,1.166119371e-008
	,1.477985623e-008
	,1.892100191e-008
	,2.442000883e-008
	,3.172112663e-008
	,4.141210365e-008
	,5.426937164e-008
	,7.131681533e-008
	,9.377782471e-008
	,1.234777904e-007
	,1.626974550e-007
	,2.143930885e-007
	,2.823802447e-007
	,3.715490576e-007
	,4.881143549e-007
	,6.398958572e-007
	,8.366170714e-007
	,1.090202753e-006
	,1.415044580e-006
	,1.828194535e-006
	,2.349438225e-006
	,3.001199706e-006
	,3.808239120e-006
	,4.797126886e-006
	,5.995511688e-006
	,7.431237835e-006
	,9.131401247e-006
	,1.112144916e-005
	,1.342442357e-005
	,1.606042212e-005
	,1.904630973e-005
	,2.239567312e-005
	,2.611897948e-005
	,3.022388044e-005
	,3.471561918e-005
	,3.959748971e-005
	,4.487174702e-005
	,5.053876688e-005
	,5.659819353e-005
	,6.304927038e-005
	,6.989094848e-005
	,7.712207157e-005
	,8.474151691e-005
	,9.274829329e-005
	,1.011415923e-004
	,1.099209189e-004
	,1.190860380e-004
	,1.286369578e-004
	,1.382425310e-004
	,1.480538354e-004
	,1.582189703e-004
	,1.686950213e-004
	,1.794444695e-004
	,1.905096037e-004
	,2.018832980e-004
	,2.135585354e-004
	,2.255287334e-004
	,2.377886101e-004
	,2.503315234e-004
	,2.631515957e-004
	,2.762435178e-004
	,2.896010273e-004
	,3.032181044e-004
	,3.170879762e-004
	,3.312052940e-004
	,3.455654100e-004
	,3.601633460e-004
	,3.749997027e-004
	,3.900639263e-004
	,4.046364740e-004
	,4.185835819e-004
	,4.327081309e-004
	,4.470075563e-004
	,4.614796140e-004
	,4.761223754e-004
	,4.909340999e-004
	,5.059182765e-004
	,5.210694626e-004
	,-1.098625331e-004
	,-9.940853671e-005
	,-8.939853289e-005
	,-7.984981154e-005
	,-7.081658955e-005
	,-6.233379654e-005
	,-5.441686289e-005
	,-4.708727429e-005
	,-4.035102236e-005
	,-3.421080639e-005
	,-2.866795630e-005
	,-2.371813577e-005
	,-1.935307309e-005
	,-1.555555694e-005
	,-1.229861266e-005
	,-9.551988564e-006
	,-7.292909933e-006
	,-5.485366669e-006
	,-4.070517686e-006
	,-2.983886243e-006
	,-2.163518774e-006
	,-1.553453728e-006
	,-1.105508362e-006
	,-7.809084369e-007
	,-5.484684790e-007
	,-3.832540146e-007
	,-2.664728843e-007
	,-1.844752095e-007
	,-1.272655179e-007
	,-8.750118517e-008
	,-5.993453527e-008
	,-4.086292382e-008
	,-2.769043118e-008
	,-1.860483427e-008
	,-1.234509932e-008
	,-8.035983231e-009
	,-5.071404103e-009
	,-3.032460336e-009
	,-1.630042963e-009
	,-6.649248898e-010
	,-1.545621512e-017
	,4.589910500e-010
	,7.767874167e-010
	,9.978173548e-010
	,1.152552126e-009
	,1.261881556e-009
	,1.340121355e-009
	,1.397079449e-009
	,1.439473499e-009
	,1.471903626e-009
	,1.497521612e-009
	,1.518487017e-009
	,1.536278235e-009
	,1.551907248e-009
	,1.566066639e-009
	,1.579230433e-009
	,1.591722937e-009
	,1.603765220e-009
	,1.615507099e-009
	,1.627048207e-009
	,1.638450703e-009
	,1.649746270e-009
	,1.660943792e-009
	,1.672051010e-009
	,1.683099178e-009
	,1.694132176e-009
	,1.705183527e-009
	,1.716273393e-009
	,1.727413148e-009
	,1.738609535e-009
	,1.749866601e-009
	,1.761186939e-009
	,1.772572078e-009
	,1.784023036e-009
	,1.795540407e-009
	,1.807124579e-009
	,1.818775862e-009
	,1.830494325e-009
	,1.842279953e-009
	,1.854132874e-009
	,1.866053000e-009
	,1.878040333e-009
	,1.890094906e-009
	,1.902216595e-009
	,1.914405416e-009
	,1.926661470e-009
	,1.938984704e-009
	,1.951375237e-009
	,1.963833499e-009
	,1.976359920e-009
	,1.988955116e-009
	,2.001619876e-009
	,2.014355651e-009
	,2.027164071e-009
	,2.040047515e-009
	,2.053009237e-009
	,2.066053529e-009
	,2.079186337e-009
	,2.092415523e-009
	,2.105751902e-009
	,2.119209931e-009
	,2.132809143e-009
	,2.146576009e-009
	,2.160546277e-009
	,2.174768057e-009
	,2.189306915e-009
	,2.204251536e-009
	,2.219722148e-009
	,2.235839778e-009
	,2.252661638e-009
	,2.270558408e-009
	,2.289879452e-009
	,2.311096999e-009
	,2.334851581e-009
	,2.362010954e-009
	,2.393751310e-009
	,2.431670414e-009
	,2.477937951e-009
	,2.535501971e-009
	,2.604208998e-009
	,2.690321605e-009
	,2.799772748e-009
	,2.940180221e-009
	,3.121665295e-009
	,3.357678634e-009
	,3.666092806e-009
	,4.070664706e-009
	,4.602974524e-009
	,5.304992635e-009
	,6.232496850e-009
	,7.459603724e-009
	,9.084776348e-009
	,1.123877844e-008
	,1.409519796e-008
	,1.788434493e-008
	,2.291157563e-008
	,2.958139804e-008
	,3.842910460e-008
	,5.016216378e-008
	,6.560892958e-008
	,8.604384402e-008
	,1.130601073e-007
	,1.487294766e-007
	,1.957451956e-007
	,2.575892505e-007
	,3.387342066e-007
	,4.448802199e-007
	,5.832243652e-007
	,7.627536313e-007
	,9.945449146e-007
	,1.292045622e-006
	,1.671298139e-006
	,2.151062845e-006
	,2.752790997e-006
	,3.500404361e-006
	,4.419856174e-006
	,5.538477499e-006
	,6.884150045e-006
	,8.484382305e-006
	,1.036538961e-005
	,1.255128003e-005
	,1.506343094e-005
	,1.792010468e-005
	,2.113630970e-005
	,2.472388099e-005
	,2.869173003e-005
	,3.304628153e-005
	,3.779189654e-005
	,4.293129009e-005
	,4.846541685e-005
	,5.439444869e-005
	,6.071790512e-005
	,6.743487663e-005
	,7.454421935e-005
	,8.204472465e-005
	,8.993519253e-005
	,9.821445043e-005
	,1.068816022e-004
	,1.159357335e-004
	,1.251167799e-004
	,1.344462861e-004
	,1.441298941e-004
	,1.541614933e-004
	,1.645354380e-004
	,1.752468194e-004
	,1.862917788e-004
	,1.976656655e-004
	,2.093635964e-004
	,2.213813856e-004
	,2.337162208e-004
	,2.463651885e-004
	,2.593243492e-004
	,2.725911955e-004
	,2.861639097e-004
	,3.000459753e-004
	,3.142331745e-004
	,3.287245132e-004
	,3.432920242e-004
	,3.580439152e-004
	,3.730405290e-004
	,3.867910602e-004
	,-1.184838682e-004
	,-1.072635829e-004
	,-9.651494130e-005
	,-8.630341863e-005
	,-7.664681231e-005
	,-6.756766228e-005
	,-5.909819029e-005
	,-5.124658809e-005
	,-4.401000328e-005
	,-3.738519969e-005
	,-3.136942000e-005
	,-2.595587381e-005
	,-2.112559289e-005
	,-1.688092050e-005
	,-1.326078555e-005
	,-1.025380622e-005
	,-7.809520492e-006
	,-5.862545573e-006
	,-4.341809387e-006
	,-3.175348066e-006
	,-2.294904666e-006
	,-1.642638147e-006
	,-1.165518376e-006
	,-8.205809370e-007
	,-5.746988923e-007
	,-4.008992347e-007
	,-2.787355756e-007
	,-1.932255467e-007
	,-1.335659414e-007
	,-9.204827896e-008
	,-6.321429663e-008
	,-4.322146209e-008
	,-2.937674964e-008
	,-1.979930627e-008
	,-1.317909584e-008
	,-8.605643466e-009
	,-5.447275898e-009
	,-3.266371371e-009
	,-1.760119818e-009
	,-7.194172727e-010
	,-1.300204575e-017
	,4.980607121e-010
	,8.438187052e-010
	,1.084848828e-009
	,1.253895844e-009
	,1.373487933e-009
	,1.459118969e-009
	,1.521441680e-009
	,1.567776959e-009
	,1.603154352e-009
	,1.631027907e-009
	,1.653768933e-009
	,1.673005179e-009
	,1.689854216e-009
	,1.705083018e-009
	,1.719218234e-009
	,1.732621547e-009
	,1.745541202e-009
	,1.758148187e-009
	,1.770559924e-009
	,1.782857614e-009
	,1.795096951e-009
	,1.807316610e-009
	,1.819543421e-009
	,1.831796064e-009
	,1.844087655e-009
	,1.856427346e-009
	,1.868821625e-009
	,1.881275128e-009
	,1.893791189e-009
	,1.906372200e-009
	,1.919019908e-009
	,1.931735646e-009
	,1.944520493e-009
	,1.957375123e-009
	,1.970300225e-009
	,1.983296147e-009
	,1.996363396e-009
	,2.009502238e-009
	,2.022712940e-009
	,2.035995691e-009
	,2.049350620e-009
	,2.062777952e-009
	,2.076277749e-009
	,2.089850089e-009
	,2.103495097e-009
	,2.117212774e-009
	,2.131003212e-009
	,2.144866474e-009
	,2.158802619e-009
	,2.172811707e-009
	,2.186893806e-009
	,2.201048988e-009
	,2.215277264e-009
	,2.229579012e-009
	,2.243954342e-009
	,2.258403738e-009
	,2.272927541e-009
	,2.287526394e-009
	,2.302201215e-009
	,2.316953011e-009
	,2.331783345e-009
	,2.346694025e-009
	,2.361687944e-009
	,2.376768485e-009
	,2.391940367e-009
	,2.407210010e-009
	,2.422585809e-009
	,2.438079059e-009
	,2.453704960e-009
	,2.469483963e-009
	,2.485443617e-009
	,2.501621060e-009
	,2.518066608e-009
	,2.534848042e-009
	,2.551943494e-009
	,2.569525165e-009
	,2.587734402e-009
	,2.606760577e-009
	,2.626859254e-009
	,2.648375568e-009
	,2.671776728e-009
	,2.697695359e-009
	,2.726988380e-009
	,2.760818627e-009
	,2.799752110e-009
	,2.845186016e-009
	,2.899943200e-009
	,2.967023029e-009
	,3.050404339e-009
	,3.155367244e-009
	,3.288919121e-009
	,3.460361869e-009
	,3.682045635e-009
	,3.970369850e-009
	,4.347112437e-009
	,4.841180561e-009
	,5.490989810e-009
	,6.347548284e-009
	,7.478596416e-009
	,8.974067075e-009
	,1.095333907e-008
	,1.357482179e-008
	,1.704862765e-008
	,2.165329994e-008
	,2.775785627e-008
	,3.585080739e-008
	,4.648864080e-008
	,6.055883212e-008
	,7.917021628e-008
	,1.037656105e-007
	,1.362302810e-007
	,1.790175379e-007
	,2.353038521e-007
	,3.091777715e-007
	,4.058632266e-007
	,5.319770111e-007
	,6.958137691e-007
	,9.076450570e-007
	,1.180010019e-006
	,1.527964756e-006
	,1.969248202e-006
	,2.524316650e-006
	,3.216201065e-006
	,4.070154305e-006
	,5.113080610e-006
	,6.372774161e-006
	,7.877030131e-006
	,9.652721251e-006
	,1.172494137e-005
	,1.411630888e-005
	,1.684648986e-005
	,1.993197653e-005
	,2.338607951e-005
	,2.721912912e-005
	,3.143877904e-005
	,3.605045296e-005
	,4.105766979e-005
	,4.646240467e-005
	,5.226544858e-005
	,5.846685558e-005
	,6.506614859e-005
	,7.206254435e-005
	,7.945526817e-005
	,8.724317668e-005
	,9.542527606e-005
	,1.040006472e-004
	,1.127631771e-004
	,1.216343229e-004
	,1.308675165e-004
	,1.404554215e-004
	,1.503918628e-004
	,1.606709817e-004
	,1.712871710e-004
	,1.822355783e-004
	,1.935111814e-004
	,2.051083879e-004
	,2.170223490e-004
	,2.292513787e-004
	,2.417887597e-004
	,2.546307636e-004
	,-1.262325037e-004
	,-1.143553921e-004
	,-1.030069325e-004
	,-9.220082132e-005
	,-8.196181794e-005
	,-7.233322470e-005
	,-6.332909242e-005
	,-5.494898571e-005
	,-4.719222267e-005
	,-4.005612276e-005
	,-3.352355525e-005
	,-2.758738609e-005
	,-2.232187939e-005
	,-1.777632012e-005
	,-1.393701189e-005
	,-1.075867988e-005
	,-8.179708473e-006
	,-6.128307109e-006
	,-4.526314343e-006
	,-3.298091380e-006
	,-2.374419056e-006
	,-1.692399418e-006
	,-1.197222765e-006
	,-8.421565216e-007
	,-5.897751181e-007
	,-4.115343037e-007
	,-2.862777967e-007
	,-1.985950354e-007
	,-1.373997722e-007
	,-9.479115058e-008
	,-6.517839966e-008
	,-4.462681598e-008
	,-3.037854103e-008
	,-2.050435347e-008
	,-1.366261811e-008
	,-8.932061546e-009
	,-5.662718218e-009
	,-3.402142403e-009
	,-1.837610486e-009
	,-7.532235293e-010
	,1.556030835e-017
	,5.248279539e-010
	,8.921262792e-010
	,1.150745763e-009
	,1.334349490e-009
	,1.466127816e-009
	,1.562052291e-009
	,1.633123216e-009
	,1.686919968e-009
	,1.728671565e-009
	,1.761993730e-009
	,1.789396024e-009
	,1.812628800e-009
	,1.832919864e-009
	,1.851135430e-009
	,1.867889462e-009
	,1.883618879e-009
	,1.898635024e-009
	,1.913160284e-009
	,1.927353496e-009
	,1.941328157e-009
	,1.955165524e-009
	,1.968923871e-009
	,1.982645004e-009
	,1.996359062e-009
	,2.010087957e-009
	,2.023847665e-009
	,2.037649855e-009
	,2.051503282e-009
	,2.065414338e-009
	,2.079387978e-009
	,2.093427950e-009
	,2.107537255e-009
	,2.121718179e-009
	,2.135972493e-009
	,2.150301729e-009
	,2.164707113e-009
	,2.179189639e-009
	,2.193750239e-009
	,2.208389559e-009
	,2.223108218e-009
	,2.237906820e-009
	,2.252785740e-009
	,2.267745439e-009
	,2.282786186e-009
	,2.297908375e-009
	,2.313112130e-009
	,2.328397858e-009
	,2.343765591e-009
	,2.359215565e-009
	,2.374747874e-009
	,2.390362679e-009
	,2.406060053e-009
	,2.421840119e-009
	,2.437702976e-009
	,2.453648619e-009
	,2.469677148e-009
	,2.485788679e-009
	,2.501983146e-009
	,2.518260721e-009
	,2.534621574e-009
	,2.551065723e-009
	,2.567593404e-009
	,2.584204980e-009
	,2.600900727e-009
	,2.617680953e-009
	,2.634546461e-009
	,2.651497821e-009
	,2.668536110e-009
	,2.685662563e-009
	,2.702878987e-009
	,2.720187438e-009
	,2.737591030e-009
	,2.755093591e-009
	,2.772700148e-009
	,2.790417682e-009
	,2.808255179e-009
	,2.826224794e-009
	,2.844342394e-009
	,2.862629662e-009
	,2.881115637e-009
	,2.899797338e-009
	,2.918727439e-009
	,2.937975137e-009
	,2.957617793e-009
	,2.977759345e-009
	,2.998539688e-009
	,3.020147331e-009
	,3.042835096e-009
	,3.066947176e-009
	,3.092948857e-009
	,3.121324666e-009
	,3.152188013e-009
	,3.186866305e-009
	,3.226554224e-009
	,3.272832649e-009
	,3.327795039e-009
	,3.394212630e-009
	,3.475756096e-009
	,3.577300150e-009
	,3.705302350e-009
	,3.868326576e-009
	,4.077733184e-009
	,4.348593487e-009
	,4.700905390e-009
	,5.161206800e-009
	,5.764705304e-009
	,6.558131301e-009
	,7.603513493e-009
	,8.983157618e-009
	,1.080626320e-008
	,1.321768778e-008
	,1.640953900e-008
	,2.063650446e-008
	,2.623612350e-008
	,3.357930322e-008
	,4.328333608e-008
	,5.611893059e-008
	,7.308678072e-008
	,9.549928879e-008
	,1.250720183e-007
	,1.640398785e-007
	,2.153005163e-007
	,2.825897543e-007
	,3.706918087e-007
	,4.856840211e-007
	,6.352120501e-007
	,8.287851295e-007
	,1.078071983e-006
	,1.397169437e-006
	,1.802803806e-006
	,2.314420441e-006
	,2.954112827e-006
	,3.746353413e-006
	,4.717508669e-006
	,5.895150950e-006
	,7.307217474e-006
	,8.981098304e-006
	,1.094275388e-005
	,1.321596230e-005
	,1.582174621e-005
	,1.877805897e-005
	,2.209973340e-005
	,2.579849993e-005
	,2.988339382e-005
	,3.436098835e-005
	,3.923586210e-005
	,4.451094016e-005
	,5.018786265e-005
	,5.626735530e-005
	,6.274962212e-005
	,6.963435086e-005
	,7.692100542e-005
	,8.460928538e-005
	,9.269832918e-005
	,1.010403699e-004
	,1.094472671e-004
	,1.182241858e-004
	,1.273642763e-004
	,1.368615129e-004
	,1.467096999e-004
	,-1.333645975e-004
	,-1.210009659e-004
	,-1.091129431e-004
	,-9.773590768e-005
	,-8.693770088e-005
	,-7.675555546e-005
	,-6.719872070e-005
	,-5.827142525e-005
	,-4.996767358e-005
	,-4.225871223e-005
	,-3.518347277e-005
	,-2.884343588e-005
	,-2.328777433e-005
	,-1.851557249e-005
	,-1.449331452e-005
	,-1.116821026e-005
	,-8.473307536e-006
	,-6.329494074e-006
	,-4.654254466e-006
	,-3.376026875e-006
	,-2.423470708e-006
	,-1.724670542e-006
	,-1.219198887e-006
	,-8.573789956e-007
	,-6.004013126e-007
	,-4.189908397e-007
	,-2.915319403e-007
	,-2.023097503e-007
	,-1.400326329e-007
	,-9.665939305e-008
	,-6.650124518e-008
	,-4.554308952e-008
	,-3.099185696e-008
	,-2.092115142e-008
	,-1.395524194e-008
	,-9.136254978e-009
	,-5.801028361e-009
	,-3.490899894e-009
	,-1.888800942e-009
	,-7.756234520e-010
	,1.597803931e-017
	,5.426097642e-010
	,9.243856645e-010
	,1.195149014e-009
	,1.389277326e-009
	,1.530481951e-009
	,1.635109222e-009
	,1.714421164e-009
	,1.776170050e-009
	,1.825686372e-009
	,1.866630000e-009
	,1.901508998e-009
	,1.932038681e-009
	,1.959389465e-009
	,1.984359560e-009
	,2.007495031e-009
	,2.029173644e-009
	,2.049663410e-009
	,2.069163551e-009
	,2.087831935e-009
	,2.105801987e-009
	,2.123192183e-009
	,2.140110102e-009
	,2.156652788e-009
	,2.172906382e-009
	,2.188945178e-009
	,2.204831752e-009
	,2.220617441e-009
	,2.236343667e-009
	,2.252043138e-009
	,2.267741740e-009
	,2.283459548e-009
	,2.299212123e-009
	,2.315011662e-009
	,2.330867534e-009
	,2.346787079e-009
	,2.362776120e-009
	,2.378839195e-009
	,2.394979929e-009
	,2.411201191e-009
	,2.427505471e-009
	,2.443894605e-009
	,2.460370139e-009
	,2.476933566e-009
	,2.493585877e-009
	,2.510328006e-009
	,2.527160815e-009
	,2.544085013e-009
	,2.561101115e-009
	,2.578209640e-009
	,2.595411026e-009
	,2.612705744e-009
	,2.630094000e-009
	,2.647576180e-009
	,2.665152474e-009
	,2.682823069e-009
	,2.700588219e-009
	,2.718448052e-009
	,2.736402650e-009
	,2.754452137e-009
	,2.772596666e-009
	,2.790836263e-009
	,2.809171044e-009
	,2.827601025e-009
	,2.846126195e-009
	,2.864746727e-009
	,2.883462668e-009
	,2.902274171e-009
	,2.921181314e-009
	,2.940184300e-009
	,2.959283358e-009
	,2.978478730e-009
	,2.997770776e-009
	,3.017159902e-009
	,3.036646799e-009
	,3.056232147e-009
	,3.075916795e-009
	,3.095702110e-009
	,3.115589498e-009
	,3.135581116e-009
	,3.155679432e-009
	,3.175887915e-009
	,3.196210738e-009
	,3.216653728e-009
	,3.237224320e-009
	,3.257932122e-009
	,3.278790257e-009
	,3.299802088e-009
	,3.320979049e-009
	,3.342356801e-009
	,3.363968058e-009
	,3.385856350e-009
	,3.408079782e-009
	,3.430716396e-009
	,3.453870547e-009
	,3.477681275e-009
	,3.502339177e-009
	,3.528098740e-009
	,3.554966467e-009
	,3.583415731e-009
	,3.613979627e-009
	,3.647294668e-009
	,3.684201519e-009
	,3.725811203e-009
	,3.773592404e-009
	,3.829487644e-009
	,3.896067197e-009
	,3.976723283e-009
	,4.075961840e-009
	,4.199751046e-009
	,4.355993966e-009
	,4.555164532e-009
	,4.811145960e-009
	,5.142344448e-009
	,5.573166394e-009
	,6.135970648e-009
	,6.873688461e-009
	,7.843250356e-009
	,9.120071065e-009
	,1.080435900e-008
	,1.302893892e-008
	,1.596997533e-008
	,1.986111753e-008
	,2.494745859e-008
	,3.165829262e-008
	,4.052975439e-008
	,5.225439344e-008
	,6.774277083e-008
	,8.818907033e-008
	,1.151557227e-007
	,1.506791261e-007
	,1.974024149e-007
	,2.587385768e-007
	,3.390672103e-007
	,4.439661015e-007
	,5.804752512e-007
	,7.573854528e-007
	,9.855358754e-007
	,1.278095818e-006
	,1.650796057e-006
	,2.122064768e-006
	,2.713022249e-006
	,3.447292371e-006
	,4.350602013e-006
	,5.450169689e-006
	,6.773932818e-006
	,8.349653994e-006
	,1.020402473e-005
	,1.236186266e-005
	,1.484548377e-005
	,1.767428706e-005
	,2.086456005e-005
	,2.442956229e-005
	,2.837967870e-005
	,3.272277501e-005
	,3.746455788e-005
	,4.260902122e-005
	,4.815877191e-005
	,5.411531947e-005
	,6.047952178e-005
	,6.725164093e-005
	,-1.392477634e-004
	,-1.264986803e-004
	,-1.141839137e-004
	,-1.023704010e-004
	,-9.113113327e-005
	,-8.049589766e-005
	,-7.047255635e-005
	,-6.104663791e-005
	,-5.218637751e-005
	,-4.397732120e-005
	,-3.653232005e-005
	,-2.990458120e-005
	,-2.411485992e-005
	,-1.914811551e-005
	,-1.496550252e-005
	,-1.151046475e-005
	,-8.708729717e-006
	,-6.473178617e-006
	,-4.740867966e-006
	,-3.432658996e-006
	,-2.460569170e-006
	,-1.749600058e-006
	,-1.236270248e-006
	,-8.691687146e-007
	,-6.085917730e-007
	,-4.247089858e-007
	,-2.955405887e-007
	,-2.051288717e-007
	,-1.420179573e-007
	,-9.804780631e-008
	,-6.741885283e-008
	,-4.615328670e-008
	,-3.142694005e-008
	,-2.123260600e-008
	,-1.417549273e-008
	,-9.288937050e-009
	,-5.903563713e-009
	,-3.556102882e-009
	,-1.926057168e-009
	,-7.917731555e-010
	,-7.206028742e-018
	,5.551933945e-010
	,9.470122140e-010
	,1.226034050e-009
	,1.427194268e-009
	,1.574616997e-009
	,1.684954979e-009
	,1.769698404e-009
	,1.836770349e-009
	,1.891629583e-009
	,1.938032234e-009
	,1.978557858e-009
	,2.014973257e-009
	,2.048483380e-009
	,2.079904827e-009
	,2.109785890e-009
	,2.138489079e-009
	,2.166248896e-009
	,2.193211261e-009
	,2.219461601e-009
	,2.245044597e-009
	,2.269978211e-009
	,2.294264696e-009
	,2.317899213e-009
	,2.340876357e-009
	,2.363196614e-009
	,2.384870978e-009
	,2.405924607e-009
	,2.426398224e-009
	,2.446347175e-009
	,2.465838050e-009
	,2.484944324e-009
	,2.503740447e-009
	,2.522297542e-009
	,2.540679811e-009
	,2.558942946e-009
	,2.577133602e-009
	,2.595289766e-009
	,2.613441983e-009
	,2.631614223e-009
	,2.649825451e-009
	,2.668090312e-009
	,2.686420225e-009
	,2.704824077e-009
	,2.723308877e-009
	,2.741879980e-009
	,2.760541743e-009
	,2.779297566e-009
	,2.798150179e-009
	,2.817101766e-009
	,2.836154139e-009
	,2.855308670e-009
	,2.874566720e-009
	,2.893929211e-009
	,2.913397047e-009
	,2.932970904e-009
	,2.952651419e-009
	,2.972439099e-009
	,2.992334412e-009
	,3.012337623e-009
	,3.032449148e-009
	,3.052669233e-009
	,3.072998063e-009
	,3.093436013e-009
	,3.113983019e-009
	,3.134639345e-009
	,3.155405078e-009
	,3.176280297e-009
	,3.197265118e-009
	,3.218359623e-009
	,3.239563826e-009
	,3.260877792e-009
	,3.282301635e-009
	,3.303835435e-009
	,3.325479336e-009
	,3.347233460e-009
	,3.369097960e-009
	,3.391073037e-009
	,3.413158962e-009
	,3.435356179e-009
	,3.457664981e-009
	,3.480085924e-009
	,3.502619692e-009
	,3.525267021e-009
	,3.548028998e-009
	,3.570906692e-009
	,3.593901775e-009
	,3.617016160e-009
	,3.640252117e-009
	,3.663612780e-009
	,3.687101976e-009
	,3.710724617e-009
	,3.734487186e-009
	,3.758394358e-009
	,3.782445304e-009
	,3.806659547e-009
	,3.831051723e-009
	,3.855640960e-009
	,3.880452541e-009
	,3.905519773e-009
	,3.930887315e-009
	,3.956613680e-009
	,3.982777221e-009
	,4.009485320e-009
	,4.036799732e-009
	,4.064809443e-009
	,4.093782988e-009
	,4.123981350e-009
	,4.155747755e-009
	,4.189534148e-009
	,4.225936377e-009
	,4.265736390e-009
	,4.309964533e-009
	,4.359993626e-009
	,4.417630092e-009
	,4.485256185e-009
	,4.566031468e-009
	,4.664130812e-009
	,4.785078420e-009
	,4.936186354e-009
	,5.127136082e-009
	,5.370749437e-009
	,5.684011876e-009
	,6.089427822e-009
	,6.616822958e-009
	,7.305732444e-009
	,8.208511150e-009
	,9.394631041e-009
	,1.095627427e-008
	,1.301568049e-008
	,1.573506553e-008
	,1.927477258e-008
	,2.393349019e-008
	,3.008526669e-008
	,3.820910578e-008
	,4.893585869e-008
	,6.309488674e-008
	,8.177416808e-008
	,1.063965221e-007
	,1.388184169e-007
	,1.814518433e-007
	,2.374149906e-007
	,3.107161872e-007
	,4.064721038e-007
	,5.311596214e-007
	,6.928958259e-007
	,9.017335913e-007
	,1.169951876e-006
	,1.512309177e-006
	,1.946219470e-006
	,2.491807063e-006
	,3.171792728e-006
	,4.011175970e-006
	,5.036711720e-006
	,6.276187969e-006
	,7.757586643e-006
	,9.508189533e-006
	,1.155373841e-005
	,1.391773264e-005
	,1.662093792e-005
	,1.968113437e-005
	,-1.440089802e-004
	,-1.307764908e-004
	,-1.180155097e-004
	,-1.058267045e-004
	,-9.425149320e-005
	,-8.328615434e-005
	,-7.289177727e-005
	,-6.302154521e-005
	,-5.378313945e-005
	,-4.529750516e-005
	,-3.761686974e-005
	,-3.078384168e-005
	,-2.481189761e-005
	,-1.968486129e-005
	,-1.536470377e-005
	,-1.179017073e-005
	,-8.877523957e-006
	,-6.575950678e-006
	,-4.809466447e-006
	,-3.477783942e-006
	,-2.490425397e-006
	,-1.769835251e-006
	,-1.250123814e-006
	,-8.787145265e-007
	,-6.152057393e-007
	,-4.293139281e-007
	,-2.987594618e-007
	,-2.073834409e-007
	,-1.435826082e-007
	,-9.905150175e-008
	,-6.809754492e-008
	,-4.664264095e-008
	,-3.177926078e-008
	,-2.148393665e-008
	,-1.435235473e-008
	,-9.410905620e-009
	,-5.985037661e-009
	,-3.607630079e-009
	,-1.955332879e-009
	,-8.043887822e-010
	,-7.310461482e-018
	,5.648990255e-010
	,9.643442865e-010
	,1.249521674e-009
	,1.455812143e-009
	,1.607667211e-009
	,1.721981200e-009
	,1.810423599e-009
	,1.881052472e-009
	,1.939429230e-009
	,1.989389577e-009
	,2.033576250e-009
	,2.073807046e-009
	,2.111329342e-009
	,2.146995432e-009
	,2.181384103e-009
	,2.214884454e-009
	,2.247753626e-009
	,2.280157201e-009
	,2.312196392e-009
	,2.343927876e-009
	,2.375376530e-009
	,2.406544983e-009
	,2.437419990e-009
	,2.467976735e-009
	,2.498182241e-009
	,2.527997593e-009
	,2.557379954e-009
	,2.586284361e-009
	,2.614665535e-009
	,2.642479976e-009
	,2.669688190e-009
	,2.696257703e-009
	,2.722165605e-009
	,2.747402247e-009
	,2.771973903e-009
	,2.795904997e-009
	,2.819238203e-009
	,2.842032594e-009
	,2.864359721e-009
	,2.886298052e-009
	,2.907926777e-009
	,2.929321268e-009
	,2.950549377e-009
	,2.971669565e-009
	,2.992730565e-009
	,3.013772026e-009
	,3.034825676e-009
	,3.055916268e-009
	,3.077063314e-009
	,3.098281934e-009
	,3.119583816e-009
	,3.140977846e-009
	,3.162471150e-009
	,3.184069116e-009
	,3.205776058e-009
	,3.227595353e-009
	,3.249529585e-009
	,3.271580908e-009
	,3.293751095e-009
	,3.316041480e-009
	,3.338453258e-009
	,3.360987311e-009
	,3.383644436e-009
	,3.406425304e-009
	,3.429330396e-009
	,3.452360190e-009
	,3.475515035e-009
	,3.498795312e-009
	,3.522201215e-009
	,3.545732997e-009
	,3.569390750e-009
	,3.593174780e-009
	,3.617085038e-009
	,3.641121822e-009
	,3.665285075e-009
	,3.689575116e-009
	,3.713991718e-009
	,3.738535175e-009
	,3.763205583e-009
	,3.788002976e-009
	,3.812927603e-009
	,3.837979506e-009
	,3.863158946e-009
	,3.888466158e-009
	,3.913901497e-009
	,3.939465243e-009
	,3.965157989e-009
	,3.990980168e-009
	,4.016932512e-009
	,4.043015732e-009
	,4.069230961e-009
	,4.095579091e-009
	,4.122061592e-009
	,4.148680085e-009
	,4.175436667e-009
	,4.202333548e-009
	,4.229373775e-009
	,4.256560957e-009
	,4.283899591e-009
	,4.311386604e-009
	,4.339033173e-009
	,4.366846625e-009
	,4.394836237e-009
	,4.423013904e-009
	,4.451395168e-009
	,4.480000182e-009
	,4.508853956e-009
	,4.537991835e-009
	,4.567459873e-009
	,4.597312085e-009
	,4.627535018e-009
	,4.658266887e-009
	,4.689617077e-009
	,4.721728968e-009
	,4.754789928e-009
	,4.789046193e-009
	,4.824821205e-009
	,4.862529462e-009
	,4.902735781e-009
	,4.946175491e-009
	,4.993817490e-009
	,5.046939338e-009
	,5.107226433e-009
	,5.176905346e-009
	,5.258916352e-009
	,5.357144636e-009
	,5.476726227e-009
	,5.624422114e-009
	,5.809195056e-009
	,6.042945004e-009
	,6.341393980e-009
	,6.725359508e-009
	,7.222388546e-009
	,7.869024133e-009
	,8.713682031e-009
	,9.820556717e-009
	,1.127480902e-008
	,1.318949350e-008
	,1.566819116e-008
	,1.891880573e-008
	,2.320354052e-008
	,2.885391862e-008
	,3.630695952e-008
	,4.613798554e-008
	,5.910292337e-008
	,7.619333912e-008
	,9.870752787e-008
	,1.283390338e-007
	,1.672895459e-007
	,2.184087624e-007
	,2.853653924e-007
	,3.728520153e-007
	,4.868241324e-007
	,6.347698291e-007
	,8.260008671e-007
	,1.071946588e-006
	,1.386424443e-006
	,1.785845683e-006
	,2.289326127e-006
	,2.918643322e-006
	,-1.475996878e-004
	,-1.340848391e-004
	,-1.210885257e-004
	,-1.086754233e-004
	,-9.684623605e-005
	,-8.555158719e-005
	,-7.473378136e-005
	,-6.451297736e-005
	,-5.502720445e-005
	,-4.632828512e-005
	,-3.846262064e-005
	,-3.146949916e-005
	,-2.535591328e-005
	,-2.010334173e-005
	,-1.566707236e-005
	,-1.197644098e-005
	,-8.991676160e-006
	,-6.654345163e-006
	,-4.862996161e-006
	,-3.513299871e-006
	,-2.514524293e-006
	,-1.786378864e-006
	,-1.261528821e-006
	,-8.866047217e-007
	,-6.206843073e-007
	,-4.331312163e-007
	,-3.014252893e-007
	,-2.092342838e-007
	,-1.447629999e-007
	,-9.983959566e-008
	,-6.866746147e-008
	,-4.705479366e-008
	,-3.207522461e-008
	,-2.169438103e-008
	,-1.449995618e-008
	,-9.512362307e-009
	,-6.052590315e-009
	,-3.650214989e-009
	,-1.979449473e-009
	,-8.147469395e-010
	,-7.937057916e-018
	,5.728130834e-010
	,9.784249638e-010
	,1.268528645e-009
	,1.478874207e-009
	,1.634181857e-009
	,1.751542015e-009
	,1.842768297e-009
	,1.916024945e-009
	,1.976952742e-009
	,2.029447940e-009
	,2.076200333e-009
	,2.119065569e-009
	,2.159322460e-009
	,2.197850616e-009
	,2.235253400e-009
	,2.271942626e-009
	,2.308197118e-009
	,2.344202982e-009
	,2.380081834e-009
	,2.415909383e-009
	,2.451729272e-009
	,2.487562015e-009
	,2.523411254e-009
	,2.559268417e-009
	,2.595115655e-009
	,2.630928353e-009
	,2.666676363e-009
	,2.702325456e-009
	,2.737837934e-009
	,2.773173267e-009
	,2.808288214e-009
	,2.843137049e-009
	,2.877671728e-009
	,2.911842373e-009
	,2.945597432e-009
	,2.978884584e-009
	,3.011651760e-009
	,3.043848779e-009
	,3.075428747e-009
	,3.106350396e-009
	,3.136580683e-009
	,3.166097678e-009
	,3.194893919e-009
	,3.222979215e-009
	,3.250382674e-009
	,3.277153004e-009
	,3.303355920e-009
	,3.329070111e-009
	,3.354380933e-009
	,3.379374628e-009
	,3.404132351e-009
	,3.428727124e-009
	,3.453221672e-009
	,3.477668211e-009
	,3.502109060e-009
	,3.526577972e-009
	,3.551101363e-009
	,3.575699746e-009
	,3.600388978e-009
	,3.625181309e-009
	,3.650086086e-009
	,3.675110599e-009
	,3.700260447e-009
	,3.725539934e-009
	,3.750952541e-009
	,3.776500871e-009
	,3.802187163e-009
	,3.828012920e-009
	,3.853979617e-009
	,3.880088268e-009
	,3.906339755e-009
	,3.932734826e-009
	,3.959274053e-009
	,3.985957884e-009
	,4.012786602e-009
	,4.039760724e-009
	,4.066880476e-009
	,4.094146077e-009
	,4.121557671e-009
	,4.149115417e-009
	,4.176819477e-009
	,4.204669952e-009
	,4.232666934e-009
	,4.260810537e-009
	,4.289100855e-009
	,4.317538039e-009
	,4.346122213e-009
	,4.374853557e-009
	,4.403732259e-009
	,4.432758538e-009
	,4.461932671e-009
	,4.491255037e-009
	,4.520726047e-009
	,4.550346208e-009
	,4.580116251e-009
	,4.610036989e-009
	,4.640109250e-009
	,4.670334294e-009
	,4.700713206e-009
	,4.731247452e-009
	,4.761938679e-009
	,4.792788736e-009
	,4.823799851e-009
	,4.854974620e-009
	,4.886316126e-009
	,4.917824101e-009
	,4.949503511e-009
	,4.981359562e-009
	,5.013397344e-009
	,5.045623517e-009
	,5.078045800e-009
	,5.110674347e-009
	,5.143521744e-009
	,5.176604522e-009
	,5.209944102e-009
	,5.243568901e-009
	,5.277481313e-009
	,5.311722071e-009
	,5.346348963e-009
	,5.381423272e-009
	,5.417019602e-009
	,5.453246888e-009
	,5.490238513e-009
	,5.528173574e-009
	,5.567284290e-009
	,5.607875364e-009
	,5.650346644e-009
	,5.695223649e-009
	,5.743197668e-009
	,5.795178629e-009
	,5.852365015e-009
	,5.916336222e-009
	,5.989175786e-009
	,6.073611698e-009
	,6.173254742e-009
	,6.292906925e-009
	,6.438888925e-009
	,6.619555479e-009
	,6.845953499e-009
	,7.132692604e-009
	,7.499116433e-009
	,7.970833060e-009
	,8.581766656e-009
	,9.376886366e-009
	,1.041562860e-008
	,1.177716081e-008
	,1.352738001e-008
	,1.581099325e-008
	,1.881304706e-008
	,2.276333419e-008
	,2.796479127e-008
	,3.481668840e-008
	,4.384438259e-008
	,5.573814594e-008
	,7.140332811e-008
	,9.202473337e-008
	,1.191486504e-007
	,1.547864037e-007
	,2.015435388e-007
	,2.627786980e-007
	,-1.504596156e-004
	,-1.367630737e-004
	,-1.236138250e-004
	,-1.110248664e-004
	,-9.893946327e-005
	,-8.727999442e-005
	,-7.615864695e-005
	,-6.573254153e-005
	,-5.606437880e-005
	,-4.719358680e-005
	,-3.917625466e-005
	,-3.204691294e-005
	,-2.580900389e-005
	,-2.043636587e-005
	,-1.587652669e-005
	,-1.210367804e-005
	,-9.078314710e-006
	,-6.715340075e-006
	,-4.904302989e-006
	,-3.541205243e-006
	,-2.533828698e-006
	,-1.799809418e-006
	,-1.270889446e-006
	,-8.931391694e-007
	,-6.252538241e-007
	,-4.363308107e-007
	,-3.036596791e-007
	,-2.107032874e-007
	,-1.456977327e-007
	,-1.005154240e-007
	,-6.915870241e-008
	,-4.740973575e-008
	,-3.232965370e-008
	,-2.187492604e-008
	,-1.462631910e-008
	,-9.599033820e-009
	,-6.110174270e-009
	,-3.686437658e-009
	,-1.999919166e-009
	,-8.235201088e-010
	,3.023310817e-017
	,5.794878478e-010
	,9.902755823e-010
	,1.284490870e-009
	,1.498199190e-009
	,1.656349046e-009
	,1.776196455e-009
	,1.869675219e-009
	,1.945037224e-009
	,2.007987426e-009
	,2.062469609e-009
	,2.111209357e-009
	,2.156089834e-009
	,2.198411681e-009
	,2.239072727e-009
	,2.278692160e-009
	,2.317696135e-009
	,2.356377323e-009
	,2.394935604e-009
	,2.433506387e-009
	,2.472179898e-009
	,2.511014896e-009
	,2.550047449e-009
	,2.589297344e-009
	,2.628772579e-009
	,2.668471950e-009
	,2.708387276e-009
	,2.748504803e-009
	,2.788805881e-009
	,2.829267867e-009
	,2.869864606e-009
	,2.910566960e-009
	,2.951343001e-009
	,2.992158624e-009
	,3.032977641e-009
	,3.073762083e-009
	,3.114472394e-009
	,3.155067250e-009
	,3.195503418e-009
	,3.235735676e-009
	,3.275716386e-009
	,3.315395676e-009
	,3.354721187e-009
	,3.393638663e-009
	,3.432092585e-009
	,3.470027036e-009
	,3.507386930e-009
	,3.544119610e-009
	,3.580176197e-009
	,3.615514201e-009
	,3.650100192e-009
	,3.683912965e-009
	,3.716946839e-009
	,3.749214855e-009
	,3.780750593e-009
	,3.811608529e-009
	,3.841861291e-009
	,3.871595213e-009
	,3.900903698e-009
	,3.929880710e-009
	,3.958614917e-009
	,3.987186076e-009
	,4.015662476e-009
	,4.044100869e-009
	,4.072547188e-009
	,4.101038027e-009
	,4.129601716e-009
	,4.158260604e-009
	,4.187031652e-009
	,4.215927816e-009
	,4.244959263e-009
	,4.274133536e-009
	,4.303456569e-009
	,4.332932871e-009
	,4.362565950e-009
	,4.392358514e-009
	,4.422312566e-009
	,4.452429843e-009
	,4.482711761e-009
	,4.513159396e-009
	,4.543773607e-009
	,4.574555162e-009
	,4.605504411e-009
	,4.636621910e-009
	,4.667908142e-009
	,4.699363299e-009
	,4.730987669e-009
	,4.762781500e-009
	,4.794744911e-009
	,4.826878083e-009
	,4.859181194e-009
	,4.891654283e-009
	,4.924297715e-009
	,4.957111428e-009
	,4.990095822e-009
	,5.023251085e-009
	,5.056577493e-009
	,5.090075427e-009
	,5.123745318e-009
	,5.157587616e-009
	,5.191602981e-009
	,5.225792057e-009
	,5.260155649e-009
	,5.294694711e-009
	,5.329410264e-009
	,5.364303512e-009
	,5.399375869e-009
	,5.434628819e-009
	,5.470064218e-009
	,5.505683884e-009
	,5.541490206e-009
	,5.577485751e-009
	,5.613672157e-009
	,5.650051970e-009
	,5.686629392e-009
	,5.723408113e-009
	,5.760392590e-009
	,5.797587799e-009
	,5.834999928e-009
	,5.872635613e-009
	,5.910503614e-009
	,5.948615021e-009
	,5.986983848e-009
	,6.025620809e-009
	,6.064533112e-009
	,6.103752382e-009
	,6.143306979e-009
	,6.183232942e-009
	,6.223576485e-009
	,6.264396804e-009
	,6.305771178e-009
	,6.347799508e-009
	,6.390611969e-009
	,6.434378343e-009
	,6.479318364e-009
	,6.525707335e-009
	,6.573934429e-009
	,6.624496089e-009
	,6.678044163e-009
	,6.735427933e-009
	,6.797777003e-009
	,6.866574690e-009
	,6.943773992e-009
	,7.031948227e-009
	,7.134491484e-009
	,7.255882132e-009
	,7.402032279e-009
	,7.580750955e-009
	,7.802357052e-009
	,8.080496038e-009
	,8.433222935e-009
	,8.884234955e-009
	,9.465296145e-009
	,1.021839360e-008
	,1.119929322e-008
	,1.244887852e-008
	,1.406777257e-008
	,1.618774043e-008
	,1.896850989e-008
	,2.262072618e-008
	,2.742197960e-008
	,-1.529534450e-004
	,-1.390982164e-004
	,-1.257847757e-004
	,-1.129636063e-004
	,-1.005375443e-004
	,-8.859181693e-005
	,-7.729579209e-005
	,-6.672551412e-005
	,-5.691407294e-005
	,-4.791051981e-005
	,-3.977347697e-005
	,-3.253078283e-005
	,-2.617618128e-005
	,-2.067535489e-005
	,-1.602759092e-005
	,-1.220363639e-005
	,-9.149962019e-006
	,-6.765953460e-006
	,-4.938447079e-006
	,-3.564712126e-006
	,-2.550237469e-006
	,-1.811280999e-006
	,-1.278910937e-006
	,-8.987518030e-007
	,-6.291844503e-007
	,-4.390819713e-007
	,-3.055454490e-007
	,-2.118469127e-007
	,-1.465091005e-007
	,-1.011077173e-007
	,-6.958909609e-008
	,-4.772032170e-008
	,-3.255196825e-008
	,-2.203244957e-008
	,-1.473640521e-008
	,-9.674428316e-009
	,-6.160190767e-009
	,-3.717852999e-009
	,-2.017645654e-009
	,-8.311062295e-010
	,1.879619546e-018
	,5.852425202e-010
	,1.000477734e-009
	,1.298213314e-009
	,1.514789350e-009
	,1.675353003e-009
	,1.797303965e-009
	,1.892679764e-009
	,1.969807392e-009
	,2.034446568e-009
	,2.090580610e-009
	,2.140964330e-009
	,2.187502454e-009
	,2.231512152e-009
	,2.273903928e-009
	,2.315307207e-009
	,2.356157006e-009
	,2.396753884e-009
	,2.437305305e-009
	,2.477954262e-009
	,2.518798921e-009
	,2.559906339e-009
	,2.601321674e-009
	,2.643074751e-009
	,2.685184367e-009
	,2.727660964e-009
	,2.770509275e-009
	,2.813728983e-009
	,2.857315943e-009
	,2.901262718e-009
	,2.945558671e-009
	,2.990190403e-009
	,3.035141698e-009
	,3.080393581e-009
	,3.125924438e-009
	,3.171710013e-009
	,3.217723542e-009
	,3.263935848e-009
	,3.310315575e-009
	,3.356829471e-009
	,3.403442582e-009
	,3.450118648e-009
	,3.496820285e-009
	,3.543508837e-009
	,3.590144319e-009
	,3.636685102e-009
	,3.683087675e-009
	,3.729305900e-009
	,3.775291043e-009
	,3.820991416e-009
	,3.866352433e-009
	,3.911317122e-009
	,3.955826736e-009
	,3.999821482e-009
	,4.043241691e-009
	,4.086028974e-009
	,4.128127326e-009
	,4.169485342e-009
	,4.210058559e-009
	,4.249811869e-009
	,4.288723685e-009
	,4.326788991e-009
	,4.364023272e-009
	,4.400464356e-009
	,4.436172288e-009
	,4.471227232e-009
	,4.505723970e-009
	,4.539765108e-009
	,4.573453915e-009
	,4.606888135e-009
	,4.640155225e-009
	,4.673330514e-009
	,4.706476777e-009
	,4.739644464e-009
	,4.772873857e-009
	,4.806196421e-009
	,4.839636341e-009
	,4.873212434e-009
	,4.906938807e-009
	,4.940826383e-009
	,4.974883557e-009
	,5.009116553e-009
	,5.043530289e-009
	,5.078128570e-009
	,5.112914081e-009
	,5.147889186e-009
	,5.183055564e-009
	,5.218414561e-009
	,5.253967117e-009
	,5.289714150e-009
	,5.325656040e-009
	,5.361793507e-009
	,5.398127050e-009
	,5.434657041e-009
	,5.471383750e-009
	,5.508307390e-009
	,5.545428155e-009
	,5.582746345e-009
	,5.620262131e-009
	,5.657975750e-009
	,5.695887492e-009
	,5.733997713e-009
	,5.772306650e-009
	,5.810814811e-009
	,5.849522639e-009
	,5.888430711e-009
	,5.927539786e-009
	,5.966850454e-009
	,6.006363784e-009
	,6.046080742e-009
	,6.086002411e-009
	,6.126130232e-009
	,6.166465536e-009
	,6.207010117e-009
	,6.247765649e-009
	,6.288734348e-009
	,6.329918346e-009
	,6.371320013e-009
	,6.412941944e-009
	,6.454786277e-009
	,6.496856809e-009
	,6.539156890e-009
	,6.581690269e-009
	,6.624461064e-009
	,6.667473855e-009
	,6.710733814e-009
	,6.754246821e-009
	,6.798019756e-009
	,6.842060733e-009
	,6.886379741e-009
	,6.930978793e-009
	,6.975874858e-009
	,7.021082809e-009
	,7.066618767e-009
	,7.112504439e-009
	,7.158768727e-009
	,7.205446800e-009
	,7.252583149e-009
	,7.300235401e-009
	,7.348477580e-009
	,7.397405721e-009
	,7.447144230e-009
	,7.497854999e-009
	,7.549749168e-009
	,7.603101911e-009
	,7.658273118e-009
	,7.715735990e-009
	,7.776110285e-009
	,7.840205165e-009
	,7.909044639e-009
	,7.984058026e-009
	,8.067085223e-009
	,8.160549143e-009
	,8.267642305e-009
	,8.392573014e-009
	,8.540871335e-009
	,8.719863171e-009
	,8.939233360e-009
	,9.211774040e-009
	,9.554411799e-009
	,9.989569911e-009
	,-1.552370939e-004
	,-1.412223083e-004
	,-1.276943937e-004
	,-1.145461557e-004
	,-1.018215225e-004
	,-8.969790255e-005
	,-7.826751562e-005
	,-6.756790463e-005
	,-5.762989150e-005
	,-4.851486876e-005
	,-4.027500742e-005
	,-3.292324828e-005
	,-2.643925049e-005
	,-2.084991804e-005
	,-1.614264926e-005
	,-1.228539067e-005
	,-9.210113551e-006
	,-6.808264447e-006
	,-4.967313417e-006
	,-3.584926711e-006
	,-2.564464499e-006
	,-1.821277935e-006
	,-1.285925464e-006
	,-9.036710695e-007
	,-6.326328354e-007
	,-4.414858910e-007
	,-3.070675428e-007
	,-2.128367340e-007
	,-1.472321189e-007
	,-1.016357582e-007
	,-6.997227641e-008
	,-4.799639502e-008
	,-3.274925999e-008
	,-2.217202077e-008
	,-1.483379338e-008
	,-9.741024651e-009
	,-6.204304650e-009
	,-3.745520264e-009
	,-2.033234840e-009
	,-8.377683529e-010
	,1.529922650e-017
	,5.902826689e-010
	,1.009401812e-009
	,1.310201824e-009
	,1.529266153e-009
	,1.691917662e-009
	,1.815682753e-009
	,1.912690558e-009
	,1.991334268e-009
	,2.057421312e-009
	,2.114969867e-009
	,2.166759813e-009
	,2.214714409e-009
	,2.260164295e-009
	,2.304030118e-009
	,2.346949009e-009
	,2.389361999e-009
	,2.431574457e-009
	,2.473798251e-009
	,2.516180156e-009
	,2.558822356e-009
	,2.601795924e-009
	,2.645150431e-009
	,2.688920549e-009
	,2.733130413e-009
	,2.777796753e-009
	,2.822931049e-009
	,2.868540780e-009
	,2.914630464e-009
	,2.961202034e-009
	,3.008255329e-009
	,3.055788547e-009
	,3.103797755e-009
	,3.152277378e-009
	,3.201219932e-009
	,3.250615969e-009
	,3.300453944e-009
	,3.350720232e-009
	,3.401398684e-009
	,3.452471089e-009
	,3.503916578e-009
	,3.555711981e-009
	,3.607831530e-009
	,3.660247017e-009
	,3.712928237e-009
	,3.765842977e-009
	,3.818957469e-009
	,3.872236706e-009
	,3.925644563e-009
	,3.979144302e-009
	,4.032698344e-009
	,4.086268109e-009
	,4.139813703e-009
	,4.193293232e-009
	,4.246662280e-009
	,4.299873400e-009
	,4.352876101e-009
	,4.405616648e-009
	,4.458038099e-009
	,4.510080371e-009
	,4.561681244e-009
	,4.612777251e-009
	,4.663304334e-009
	,4.713198496e-009
	,4.762397450e-009
	,4.810841203e-009
	,4.858474536e-009
	,4.905249583e-009
	,4.951128829e-009
	,4.996089352e-009
	,5.040126442e-009
	,5.083257233e-009
	,5.125522948e-009
	,5.166988849e-009
	,5.207742393e-009
	,5.247887792e-009
	,5.287538062e-009
	,5.326807327e-009
	,5.365803908e-009
	,5.404625111e-009
	,5.443355013e-009
	,5.482063510e-009
	,5.520807220e-009
	,5.559631131e-009
	,5.598570258e-009
	,5.637651877e-009
	,5.676896608e-009
	,5.716320427e-009
	,5.755935327e-009
	,5.795750492e-009
	,5.835772941e-009
	,5.876007848e-009
	,5.916459330e-009
	,5.957130392e-009
	,5.998023499e-009
	,6.039140448e-009
	,6.080482524e-009
	,6.122050609e-009
	,6.163845497e-009
	,6.205868116e-009
	,6.248119127e-009
	,6.290598964e-009
	,6.333307983e-009
	,6.376246621e-009
	,6.419415074e-009
	,6.462813742e-009
	,6.506443055e-009
	,6.550303300e-009
	,6.594394931e-009
	,6.638718410e-009
	,6.683274344e-009
	,6.728063462e-009
	,6.773086526e-009
	,6.818344348e-009
	,6.863837921e-009
	,6.909568370e-009
	,6.955537027e-009
	,7.001745161e-009
	,7.048194262e-009
	,7.094886036e-009
	,7.141822551e-009
	,7.189005968e-009
	,7.236438937e-009
	,7.284124225e-009
	,7.332064977e-009
	,7.380263822e-009
	,7.428724575e-009
	,7.477450823e-009
	,7.526446329e-009
	,7.575715227e-009
	,7.625261870e-009
	,7.675090806e-009
	,7.725207047e-009
	,7.775616200e-009
	,7.826324222e-009
	,7.877338095e-009
	,7.928663362e-009
	,7.980307579e-009
	,8.032280917e-009
	,8.084594021e-009
	,8.137259350e-009
	,8.190292106e-009
	,8.243710279e-009
	,8.297536396e-009
	,8.351798442e-009
	,8.406530658e-009
	,8.461777921e-009
	,8.517593395e-009
	,8.574045863e-009
	,8.631231318e-009
	,8.689269033e-009
	,8.748314293e-009
	,8.808568313e-009
	,8.870293846e-009
	,8.933834370e-009
	,8.999639105e-009
	,9.068296202e-009
	,9.140577056e-009
	,9.217493994e-009
	,9.300376958e-009
	,9.390972517e-009
	,-1.573649990e-004
	,-1.431568698e-004
	,-1.293262571e-004
	,-1.158663649e-004
	,-1.029528974e-004
	,-9.069657604e-005
	,-7.914498345e-005
	,-6.832228599e-005
	,-5.826903204e-005
	,-4.905161562e-005
	,-4.070491732e-005
	,-3.321926672e-005
	,-2.664012266e-005
	,-2.098939669e-005
	,-1.623693741e-005
	,-1.235549337e-005
	,-9.261980263e-006
	,-6.844352944e-006
	,-4.992339856e-006
	,-3.602643976e-006
	,-2.577004390e-006
	,-1.830123420e-006
	,-1.292149573e-006
	,-9.080442485e-007
	,-6.356986515e-007
	,-4.435863949e-007
	,-3.083138148e-007
	,-2.137276855e-007
	,-1.478859467e-007
	,-1.021129399e-007
	,-7.031811976e-008
	,-4.824523488e-008
	,-3.292684917e-008
	,-2.229748300e-008
	,-1.492121737e-008
	,-9.800725052e-009
	,-6.243795608e-009
	,-3.770253405e-009
	,-2.047151058e-009
	,-8.437069605e-010
	,2.819514196e-018
	,5.947625179e-010
	,1.017322441e-009
	,1.320827285e-009
	,1.542079262e-009
	,1.706558981e-009
	,1.831906772e-009
	,1.930333939e-009
	,2.010292979e-009
	,2.077634397e-009
	,2.136407516e-009
	,2.189415067e-009
	,2.238596954e-009
	,2.285295952e-009
	,2.330441769e-009
	,2.374678191e-009
	,2.418451203e-009
	,2.462070142e-009
	,2.505749651e-009
	,2.549639041e-009
	,2.593842355e-009
	,2.638432633e-009
	,2.683461269e-009
	,2.728964915e-009
	,2.774969970e-009
	,2.821495802e-009
	,2.868556886e-009
	,2.916164293e-009
	,2.964326589e-009
	,3.013050556e-009
	,3.062341694e-009
	,3.112204099e-009
	,3.162641088e-009
	,3.213654760e-009
	,3.265246414e-009
	,3.317416072e-009
	,3.370162770e-009
	,3.423484135e-009
	,3.477376752e-009
	,3.531835519e-009
	,3.586853716e-009
	,3.642422880e-009
	,3.698532382e-009
	,3.755169806e-009
	,3.812320251e-009
	,3.869966581e-009
	,3.928089175e-009
	,3.986665815e-009
	,4.045671858e-009
	,4.105080206e-009
	,4.164861347e-009
	,4.224983628e-009
	,4.285413618e-009
	,4.346117311e-009
	,4.407059958e-009
	,4.468206010e-009
	,4.529519471e-009
	,4.590963832e-009
	,4.652502094e-009
	,4.714096084e-009
	,4.775706007e-009
	,4.837289570e-009
	,4.898801267e-009
	,4.960191789e-009
	,5.021408040e-009
	,5.082392640e-009
	,5.143084991e-009
	,5.203421383e-009
	,5.263336114e-009
	,5.322761648e-009
	,5.381629729e-009
	,5.439871729e-009
	,5.497418855e-009
	,5.554203462e-009
	,5.610160547e-009
	,5.665229734e-009
	,5.719358414e-009
	,5.772505495e-009
	,5.824645571e-009
	,5.875773030e-009
	,5.925905732e-009
	,5.975088185e-009
	,6.023391280e-009
	,6.070910314e-009
	,6.117758962e-009
	,6.164061538e-009
	,6.209944978e-009
	,6.255530586e-009
	,6.300927925e-009
	,6.346231530e-009
	,6.391520361e-009
	,6.436858556e-009
	,6.482296916e-009
	,6.527875391e-009
	,6.573624614e-009
	,6.619568146e-009
	,6.665723872e-009
	,6.712105331e-009
	,6.758722804e-009
	,6.805583993e-009
	,6.852694699e-009
	,6.900059290e-009
	,6.947680893e-009
	,6.995562039e-009
	,7.043704557e-009
	,7.092109441e-009
	,7.140778281e-009
	,7.189712746e-009
	,7.238913802e-009
	,7.288382320e-009
	,7.338118959e-009
	,7.388124230e-009
	,7.438398744e-009
	,7.488943013e-009
	,7.539757701e-009
	,7.590843420e-009
	,7.642200864e-009
	,7.693830902e-009
	,7.745734482e-009
	,7.797912614e-009
	,7.850366515e-009
	,7.903097519e-009
	,7.956107180e-009
	,8.009397243e-009
	,8.062969659e-009
	,8.116826672e-009
	,8.170970513e-009
	,8.225403746e-009
	,8.280129271e-009
	,8.335150054e-009
	,8.390469342e-009
	,8.446090446e-009
	,8.502017115e-009
	,8.558253379e-009
	,8.614803442e-009
	,8.671671564e-009
	,8.728862409e-009
	,8.786380816e-009
	,8.844231997e-009
	,8.902421213e-009
	,8.960954237e-009
	,9.019837034e-009
	,9.079075987e-009
	,9.138676790e-009
	,9.198647560e-009
	,9.258995865e-009
	,9.319730591e-009
	,9.380861578e-009
	,9.442400290e-009
	,9.504359645e-009
	,9.566755066e-009
	,9.629605093e-009
	,9.692932083e-009
	,9.756763707e-009
	,9.821134505e-009
	,9.886087773e-009
	,9.951678527e-009
	,1.001797658e-008
	,1.008507272e-008
	,1.015308343e-008
	,1.022215990e-008
	,-1.593394839e-004
	,-1.448615948e-004
	,-1.307114531e-004
	,-1.170463991e-004
	,-1.039984903e-004
	,-9.162636967e-005
	,-7.995934853e-005
	,-6.901899348e-005
	,-5.885831930e-005
	,-4.953374522e-005
	,-4.104868459e-005
	,-3.345496792e-005
	,-2.681311550e-005
	,-2.110715411e-005
	,-1.632068765e-005
	,-1.241888999e-005
	,-9.308458630e-006
	,-6.876405562e-006
	,-5.014841827e-006
	,-3.618632109e-006
	,-2.588331569e-006
	,-1.838116796e-006
	,-1.297775138e-006
	,-9.119957977e-007
	,-6.384595736e-007
	,-4.453589180e-007
	,-3.094253551e-007
	,-2.145428535e-007
	,-1.484843005e-007
	,-1.025491384e-007
	,-7.063387072e-008
	,-4.847215280e-008
	,-3.308860876e-008
	,-2.241163559e-008
	,-1.500067372e-008
	,-9.854925378e-009
	,-6.279609021e-009
	,-3.792658076e-009
	,-2.059742684e-009
	,-8.490739698e-010
	,-2.323645417e-017
	,5.988011622e-010
	,1.024453828e-009
	,1.330381317e-009
	,1.553584731e-009
	,1.719688087e-009
	,1.846434909e-009
	,1.946111018e-009
	,2.027222931e-009
	,2.095660176e-009
	,2.155500559e-009
	,2.209567677e-009
	,2.259816769e-009
	,2.307602086e-009
	,2.353861949e-009
	,2.399246656e-009
	,2.444207223e-009
	,2.489056873e-009
	,2.534013102e-009
	,2.579227609e-009
	,2.624806357e-009
	,2.670823729e-009
	,2.717332279e-009
	,2.764369606e-009
	,2.811963072e-009
	,2.860132837e-009
	,2.908894404e-009
	,2.958260009e-009
	,3.008239665e-009
	,3.058841970e-009
	,3.110074499e-009
	,3.161944233e-009
	,3.214457482e-009
	,3.267620394e-009
	,3.321438418e-009
	,3.375916777e-009
	,3.431060177e-009
	,3.486873054e-009
	,3.543358959e-009
	,3.600520868e-009
	,3.658360972e-009
	,3.716880318e-009
	,3.776079053e-009
	,3.835956125e-009
	,3.896509105e-009
	,3.957734163e-009
	,4.019625786e-009
	,4.082176751e-009
	,4.145377767e-009
	,4.209217211e-009
	,4.273681296e-009
	,4.338754453e-009
	,4.404418982e-009
	,4.470654180e-009
	,4.537436657e-009
	,4.604740395e-009
	,4.672536891e-009
	,4.740795446e-009
	,4.809483541e-009
	,4.878567226e-009
	,4.948011592e-009
	,5.017781134e-009
	,5.087840275e-009
	,5.158153690e-009
	,5.228686021e-009
	,5.299401732e-009
	,5.370264615e-009
	,5.441236778e-009
	,5.512277994e-009
	,5.583344607e-009
	,5.654388749e-009
	,5.725358162e-009
	,5.796195929e-009
	,5.866840876e-009
	,5.937228183e-009
	,6.007290059e-009
	,6.076957083e-009
	,6.146157960e-009
	,6.214820512e-009
	,6.282871464e-009
	,6.350236697e-009
	,6.416841551e-009
	,6.482611636e-009
	,6.547474885e-009
	,6.611364238e-009
	,6.674220868e-009
	,6.735998581e-009
	,6.796667925e-009
	,6.856220695e-009
	,6.914674867e-009
	,6.972077108e-009
	,7.028504109e-009
	,7.084059807e-009
	,7.138869627e-009
	,7.193071773e-009
	,7.246807543e-009
	,7.300212324e-009
	,7.353409025e-009
	,7.406505823e-009
	,7.459593495e-009
	,7.512745591e-009
	,7.566020523e-009
	,7.619463905e-009
	,7.673111214e-009
	,7.726989357e-009
	,7.781118887e-009
	,7.835515445e-009
	,7.890190708e-009
	,7.945153717e-009
	,8.000411038e-009
	,8.055967840e-009
	,8.111827792e-009
	,8.167993427e-009
	,8.224466327e-009
	,8.281249279e-009
	,8.338344234e-009
	,8.395752423e-009
	,8.453474788e-009
	,8.511512239e-009
	,8.569865606e-009
	,8.628535773e-009
	,8.687523567e-009
	,8.746829934e-009
	,8.806455918e-009
	,8.866402639e-009
	,8.926671430e-009
	,8.987263736e-009
	,9.048181177e-009
	,9.109425510e-009
	,9.170998782e-009
	,9.232903366e-009
	,9.295141633e-009
	,9.357716335e-009
	,9.420630307e-009
	,9.483886868e-009
	,9.547489561e-009
	,9.611442134e-009
	,9.675748558e-009
	,9.740412998e-009
	,9.805440019e-009
	,9.870834290e-009
	,9.936600794e-009
	,1.000274473e-008
	,1.006927151e-008
	,1.013618696e-008
	,1.020349701e-008
	,1.027120784e-008
	,1.033932600e-008
	,1.040785797e-008
	,1.047681039e-008
	,1.054619059e-008
	,1.061600571e-008
	,1.068626395e-008
	,1.075697358e-008
	,1.082814345e-008
	,1.089978342e-008
	,1.097190414e-008
	,1.104451803e-008
	,1.111763873e-008
	,1.119128207e-008
	,1.126546676e-008
	,-1.222656109e-007
	,-9.386616216e-008
	,-7.204092107e-008
	,-5.521746566e-008
	,-4.224890069e-008
	,-3.227246598e-008
	,-2.460227983e-008
	,-1.869897114e-008
	,-1.415605723e-008
	,-1.067359357e-008
	,-8.022439447e-009
	,-6.017476873e-009
	,-4.509875148e-009
	,-3.380877906e-009
	,-2.536777610e-009
	,-1.905423032e-009
	,-1.432378561e-009
	,-1.077141422e-009
	,-8.099947281e-010
	,-6.091705249e-010
	,-4.583161403e-010
	,-3.449775968e-010
	,-2.597642521e-010
	,-1.956598275e-010
	,-1.473877356e-010
	,-1.109713618e-010
	,-8.344300269e-011
	,-6.262603384e-011
	,-4.691393339e-011
	,-3.507468076e-011
	,-2.615293704e-011
	,-1.941895989e-011
	,-1.432765208e-011
	,-1.047671242e-011
	,-7.570718312e-012
	,-5.377642803e-012
	,-3.714984100e-012
	,-2.441299910e-012
	,-1.448912509e-012
	,-6.557783875e-013
	,-4.960724838e-018
	,5.688515516e-013
	,1.091931487e-012
	,1.606888801e-012
	,2.149234227e-012
	,2.757999397e-012
	,3.477178691e-012
	,4.360362396e-012
	,5.474119908e-012
	,6.910179253e-012
	,8.788719643e-012
	,1.127171986e-011
	,1.457904424e-011
	,1.900763949e-011
	,2.493551531e-011
	,3.293282209e-011
	,4.375700271e-011
	,5.844601415e-011
	,7.842327679e-011
	,1.056424844e-010
	,1.427865780e-010
	,1.935415080e-010
	,2.629719100e-010
	,3.580347304e-010
	,4.869256906e-010
	,6.607864229e-010
	,8.962222150e-010
	,1.215710472e-009
	,1.649235211e-009
	,2.229233582e-009
	,3.001104483e-009
	,4.036504091e-009
	,5.421918909e-009
	,7.269855833e-009
	,9.726187759e-009
	,1.297927613e-008
	,1.727158886e-008
	,2.291446463e-008
	,3.030682728e-008
	,3.995883188e-008
	,5.252153015e-008
	,6.882468887e-008
	,8.992393459e-008
	,1.171603558e-007
	,1.522356923e-007
	,1.973070339e-007
	,2.547231408e-007
	,3.277558443e-007
	,4.192322697e-007
	,5.344323854e-007
	,6.795072461e-007
	,8.617214796e-007
	,1.089918637e-006
	,1.375020051e-006
	,1.719398491e-006
	,2.118260174e-006
	,2.590788826e-006
	,3.123719976e-006
	,3.755411821e-006
	,4.505370652e-006
	,5.391877467e-006
	,6.434963066e-006
	,7.656489341e-006
	,9.080113068e-006
	,1.073123360e-005
	,1.263693725e-005
	,1.482595117e-005
	,1.732861764e-005
	,2.017038298e-005
	,2.323101776e-005
	,2.663522545e-005
	,3.041336583e-005
	,3.458481179e-005
	,3.917195291e-005
	,4.408262820e-005
	,4.905869896e-005
	,5.410637928e-005
	,5.886608706e-005
	,6.402513050e-005
	,6.958426442e-005
	,7.554697556e-005
	,8.192049021e-005
	,8.870983454e-005
	,9.592768054e-005
	,1.035763116e-004
	,1.116557398e-004
	,1.201968046e-004
	,1.291630196e-004
	,1.381627418e-004
	,1.475388281e-004
	,1.572460099e-004
	,1.672946890e-004
	,1.773756713e-004
	,1.876350114e-004
	,1.978435407e-004
	,2.077881319e-004
	,2.180567231e-004
	,2.286965678e-004
	,2.397192380e-004
	,2.511382904e-004
	,2.629688198e-004
	,2.748298812e-004
	,2.862752406e-004
	,2.982192403e-004
	,3.106989950e-004
	,3.228681789e-004
	,3.349456485e-004
	,3.474512442e-004
	,3.603930428e-004
	,3.737833115e-004
	,3.876385523e-004
	,4.019798880e-004
	,4.164301296e-004
	,4.294746989e-004
	,4.432398780e-004
	,4.577091118e-004
	,4.725284441e-004
	,4.852615821e-004
	,4.986436019e-004
	,5.126899778e-004
	,5.273232214e-004
	,5.424674970e-004
	,5.576611914e-004
	,5.713059320e-004
	,5.839783525e-004
	,5.971104279e-004
	,6.104293933e-004
	,6.239180885e-004
	,6.377098188e-004
	,6.517749683e-004
	,6.660786945e-004
	,6.779819831e-004
	,6.902136917e-004
	,7.026175969e-004
	,7.150706369e-004
	,7.278204083e-004
	,7.408415225e-004
	,7.541285323e-004
	,7.676882816e-004
	,7.814827349e-004
	,7.954964200e-004
	,8.097226690e-004
	,8.241448858e-004
	,8.387563440e-004
	,8.535411652e-004
	,8.684854439e-004
	,8.836053909e-004
	,8.989314139e-004
	,9.144831045e-004
	,9.302005895e-004
	,9.460834480e-004
	,9.621295988e-004
	,9.783335268e-004
	,9.946930447e-004
	,1.011211104e-003
	,1.027904171e-003
	,1.044750480e-003
	,1.061747340e-003
	,1.078891015e-003
	,1.096176655e-003
	,1.113619675e-003
	,-3.986218075e-007
	,-3.079228142e-007
	,-2.371321981e-007
	,-1.818800253e-007
	,-1.387922505e-007
	,-1.054103429e-007
	,-7.983429926e-008
	,-6.042400871e-008
	,-4.575196505e-008
	,-3.467169075e-008
	,-2.629720643e-008
	,-1.995477261e-008
	,-1.513679674e-008
	,-1.146799601e-008
	,-8.676103050e-009
	,-6.557606167e-009
	,-4.953118188e-009
	,-3.737062384e-009
	,-2.813289149e-009
	,-2.111035489e-009
	,-1.578701391e-009
	,-1.176920639e-009
	,-8.748117733e-010
	,-6.485932990e-010
	,-4.800983174e-010
	,-3.551753522e-010
	,-2.627787266e-010
	,-1.944658041e-010
	,-1.439131718e-010
	,-1.064394236e-010
	,-7.859889474e-011
	,-5.786841870e-011
	,-4.240591511e-011
	,-3.085516450e-011
	,-2.220475824e-011
	,-1.569937093e-011
	,-1.077627988e-011
	,-7.017797609e-012
	,-4.113597703e-012
	,-1.832106044e-012
	,-5.117373949e-018
	,1.512076876e-012
	,2.801145313e-012
	,3.940569834e-012
	,4.988901540e-012
	,5.994889896e-012
	,7.000588555e-012
	,8.039678434e-012
	,9.150580128e-012
	,1.037224679e-011
	,1.174917183e-011
	,1.332119691e-011
	,1.516178889e-011
	,1.736623321e-011
	,2.003881373e-011
	,2.337994601e-011
	,2.761278199e-011
	,3.306333874e-011
	,4.014460686e-011
	,4.943306206e-011
	,6.171692361e-011
	,7.806195241e-011
	,9.990524685e-011
	,1.292327917e-010
	,1.687465078e-010
	,2.221397312e-010
	,2.944656088e-010
	,3.926422123e-010
	,5.261431253e-010
	,7.079480764e-010
	,9.557921000e-010
	,1.294047377e-009
	,1.756055673e-009
	,2.387424203e-009
	,3.250458708e-009
	,4.430106341e-009
	,6.041874988e-009
	,8.242299650e-009
	,1.123164687e-008
	,1.526920240e-008
	,2.071429351e-008
	,2.805090140e-008
	,3.789945322e-008
	,5.106624506e-008
	,6.859395046e-008
	,9.182539578e-008
	,1.224839831e-007
	,1.627747835e-007
	,2.155111622e-007
	,2.842729415e-007
	,3.709706026e-007
	,4.785418420e-007
	,6.143755828e-007
	,7.775827571e-007
	,9.773885530e-007
	,1.224073375e-006
	,1.527491387e-006
	,1.899014592e-006
	,2.351791257e-006
	,2.900882565e-006
	,3.563375886e-006
	,4.358468950e-006
	,5.307521860e-006
	,6.434077698e-006
	,7.763856886e-006
	,9.324735619e-006
	,1.113527238e-005
	,1.315545090e-005
	,1.545662970e-005
	,1.806839978e-005
	,2.101423612e-005
	,2.431866938e-005
	,2.798749817e-005
	,3.169631394e-005
	,3.562138020e-005
	,3.940020357e-005
	,4.352264120e-005
	,4.799589447e-005
	,5.282824196e-005
	,5.801598200e-005
	,6.357021333e-005
	,6.950994726e-005
	,7.584624476e-005
	,8.259076536e-005
	,8.975568115e-005
	,9.735352255e-005
	,1.053181445e-004
	,1.134235957e-004
	,1.219319789e-004
	,1.308515964e-004
	,1.401907412e-004
	,1.498620685e-004
	,1.599231305e-004
	,1.697164894e-004
	,1.795148572e-004
	,1.893227010e-004
	,1.993834395e-004
	,2.098029535e-004
	,2.204954546e-004
	,2.308735795e-004
	,2.411566149e-004
	,2.519262865e-004
	,2.631241533e-004
	,2.747886651e-004
	,2.869284682e-004
	,2.984196229e-004
	,3.102927568e-004
	,3.225554459e-004
	,3.352171855e-004
	,3.482908659e-004
	,3.614815268e-004
	,3.744644766e-004
	,3.863270577e-004
	,3.988323920e-004
	,4.120000920e-004
	,4.258716346e-004
	,4.405053640e-004
	,4.536522421e-004
	,4.671503115e-004
	,4.812116275e-004
	,4.957252246e-004
	,5.107167607e-004
	,5.252074832e-004
	,5.378202956e-004
	,5.505559048e-004
	,5.636860077e-004
	,5.771501678e-004
	,5.909076866e-004
	,6.020112748e-004
	,6.134645051e-004
	,6.253264847e-004
	,6.375395526e-004
	,6.500588393e-004
	,6.628796662e-004
	,6.759626898e-004
	,6.891171733e-004
	,7.023924571e-004
	,7.158792255e-004
	,7.295673522e-004
	,7.434843664e-004
	,7.576016719e-004
	,7.719025269e-004
	,7.863960612e-004
	,8.010622998e-004
	,8.158968759e-004
	,8.308961329e-004
	,8.460428795e-004
	,8.613327738e-004
	,8.767970009e-004
	,8.924572782e-004
	,9.082994594e-004
	,9.242939324e-004
	,9.404421550e-004
	,9.567393594e-004
	,9.731836463e-004
	,9.897735013e-004
	,1.006523182e-003
	,1.023429190e-003
	,1.040479800e-003
	,1.057646873e-003
	,1.073552938e-003
	,-1.305723728e-006
	,-1.010458511e-006
	,-7.817074097e-007
	,-6.039237590e-007
	,-4.657086684e-007
	,-3.585992850e-007
	,-2.757341106e-007
	,-2.116665843e-007
	,-1.620976453e-007
	,-1.237964167e-007
	,-9.430776515e-008
	,-7.164460553e-008
	,-5.422196710e-008
	,-4.086226164e-008
	,-3.068847551e-008
	,-2.299316771e-008
	,-1.720399976e-008
	,-1.286874824e-008
	,-9.629474761e-009
	,-7.209989088e-009
	,-5.400053750e-009
	,-4.044469503e-009
	,-3.028742173e-009
	,-2.267161625e-009
	,-1.695731501e-009
	,-1.267151724e-009
	,-9.461833853e-010
	,-7.060345059e-010
	,-5.263181884e-010
	,-3.916737421e-010
	,-2.906119481e-010
	,-2.146037157e-010
	,-1.573735710e-010
	,-1.142969119e-010
	,-8.189688257e-011
	,-5.750684029e-011
	,-3.908944540e-011
	,-2.512063304e-011
	,-1.447759028e-011
	,-6.320820662e-012
	,7.832285680e-018
	,4.992856721e-012
	,9.047406221e-012
	,1.245670024e-011
	,1.543929686e-011
	,1.815779719e-011
	,2.073359085e-011
	,2.325947726e-011
	,2.581079064e-011
	,2.845295220e-011
	,3.124473793e-011
	,3.424043966e-011
	,3.749275691e-011
	,4.105638383e-011
	,4.499123477e-011
	,4.937564108e-011
	,5.430247500e-011
	,5.988712600e-011
	,6.628219260e-011
	,7.367439468e-011
	,8.229543994e-011
	,9.251823105e-011
	,1.048225961e-010
	,1.197583253e-010
	,1.381095740e-010
	,1.611615042e-010
	,1.903819989e-010
	,2.280944307e-010
	,2.772112652e-010
	,3.419554423e-010
	,4.279652496e-010
	,5.430800376e-010
	,6.980085368e-010
	,9.075407635e-010
	,1.190769180e-009
	,1.573407343e-009
	,2.089537228e-009
	,2.788545495e-009
	,3.740486365e-009
	,5.038693684e-009
	,6.794081837e-009
	,9.157921757e-009
	,1.236991857e-008
	,1.673002987e-008
	,2.263772065e-008
	,3.064299586e-008
	,4.147022231e-008
	,5.607609007e-008
	,7.571270745e-008
	,1.020024337e-007
	,1.370253894e-007
	,1.834211012e-007
	,2.445064023e-007
	,3.244119769e-007
	,4.282393325e-007
	,5.622384086e-007
	,7.340038531e-007
	,9.526855688e-007
	,1.229206783e-006
	,1.576480876e-006
	,2.009616960e-006
	,2.546104158e-006
	,3.205966151e-006
	,3.998459307e-006
	,4.938514751e-006
	,6.059108328e-006
	,7.384559797e-006
	,8.939997064e-006
	,1.075050414e-005
	,1.284317029e-005
	,1.510176186e-005
	,1.755094710e-005
	,2.010566386e-005
	,2.286062466e-005
	,2.589751518e-005
	,2.922592698e-005
	,3.286491950e-005
	,3.682621326e-005
	,4.112161572e-005
	,4.576281190e-005
	,5.076147762e-005
	,5.612941117e-005
	,6.187859575e-005
	,6.802121833e-005
	,7.456963407e-005
	,8.137028372e-005
	,8.846465629e-005
	,9.594234518e-005
	,1.038104259e-004
	,1.120761955e-004
	,1.206944826e-004
	,1.294612964e-004
	,1.382011568e-004
	,1.473175643e-004
	,1.568186428e-004
	,1.667077790e-004
	,1.769073049e-004
	,1.862543469e-004
	,1.955927423e-004
	,2.053046663e-004
	,2.154463584e-004
	,2.258964395e-004
	,2.366951294e-004
	,2.479308078e-004
	,2.588830266e-004
	,2.696228654e-004
	,2.807558417e-004
	,2.921171858e-004
	,3.039007951e-004
	,3.161117793e-004
	,3.278183333e-004
	,3.391940654e-004
	,3.510680794e-004
	,3.634595217e-004
	,3.764017008e-004
	,3.899393382e-004
	,4.041267242e-004
	,4.175750512e-004
	,4.309808079e-004
	,4.448824857e-004
	,4.592892150e-004
	,4.740767016e-004
	,4.867237076e-004
	,4.996613878e-004
	,5.126843293e-004
	,5.236802290e-004
	,5.348501891e-004
	,5.464487035e-004
	,5.584077745e-004
	,5.706839533e-004
	,5.832341968e-004
	,5.958793168e-004
	,6.087726924e-004
	,6.218973365e-004
	,6.352428889e-004
	,6.488044682e-004
	,6.624189969e-004
	,6.761007992e-004
	,6.898909428e-004
	,7.038545809e-004
	,7.179973084e-004
	,7.323308791e-004
	,7.468334433e-004
	,7.614997109e-004
	,7.763331544e-004
	,7.913212104e-004
	,8.064614099e-004
	,8.217515252e-004
	,8.371684006e-004
	,8.527229772e-004
	,8.684489776e-004
	,8.843655705e-004
	,9.004342419e-004
	,9.159024805e-004
	,9.309646905e-004
	,9.461614560e-004
	,9.614898516e-004
	,9.769472998e-004
	,9.925489170e-004
	,1.008284982e-003
	,1.024146670e-003
	,-4.383125157e-006
	,-3.480032727e-006
	,-2.748693891e-006
	,-2.160812267e-006
	,-1.688222720e-006
	,-1.306856904e-006
	,-1.002974974e-006
	,-7.661311669e-007
	,-5.846499172e-007
	,-4.463802066e-007
	,-3.407493549e-007
	,-2.596926869e-007
	,-1.975267368e-007
	,-1.500609761e-007
	,-1.139858984e-007
	,-8.659432585e-008
	,-6.574500142e-008
	,-4.983166056e-008
	,-3.769460406e-008
	,-2.847013604e-008
	,-2.147678221e-008
	,-1.617290605e-008
	,-1.214211070e-008
	,-9.072955119e-009
	,-6.743465831e-009
	,-4.988370532e-009
	,-3.675827315e-009
	,-2.703094126e-009
	,-1.985958621e-009
	,-1.457636441e-009
	,-1.068073939e-009
	,-7.805404455e-010
	,-5.680098801e-010
	,-4.105369835e-010
	,-2.934409892e-010
	,-2.059541175e-010
	,-1.402031536e-010
	,-9.044131326e-011
	,-5.244862862e-011
	,-2.308539023e-011
	,-1.561286422e-017
	,1.856606544e-011
	,3.392481119e-011
	,4.705398809e-011
	,5.868226643e-011
	,6.935440034e-011
	,7.947709675e-011
	,8.934948291e-011
	,9.919384262e-011
	,1.091904728e-010
	,1.194952328e-010
	,1.302341072e-010
	,1.414961225e-010
	,1.533381645e-010
	,1.657834035e-010
	,1.788139596e-010
	,1.923947748e-010
	,2.065289673e-010
	,2.213078494e-010
	,2.368981780e-010
	,2.535392783e-010
	,2.714962357e-010
	,2.910494363e-010
	,3.124964617e-010
	,3.361668008e-010
	,3.624471977e-010
	,3.918139361e-010
	,4.248408318e-010
	,4.623964118e-010
	,5.056485061e-010
	,5.561366895e-010
	,6.159517795e-010
	,6.874417174e-010
	,7.742030666e-010
	,8.815915875e-010
	,1.016407306e-009
	,1.187439580e-009
	,1.408514088e-009
	,1.696219900e-009
	,2.075908719e-009
	,2.580276863e-009
	,3.255985408e-009
	,4.165813320e-009
	,5.390643046e-009
	,7.051200553e-009
	,9.309062820e-009
	,1.238571016e-008
	,1.658490437e-008
	,2.232287419e-008
	,3.016897435e-008
	,4.088975473e-008
	,5.548986270e-008
	,7.529343945e-008
	,1.022182997e-007
	,1.387417782e-007
	,1.881245365e-007
	,2.546109767e-007
	,3.436499062e-007
	,4.621276073e-007
	,6.185981801e-007
	,8.234914795e-007
	,1.089232643e-006
	,1.430545794e-006
	,1.864454205e-006
	,2.401358625e-006
	,3.043552018e-006
	,3.823484283e-006
	,4.727686261e-006
	,5.781804439e-006
	,7.008477786e-006
	,8.429587210e-006
	,1.006236304e-005
	,1.192359091e-005
	,1.402947105e-005
	,1.639548733e-005
	,1.903645215e-005
	,2.196653724e-005
	,2.519928356e-005
	,2.874772312e-005
	,3.262449922e-005
	,3.684197813e-005
	,4.141235015e-005
	,4.634771236e-005
	,5.156388386e-005
	,5.709419125e-005
	,6.298355959e-005
	,6.923865445e-005
	,7.586601687e-005
	,8.287209679e-005
	,8.999719508e-005
	,9.729338451e-005
	,1.049352868e-004
	,1.129280304e-004
	,1.209482690e-004
	,1.288993341e-004
	,1.370920043e-004
	,1.456204926e-004
	,1.543827767e-004
	,1.631912316e-004
	,1.724204562e-004
	,1.820706582e-004
	,1.919989940e-004
	,2.020601187e-004
	,2.124710539e-004
	,2.226154546e-004
	,2.330194049e-004
	,2.437762599e-004
	,2.548925405e-004
	,2.663756988e-004
	,2.771008590e-004
	,2.881243856e-004
	,2.995201861e-004
	,3.113070691e-004
	,3.235117279e-004
	,3.361681360e-004
	,3.493167621e-004
	,3.630036903e-004
	,3.768051575e-004
	,3.900484197e-004
	,4.037170283e-004
	,4.178200267e-004
	,4.299396710e-004
	,4.405517081e-004
	,4.516895852e-004
	,4.632364592e-004
	,4.750449238e-004
	,4.871524398e-004
	,4.995375403e-004
	,5.120582955e-004
	,5.247252017e-004
	,5.376204761e-004
	,5.507348691e-004
	,5.640577186e-004
	,5.774803436e-004
	,5.910387093e-004
	,6.047828845e-004
	,6.187130414e-004
	,6.325425567e-004
	,6.464614779e-004
	,6.605393921e-004
	,6.747003882e-004
	,6.890085734e-004
	,7.034827051e-004
	,7.181218640e-004
	,7.329116424e-004
	,7.478538728e-004
	,7.626440116e-004
	,7.767020889e-004
	,7.908999780e-004
	,8.052339605e-004
	,8.196857875e-004
	,8.342660063e-004
	,8.490045454e-004
	,8.639139494e-004
	,8.789559060e-004
	,8.941265145e-004
	,9.094242989e-004
	,9.248426179e-004
	,9.403801228e-004
	,9.560313453e-004
	,9.718079331e-004
	,-1.401938895e-005
	,-1.136727085e-005
	,-9.161647432e-006
	,-7.341257029e-006
	,-5.858689720e-006
	,-4.665111882e-006
	,-3.702677793e-006
	,-2.925179750e-006
	,-2.300656313e-006
	,-1.799601337e-006
	,-1.397364824e-006
	,-1.077243077e-006
	,-8.254167748e-007
	,-6.281631893e-007
	,-4.748012975e-007
	,-3.573841049e-007
	,-2.683981180e-007
	,-2.013705771e-007
	,-1.511336342e-007
	,-1.135074928e-007
	,-8.525513447e-008
	,-6.400141452e-008
	,-4.803741498e-008
	,-3.607650599e-008
	,-2.711905620e-008
	,-2.039791542e-008
	,-1.533420443e-008
	,-1.150171812e-008
	,-8.599912861e-009
	,-6.409766090e-009
	,-4.757143277e-009
	,-3.503769116e-009
	,-2.556407538e-009
	,-1.845142212e-009
	,-1.312513134e-009
	,-9.140888175e-010
	,-6.160303189e-010
	,-3.926764542e-010
	,-2.246908407e-010
	,-9.748450290e-011
	,-1.764930263e-017
	,7.610053012e-011
	,1.370253186e-010
	,1.873695849e-010
	,2.305222298e-010
	,2.689685626e-010
	,3.045381300e-010
	,3.385850700e-010
	,3.721010657e-010
	,4.058003537e-010
	,4.402100131e-010
	,4.757616806e-010
	,5.128481133e-010
	,5.518278033e-010
	,5.930128132e-010
	,6.366821441e-010
	,6.831100110e-010
	,7.325756609e-010
	,7.853538634e-010
	,8.417427666e-010
	,9.020605762e-010
	,9.665964644e-010
	,1.035605327e-009
	,1.109306773e-009
	,1.187891662e-009
	,1.271543596e-009
	,1.360479427e-009
	,1.455015423e-009
	,1.555629695e-009
	,1.662932270e-009
	,1.777629017e-009
	,1.900503771e-009
	,2.032437760e-009
	,2.174440506e-009
	,2.327738444e-009
	,2.493872047e-009
	,2.674761177e-009
	,2.872892422e-009
	,3.091672255e-009
	,3.335765009e-009
	,3.610183188e-009
	,3.925167103e-009
	,4.295192728e-009
	,4.739456795e-009
	,5.282760377e-009
	,5.954468240e-009
	,6.806733612e-009
	,7.907669891e-009
	,9.342224963e-009
	,1.121349626e-008
	,1.367025469e-008
	,1.694205300e-008
	,2.131587602e-008
	,2.718796606e-008
	,3.508787623e-008
	,4.573462462e-008
	,6.009291282e-008
	,7.946045816e-008
	,1.055713289e-007
	,1.407298273e-007
	,1.879565191e-007
	,2.512561859e-007
	,3.357962992e-007
	,4.481876753e-007
	,5.967546123e-007
	,7.917824473e-007
	,1.045674249e-006
	,1.372932601e-006
	,1.790448408e-006
	,2.316932114e-006
	,2.972627512e-006
	,3.778806424e-006
	,4.757207315e-006
	,5.929485375e-006
	,7.316733661e-006
	,8.939116949e-006
	,1.081563669e-005
	,1.296402416e-005
	,1.540074368e-005
	,1.812240351e-005
	,2.113967949e-005
	,2.447269395e-005
	,2.813076840e-005
	,3.208712378e-005
	,3.637643839e-005
	,4.098296307e-005
	,4.580516803e-005
	,5.093477797e-005
	,5.627950100e-005
	,6.169979654e-005
	,6.725230719e-005
	,7.310853924e-005
	,7.927351917e-005
	,8.575295568e-005
	,9.255326645e-005
	,9.968158478e-005
	,1.071458277e-004
	,1.149546313e-004
	,1.231173446e-004
	,1.316438985e-004
	,1.405449486e-004
	,1.498152574e-004
	,1.594739829e-004
	,1.692517710e-004
	,1.793438844e-004
	,1.897231359e-004
	,2.002199315e-004
	,2.106297422e-004
	,2.207679035e-004
	,2.311961752e-004
	,2.419231974e-004
	,2.529612844e-004
	,2.643267226e-004
	,2.760400955e-004
	,2.881265243e-004
	,3.006156628e-004
	,3.133839866e-004
	,3.258964973e-004
	,3.381831841e-004
	,3.505179890e-004
	,3.618672120e-004
	,3.729729818e-004
	,3.844511729e-004
	,3.962346076e-004
	,4.082858255e-004
	,4.205812444e-004
	,4.331052919e-004
	,4.458266616e-004
	,4.587204399e-004
	,4.718171070e-004
	,4.851118379e-004
	,4.984661617e-004
	,5.119784963e-004
	,5.256738901e-004
	,5.395469380e-004
	,5.535944073e-004
	,5.676781149e-004
	,5.818763478e-004
	,5.957827889e-004
	,6.098358149e-004
	,6.230918188e-004
	,6.363915179e-004
	,6.498104222e-004
	,6.633381456e-004
	,6.770090944e-004
	,6.908357581e-004
	,7.048065010e-004
	,7.189061188e-004
	,7.331415275e-004
	,7.474996566e-004
	,7.619786444e-004
	,7.765768873e-004
	,7.912848546e-004
	,8.061006648e-004
	,8.210569010e-004
	,8.361547812e-004
	,8.513917443e-004
	,8.667475261e-004
	,8.822225999e-004
	,8.978114439e-004
	,9.135132869e-004
	,-3.900290964e-005
	,-3.320999026e-005
	,-2.809212889e-005
	,-2.363437533e-005
	,-1.975710136e-005
	,-1.635004552e-005
	,-1.332295086e-005
	,-1.070286769e-005
	,-8.532182597e-006
	,-6.785710164e-006
	,-5.397421939e-006
	,-4.295637146e-006
	,-3.416565421e-006
	,-2.710822650e-006
	,-2.144275002e-006
	,-1.683927869e-006
	,-1.297772025e-006
	,-9.796715913e-007
	,-7.316253743e-007
	,-5.443707820e-007
	,-4.046908503e-007
	,-3.009654636e-007
	,-2.240640995e-007
	,-1.670139306e-007
	,-1.245958606e-007
	,-9.295855706e-008
	,-6.927396019e-008
	,-5.150127078e-008
	,-3.816949318e-008
	,-2.818320195e-008
	,-2.071670661e-008
	,-1.515375306e-008
	,-1.102004258e-008
	,-7.950469498e-009
	,-5.669705495e-009
	,-3.971191817e-009
	,-2.699499058e-009
	,-1.738408570e-009
	,-1.004565392e-009
	,-4.397303562e-010
	,-2.612515942e-019
	,3.482879838e-010
	,6.295607514e-010
	,8.616492105e-010
	,1.058033058e-009
	,1.229253531e-009
	,1.383595072e-009
	,1.527253991e-009
	,1.664551279e-009
	,1.798288997e-009
	,1.930201624e-009
	,2.061455451e-009
	,2.193042288e-009
	,2.325939194e-009
	,2.461126643e-009
	,2.599590975e-009
	,2.742270503e-009
	,2.889932118e-009
	,3.043047207e-009
	,3.201715127e-009
	,3.365803212e-009
	,3.535305209e-009
	,3.710510092e-009
	,3.891771031e-009
	,4.079274145e-009
	,4.273200553e-009
	,4.473880923e-009
	,4.681685909e-009
	,4.896967304e-009
	,5.120043723e-009
	,5.351230569e-009
	,5.590847517e-009
	,5.839200977e-009
	,6.096577721e-009
	,6.363256001e-009
	,6.639518090e-009
	,6.925669960e-009
	,7.222063931e-009
	,7.529155171e-009
	,7.847553865e-009
	,8.178092705e-009
	,8.521929530e-009
	,8.880683070e-009
	,9.256622846e-009
	,9.652926935e-009
	,1.007405007e-008
	,1.052414976e-008
	,1.101285767e-008
	,1.155165699e-008
	,1.215717593e-008
	,1.285164343e-008
	,1.366597022e-008
	,1.464336609e-008
	,1.584280399e-008
	,1.733854946e-008
	,1.922247195e-008
	,2.157061839e-008
	,2.460191446e-008
	,2.853927907e-008
	,3.370418651e-008
	,4.051349689e-008
	,4.953209395e-008
	,6.151265616e-008
	,7.746020029e-008
	,9.870283704e-008
	,1.270078357e-007
	,1.646933136e-007
	,2.147995226e-007
	,2.811699258e-007
	,3.686653657e-007
	,4.838698569e-007
	,6.349529428e-007
	,8.314442874e-007
	,1.085645333e-006
	,1.411247791e-006
	,1.826049603e-006
	,2.349532114e-006
	,3.003311658e-006
	,3.810620309e-006
	,4.795461203e-006
	,5.981126770e-006
	,7.390976097e-006
	,9.046546547e-006
	,1.096676068e-005
	,1.316774741e-005
	,1.566271840e-005
	,1.846208388e-005
	,2.157374996e-005
	,2.500352934e-005
	,2.875560144e-005
	,3.283297950e-005
	,3.723793609e-005
	,4.197237470e-005
	,4.703813833e-005
	,5.243727154e-005
	,5.817219497e-005
	,6.424584234e-005
	,7.066174385e-005
	,7.742406490e-005
	,8.453760451e-005
	,9.200327734e-005
	,9.979520100e-005
	,1.078631054e-004
	,1.162743233e-004
	,1.250323807e-004
	,1.339167403e-004
	,1.431318042e-004
	,1.526881798e-004
	,1.625926653e-004
	,1.728052248e-004
	,1.831544200e-004
	,1.931714018e-004
	,2.031739603e-004
	,2.134871786e-004
	,2.241294429e-004
	,2.351237411e-004
	,2.464972366e-004
	,2.582801120e-004
	,2.705032816e-004
	,2.820135915e-004
	,2.933078672e-004
	,3.048843886e-004
	,3.167096764e-004
	,3.287646437e-004
	,3.410369265e-004
	,3.535178736e-004
	,3.662005310e-004
	,3.790803124e-004
	,3.921536295e-004
	,4.054169992e-004
	,4.188612062e-004
	,4.324608284e-004
	,4.462420241e-004
	,4.599514046e-004
	,4.731524033e-004
	,4.864736089e-004
	,4.999443928e-004
	,5.135576021e-004
	,5.273090064e-004
	,5.408460816e-004
	,5.541481235e-004
	,5.675979263e-004
	,5.811662239e-004
	,5.948563129e-004
	,6.086667151e-004
	,6.225812959e-004
	,6.361649868e-004
	,6.498266965e-004
	,6.636175850e-004
	,6.775382344e-004
	,6.915678934e-004
	,7.057128565e-004
	,7.199640401e-004
	,7.343203342e-004
	,7.487807018e-004
	,7.633403278e-004
	,7.780042207e-004
	,7.927937733e-004
	,8.077040337e-004
	,8.227344683e-004
	,8.378771256e-004
	,-8.270812580e-005
	,-7.393384191e-005
	,-6.566411357e-005
	,-5.793732718e-005
	,-5.069101246e-005
	,-4.393187033e-005
	,-3.776693106e-005
	,-3.222949499e-005
	,-2.727730845e-005
	,-2.288699681e-005
	,-1.906576477e-005
	,-1.579347861e-005
	,-1.300610162e-005
	,-1.062086566e-005
	,-8.579058659e-006
	,-6.864575824e-006
	,-5.459303237e-006
	,-4.317948056e-006
	,-3.395391750e-006
	,-2.649436755e-006
	,-2.042512087e-006
	,-1.552512344e-006
	,-1.166104816e-006
	,-8.714662552e-007
	,-6.500153539e-007
	,-4.840684599e-007
	,-3.597414181e-007
	,-2.663708902e-007
	,-1.960848500e-007
	,-1.433012773e-007
	,-1.038995110e-007
	,-7.478522595e-008
	,-5.343446815e-008
	,-3.782571931e-008
	,-2.644108437e-008
	,-1.813894778e-008
	,-1.207015539e-008
	,-7.612076909e-009
	,-4.313321500e-009
	,-1.852167046e-009
	,9.607642236e-018
	,1.409237851e-009
	,2.497797011e-009
	,3.354483451e-009
	,4.044328934e-009
	,4.616365899e-009
	,5.105206466e-009
	,5.537160613e-009
	,5.932342468e-009
	,6.303534568e-009
	,6.658718943e-009
	,7.003518178e-009
	,7.342064697e-009
	,7.676719566e-009
	,8.008501333e-009
	,8.338023719e-009
	,8.665746933e-009
	,8.991902049e-009
	,9.316749819e-009
	,9.640763100e-009
	,9.964605775e-009
	,1.028895410e-008
	,1.061421650e-008
	,1.094036294e-008
	,1.126687501e-008
	,1.159276028e-008
	,1.191663644e-008
	,1.223690519e-008
	,1.255196448e-008
	,1.286036880e-008
	,1.316107129e-008
	,1.345395839e-008
	,1.373982194e-008
	,1.401958785e-008
	,1.429392515e-008
	,1.456340432e-008
	,1.482883972e-008
	,1.509137245e-008
	,1.535216022e-008
	,1.561209350e-008
	,1.587181945e-008
	,1.613187633e-008
	,1.639273036e-008
	,1.665478441e-008
	,1.691842121e-008
	,1.718404730e-008
	,1.745214035e-008
	,1.772332279e-008
	,1.799846576e-008
	,1.827882992e-008
	,1.856624281e-008
	,1.886331687e-008
	,1.917218318e-008
	,1.949781794e-008
	,1.984706991e-008
	,2.022867249e-008
	,2.065453587e-008
	,2.114091802e-008
	,2.171001251e-008
	,2.239211738e-008
	,2.322859836e-008
	,2.427594366e-008
	,2.554185106e-008
	,2.713613455e-008
	,2.917998526e-008
	,3.182425797e-008
	,3.526997065e-008
	,3.978316585e-008
	,4.571468433e-008
	,5.353993751e-008
	,6.388282380e-008
	,7.756377580e-008
	,9.567923708e-008
	,1.196590225e-007
	,1.513910754e-007
	,1.933364447e-007
	,2.485380334e-007
	,3.212117743e-007
	,4.166215837e-007
	,5.414497648e-007
	,7.040841197e-007
	,9.149229137e-007
	,1.186665004e-006
	,1.534552970e-006
	,1.976524274e-006
	,2.533219435e-006
	,3.227799177e-006
	,4.085539428e-006
	,5.133201481e-006
	,6.398214031e-006
	,7.907743606e-006
	,9.687759377e-006
	,1.176220238e-005
	,1.415235319e-005
	,1.687645329e-005
	,1.994442800e-005
	,2.336081776e-005
	,2.713365180e-005
	,3.127096224e-005
	,3.577464042e-005
	,4.064477694e-005
	,4.588011444e-005
	,5.147847518e-005
	,5.743711450e-005
	,6.375302899e-005
	,7.042321870e-005
	,7.742920303e-005
	,8.477080133e-005
	,9.245368261e-005
	,1.004764173e-004
	,1.088386005e-004
	,1.175409375e-004
	,1.265854086e-004
	,1.359754406e-004
	,1.457136114e-004
	,1.557926981e-004
	,1.662029430e-004
	,1.765805131e-004
	,1.870260604e-004
	,1.977138463e-004
	,2.085306522e-004
	,2.196069849e-004
	,2.309349442e-004
	,2.425076420e-004
	,2.543023876e-004
	,2.659667229e-004
	,2.778189591e-004
	,2.898513389e-004
	,3.020566177e-004
	,3.144280276e-004
	,3.269595199e-004
	,3.396455066e-004
	,3.524807469e-004
	,3.654600306e-004
	,3.785759263e-004
	,3.918227968e-004
	,4.052013519e-004
	,4.187075005e-004
	,4.323272828e-004
	,4.460645709e-004
	,4.599210007e-004
	,4.738936376e-004
	,4.879798766e-004
	,5.015774344e-004
	,5.150116988e-004
	,5.285634144e-004
	,5.422215014e-004
	,5.559847000e-004
	,5.698535967e-004
	,5.838217456e-004
	,5.978884754e-004
	,6.120758974e-004
	,6.263767036e-004
	,6.407840670e-004
	,6.552964686e-004
	,6.699153717e-004
	,6.846355968e-004
	,6.994563951e-004
	,7.143747506e-004
	,7.293900647e-004
	,7.445148429e-004
	,-1.243059336e-004
	,-1.147535520e-004
	,-1.056153453e-004
	,-9.688165840e-005
	,-8.853055096e-005
	,-8.050867237e-005
	,-7.271924591e-005
	,-6.502026772e-005
	,-5.741313547e-005
	,-5.011097196e-005
	,-4.331174296e-005
	,-3.711095555e-005
	,-3.152821233e-005
	,-2.653444025e-005
	,-2.210429395e-005
	,-1.824559036e-005
	,-1.493577867e-005
	,-1.212756798e-005
	,-9.767278891e-006
	,-7.801099274e-006
	,-6.177093093e-006
	,-4.845859144e-006
	,-3.760960742e-006
	,-2.885540711e-006
	,-2.190814828e-006
	,-1.647040892e-006
	,-1.225376762e-006
	,-9.010524098e-007
	,-6.557790771e-007
	,-4.734445845e-007
	,-3.390954981e-007
	,-2.407576240e-007
	,-1.693917055e-007
	,-1.179359426e-007
	,-8.095043377e-008
	,-5.438464536e-008
	,-3.531368755e-008
	,-2.167224592e-008
	,-1.193986652e-008
	,-4.986750098e-009
	,-1.911136098e-017
	,3.597316198e-009
	,6.212182320e-009
	,8.130938503e-009
	,9.559073955e-009
	,1.064410461e-008
	,1.148921896e-008
	,1.216636420e-008
	,1.272588282e-008
	,1.320164199e-008
	,1.361866067e-008
	,1.399666138e-008
	,1.434878980e-008
	,1.468309162e-008
	,1.500427065e-008
	,1.531517600e-008
	,1.561559586e-008
	,1.590469763e-008
	,1.618482912e-008
	,1.645951021e-008
	,1.673088436e-008
	,1.699983135e-008
	,1.726647279e-008
	,1.753061842e-008
	,1.779185378e-008
	,1.804938397e-008
	,1.830245093e-008
	,1.855067841e-008
	,1.879375620e-008
	,1.903150496e-008
	,1.926405355e-008
	,1.949173545e-008
	,1.971505052e-008
	,1.993458825e-008
	,2.015092637e-008
	,2.036455445e-008
	,2.057583924e-008
	,2.078505493e-008
	,2.099240359e-008
	,2.119800830e-008
	,2.140193080e-008
	,2.160418602e-008
	,2.180479087e-008
	,2.200383835e-008
	,2.220148308e-008
	,2.239784586e-008
	,2.259295655e-008
	,2.278678663e-008
	,2.297934606e-008
	,2.317073717e-008
	,2.336110539e-008
	,2.355059855e-008
	,2.373939747e-008
	,2.392776055e-008
	,2.411606364e-008
	,2.430490026e-008
	,2.449522351e-008
	,2.468845508e-008
	,2.488596075e-008
	,2.508968939e-008
	,2.530296657e-008
	,2.552947087e-008
	,2.577406894e-008
	,2.604335938e-008
	,2.634640399e-008
	,2.669569230e-008
	,2.710826834e-008
	,2.760726122e-008
	,2.820668334e-008
	,2.893141517e-008
	,2.983929295e-008
	,3.099082009e-008
	,3.246658237e-008
	,3.437369891e-008
	,3.685461149e-008
	,4.009865106e-008
	,4.435731608e-008
	,4.996394673e-008
	,5.736041101e-008
	,6.713292201e-008
	,8.005557475e-008
	,9.714747659e-008
	,1.197515969e-007
	,1.496288030e-007
	,1.889348280e-007
	,2.407252803e-007
	,3.088389462e-007
	,3.981885364e-007
	,5.150205953e-007
	,6.671818984e-007
	,8.644483334e-007
	,1.118809797e-006
	,1.444729875e-006
	,1.859341280e-006
	,2.382514386e-006
	,3.036753228e-006
	,3.846880195e-006
	,4.839492703e-006
	,6.042210261e-006
	,7.482769769e-006
	,9.188061880e-006
	,1.118321702e-005
	,1.349084414e-005
	,1.613049739e-005
	,1.911840398e-005
	,2.246744412e-005
	,2.618734281e-005
	,3.028289661e-005
	,3.475874548e-005
	,3.961730458e-005
	,4.485894202e-005
	,5.048280530e-005
	,5.648717243e-005
	,6.286973947e-005
	,6.962786530e-005
	,7.675876767e-005
	,8.425968265e-005
	,9.211278019e-005
	,1.003228228e-004
	,1.088888329e-004
	,1.178074354e-004
	,1.270753211e-004
	,1.366881064e-004
	,1.466249102e-004
	,1.567472457e-004
	,1.668608216e-004
	,1.772719728e-004
	,1.879719639e-004
	,1.989523948e-004
	,2.102051323e-004
	,2.217222486e-004
	,2.334960777e-004
	,2.455191265e-004
	,2.577841023e-004
	,2.702839194e-004
	,2.830117094e-004
	,2.959608331e-004
	,3.091248251e-004
	,3.224973313e-004
	,3.360209136e-004
	,3.496985975e-004
	,3.635592407e-004
	,3.775972647e-004
	,3.918052401e-004
	,4.061819140e-004
	,4.207224104e-004
	,4.354234243e-004
	,4.501601965e-004
	,4.639594324e-004
	,4.779031966e-004
	,4.919864071e-004
	,5.062060346e-004
	,5.205606620e-004
	,5.350440408e-004
	,5.494688832e-004
	,5.640150116e-004
	,5.786813495e-004
	,5.934622996e-004
	,6.083532345e-004
	,6.233589452e-004
	,6.384731127e-004
	,-1.500616304e-004
	,-1.391757573e-004
	,-1.288062199e-004
	,-1.189483603e-004
	,-1.095600724e-004
	,-1.005744149e-004
	,-9.190950810e-005
	,-8.349661269e-005
	,-7.533292390e-005
	,-6.749041032e-005
	,-6.004955207e-005
	,-5.305250737e-005
	,-4.650686783e-005
	,-4.042564393e-005
	,-3.483376048e-005
	,-2.973539055e-005
	,-2.511740940e-005
	,-2.096585341e-005
	,-1.727171010e-005
	,-1.402765444e-005
	,-1.122819439e-005
	,-8.860215330e-006
	,-6.894477016e-006
	,-5.290726856e-006
	,-4.004040713e-006
	,-2.988691299e-006
	,-2.201849070e-006
	,-1.603527312e-006
	,-1.155769425e-006
	,-8.251129912e-007
	,-5.836842428e-007
	,-4.090687853e-007
	,-2.837321967e-007
	,-1.943956302e-007
	,-1.311781215e-007
	,-8.666361594e-008
	,-5.542691995e-008
	,-3.354989507e-008
	,-1.823781585e-008
	,-7.516934493e-009
	,1.289727351e-017
	,5.285028436e-009
	,9.017663524e-009
	,1.167203903e-008
	,1.357803581e-008
	,1.496465891e-008
	,1.599112350e-008
	,1.676794008e-008
	,1.737129057e-008
	,1.785377755e-008
	,1.825174737e-008
	,1.859002140e-008
	,1.888590269e-008
	,1.915143893e-008
	,1.939494045e-008
	,1.962235457e-008
	,1.983827206e-008
	,2.004598385e-008
	,2.024768356e-008
	,2.044498328e-008
	,2.063909561e-008
	,2.083079524e-008
	,2.102058614e-008
	,2.120885434e-008
	,2.139582277e-008
	,2.158163486e-008
	,2.176634387e-008
	,2.194989523e-008
	,2.213215752e-008
	,2.231302211e-008
	,2.249248792e-008
	,2.267070992e-008
	,2.284791869e-008
	,2.302430677e-008
	,2.320001233e-008
	,2.337516269e-008
	,2.354990109e-008
	,2.372437484e-008
	,2.389873353e-008
	,2.407311225e-008
	,2.424760899e-008
	,2.442229216e-008
	,2.459720528e-008
	,2.477237008e-008
	,2.494778642e-008
	,2.512342103e-008
	,2.529920533e-008
	,2.547507325e-008
	,2.565103726e-008
	,2.582719207e-008
	,2.600364605e-008
	,2.618048226e-008
	,2.635775947e-008
	,2.653552262e-008
	,2.671381238e-008
	,2.689267220e-008
	,2.707215349e-008
	,2.725232169e-008
	,2.743326182e-008
	,2.761508526e-008
	,2.779793714e-008
	,2.798200821e-008
	,2.816755485e-008
	,2.835493203e-008
	,2.854451240e-008
	,2.873657661e-008
	,2.893247819e-008
	,2.913372854e-008
	,2.934240476e-008
	,2.956126117e-008
	,2.979394071e-008
	,3.004530407e-008
	,3.032189449e-008
	,3.063256711e-008
	,3.098751579e-008
	,3.138826918e-008
	,3.186072689e-008
	,3.242829794e-008
	,3.312212510e-008
	,3.398364299e-008
	,3.506797421e-008
	,3.644844137e-008
	,3.822255189e-008
	,4.051992878e-008
	,4.351280987e-008
	,4.742991515e-008
	,5.257473351e-008
	,5.934956171e-008
	,6.828700720e-008
	,8.009124929e-008
	,9.569147380e-008
	,1.163110803e-007
	,1.434344983e-007
	,1.792102565e-007
	,2.263552123e-007
	,2.883683682e-007
	,3.697486547e-007
	,4.762311314e-007
	,6.150600993e-007
	,7.952838478e-007
	,1.028056628e-006
	,1.326919889e-006
	,1.708026838e-006
	,2.190261184e-006
	,2.795207381e-006
	,3.546925999e-006
	,4.471497759e-006
	,5.596356861e-006
	,6.949447899e-006
	,8.558287203e-006
	,1.044903219e-005
	,1.264566324e-005
	,1.516936437e-005
	,1.803815104e-005
	,2.126675018e-005
	,2.486670290e-005
	,2.884663616e-005
	,3.321265025e-005
	,3.796875425e-005
	,4.311730484e-005
	,4.865103961e-005
	,5.457093434e-005
	,6.087823596e-005
	,6.757092600e-005
	,7.464668563e-005
	,8.210303333e-005
	,8.993742013e-005
	,9.814725816e-005
	,1.067300257e-004
	,1.156831687e-004
	,1.250037793e-004
	,1.346882701e-004
	,1.444733643e-004
	,1.543837989e-004
	,1.646219535e-004
	,1.751801853e-004
	,1.860511737e-004
	,1.972278435e-004
	,2.087033134e-004
	,2.204708659e-004
	,2.325239297e-004
	,2.448560744e-004
	,2.574610222e-004
	,2.703329901e-004
	,2.834658818e-004
	,2.968538095e-004
	,3.104916196e-004
	,3.243754526e-004
	,3.385004576e-004
	,3.528602999e-004
	,3.674499584e-004
	,3.822647541e-004
	,3.973051474e-004
	,4.125727247e-004
	,4.266109385e-004
	,4.407676962e-004
	,4.550992646e-004
	,4.696026675e-004
	,4.842800578e-004
	,4.991290290e-004
	,5.139519792e-004
	,-1.714955715e-004
	,-1.600515840e-004
	,-1.489644185e-004
	,-1.381745411e-004
	,-1.276591958e-004
	,-1.174090113e-004
	,-1.074389543e-004
	,-9.779180173e-005
	,-8.849889845e-005
	,-7.958321039e-005
	,-7.109425059e-005
	,-6.306659283e-005
	,-5.551377125e-005
	,-4.846132709e-005
	,-4.192736798e-005
	,-3.592043691e-005
	,-3.045130430e-005
	,-2.552924286e-005
	,-2.115407238e-005
	,-1.731244172e-005
	,-1.398194106e-005
	,-1.113445357e-005
	,-8.737063707e-006
	,-6.752136507e-006
	,-5.138384811e-006
	,-3.852126758e-006
	,-2.846948949e-006
	,-2.075670128e-006
	,-1.493840779e-006
	,-1.062602575e-006
	,-7.480577737e-007
	,-5.214273575e-007
	,-3.597084694e-007
	,-2.452054658e-007
	,-1.646322429e-007
	,-1.082044814e-007
	,-6.882841000e-008
	,-4.142203028e-008
	,-2.238084361e-008
	,-9.167713814e-009
	,1.811891046e-017
	,6.369163074e-009
	,1.080691167e-008
	,1.391394004e-008
	,1.610506733e-008
	,1.766612496e-008
	,1.879379594e-008
	,1.962327096e-008
	,2.024754577e-008
	,2.073086328e-008
	,2.111739300e-008
	,2.143742350e-008
	,2.171173748e-008
	,2.195459521e-008
	,2.217578280e-008
	,2.238202161e-008
	,2.257793048e-008
	,2.276665664e-008
	,2.295030268e-008
	,2.313022779e-008
	,2.330727152e-008
	,2.348197262e-008
	,2.365481508e-008
	,2.382634234e-008
	,2.399706758e-008
	,2.416739815e-008
	,2.433762538e-008
	,2.450795590e-008
	,2.467853428e-008
	,2.484945327e-008
	,2.502078105e-008
	,2.519257058e-008
	,2.536485613e-008
	,2.553766313e-008
	,2.571101345e-008
	,2.588492749e-008
	,2.605942295e-008
	,2.623451652e-008
	,2.641022226e-008
	,2.658655125e-008
	,2.676351213e-008
	,2.694111387e-008
	,2.711936580e-008
	,2.729827653e-008
	,2.747785310e-008
	,2.765810135e-008
	,2.783902666e-008
	,2.802063426e-008
	,2.820292847e-008
	,2.838591337e-008
	,2.856959441e-008
	,2.875397843e-008
	,2.893907335e-008
	,2.912488707e-008
	,2.931142810e-008
	,2.949870591e-008
	,2.968673008e-008
	,2.987551053e-008
	,3.006505851e-008
	,3.025538763e-008
	,3.044651352e-008
	,3.063845461e-008
	,3.083123225e-008
	,3.102487171e-008
	,3.121940318e-008
	,3.141486266e-008
	,3.161128993e-008
	,3.180872061e-008
	,3.200717422e-008
	,3.220667084e-008
	,3.240734967e-008
	,3.260929860e-008
	,3.281335646e-008
	,3.302028047e-008
	,3.323094687e-008
	,3.344643913e-008
	,3.366816793e-008
	,3.389801432e-008
	,3.413851252e-008
	,3.439309366e-008
	,3.466641391e-008
	,3.495945477e-008
	,3.528015590e-008
	,3.563879863e-008
	,3.604748964e-008
	,3.652232271e-008
	,3.708468946e-008
	,3.776302961e-008
	,3.859514987e-008
	,3.963131502e-008
	,4.093833939e-008
	,4.260502011e-008
	,4.474933886e-008
	,4.752798928e-008
	,5.114896960e-008
	,5.588819732e-008
	,6.211137860e-008
	,7.030272002e-008
	,8.110250799e-008
	,9.535610435e-008
	,1.140746801e-007
	,1.387562369e-007
	,1.713042399e-007
	,2.141803905e-007
	,2.705746097e-007
	,3.445951273e-007
	,4.414939807e-007
	,5.679260600e-007
	,7.322362387e-007
	,9.447597125e-007
	,1.218114003e-006
	,1.567447780e-006
	,2.010603970e-006
	,2.568148894e-006
	,3.263220884e-006
	,4.121164931e-006
	,5.168946066e-006
	,6.434369763e-006
	,7.945175077e-006
	,9.728096596e-006
	,1.180799928e-005
	,1.420718074e-005
	,1.694490332e-005
	,2.003717626e-005
	,2.349677102e-005
	,2.733342417e-005
	,3.155417066e-005
	,3.616375686e-005
	,4.116506107e-005
	,4.655950270e-005
	,5.234743285e-005
	,5.852844960e-005
	,6.510166693e-005
	,7.206593163e-005
	,7.941998922e-005
	,8.716261736e-005
	,9.529273624e-005
	,1.038096946e-004
	,1.127132551e-004
	,1.220036746e-004
	,1.314359418e-004
	,1.409973796e-004
	,1.509132589e-004
	,1.611781187e-004
	,1.717872814e-004
	,1.827364862e-004
	,1.940220348e-004
	,2.056409998e-004
	,2.175274399e-004
	,2.296389588e-004
	,2.420405967e-004
	,2.547258640e-004
	,2.676903808e-004
	,2.809266167e-004
	,2.944286814e-004
	,3.081907263e-004
	,3.222070044e-004
	,3.364776188e-004
	,3.509945521e-004
	,3.657508048e-004
	,3.807408226e-004
	,-1.898153237e-004
	,-1.773027234e-004
	,-1.650437564e-004
	,-1.530021325e-004
	,-1.411910194e-004
	,-1.296875008e-004
	,-1.185803655e-004
	,-1.079195066e-004
	,-9.771752584e-005
	,-8.796665098e-005
	,-7.868263392e-005
	,-6.990823114e-005
	,-6.166362880e-005
	,-5.396320356e-005
	,-4.682604079e-005
	,-4.025689965e-005
	,-3.425183808e-005
	,-2.880631101e-005
	,-2.391853675e-005
	,-1.959018415e-005
	,-1.581494149e-005
	,-1.257247919e-005
	,-9.834198633e-006
	,-7.563379576e-006
	,-5.719790820e-006
	,-4.261444742e-006
	,-3.132958626e-006
	,-2.275654370e-006
	,-1.634869738e-006
	,-1.162699291e-006
	,-8.189457253e-007
	,-5.711687665e-007
	,-3.943432796e-007
	,-2.691489646e-007
	,-1.809622599e-007
	,-1.190869367e-007
	,-7.581837041e-008
	,-4.566820286e-008
	,-2.470183380e-008
	,-1.013051259e-008
	,-5.743970394e-018
	,7.052409062e-009
	,1.197416301e-008
	,1.542264151e-008
	,1.785335615e-008
	,1.958163551e-008
	,2.082550939e-008
	,2.173557361e-008
	,2.241575140e-008
	,2.293770290e-008
	,2.335080414e-008
	,2.368908526e-008
	,2.397601933e-008
	,2.422775907e-008
	,2.445541202e-008
	,2.466662405e-008
	,2.486666269e-008
	,2.505915764e-008
	,2.524661580e-008
	,2.543077372e-008
	,2.561283168e-008
	,2.579362418e-008
	,2.597374596e-008
	,2.615361211e-008
	,2.633351047e-008
	,2.651364319e-008
	,2.669415198e-008
	,2.687514019e-008
	,2.705668760e-008
	,2.723885130e-008
	,2.742167143e-008
	,2.760517522e-008
	,2.778937751e-008
	,2.797427850e-008
	,2.815985776e-008
	,2.834606109e-008
	,2.853277851e-008
	,2.871982038e-008
	,2.890698200e-008
	,2.909425104e-008
	,2.928187024e-008
	,2.947012086e-008
	,2.965918889e-008
	,2.984917658e-008
	,3.004013849e-008
	,3.023210439e-008
	,3.042509075e-008
	,3.061910708e-008
	,3.081415862e-008
	,3.101024806e-008
	,3.120737675e-008
	,3.140554518e-008
	,3.160475303e-008
	,3.180499959e-008
	,3.200628365e-008
	,3.220860409e-008
	,3.241196041e-008
	,3.261635198e-008
	,3.282177833e-008
	,3.302823937e-008
	,3.323573545e-008
	,3.344426743e-008
	,3.365383710e-008
	,3.386444706e-008
	,3.407610110e-008
	,3.428880449e-008
	,3.450256462e-008
	,3.471739103e-008
	,3.493329640e-008
	,3.515029727e-008
	,3.536841514e-008
	,3.558767828e-008
	,3.580812332e-008
	,3.602979885e-008
	,3.625276850e-008
	,3.647711669e-008
	,3.670295554e-008
	,3.693031071e-008
	,3.715938522e-008
	,3.739043886e-008
	,3.762377790e-008
	,3.785981227e-008
	,3.809909277e-008
	,3.834236181e-008
	,3.859062135e-008
	,3.884522576e-008
	,3.910800851e-008
	,3.938035604e-008
	,3.966370702e-008
	,3.996286463e-008
	,4.028258306e-008
	,4.062916828e-008
	,4.101098926e-008
	,4.143916025e-008
	,4.192843810e-008
	,4.249842272e-008
	,4.317514999e-008
	,4.399320710e-008
	,4.499854147e-008
	,4.625217997e-008
	,4.783518059e-008
	,4.985518739e-008
	,5.245507954e-008
	,5.582444883e-008
	,6.021475046e-008
	,6.595921605e-008
	,7.349910347e-008
	,8.341812102e-008
	,9.640031385e-008
	,1.134862798e-007
	,1.360041715e-007
	,1.656727953e-007
	,2.047329750e-007
	,2.560924248e-007
	,3.235028461e-007
	,4.117718226e-007
	,5.270095005e-007
	,6.769057034e-007
	,8.710267100e-007
	,1.121112371e-006
	,1.441344174e-006
	,1.848544813e-006
	,2.362264663e-006
	,3.004700569e-006
	,3.800415242e-006
	,4.775837000e-006
	,5.958553094e-006
	,7.376449452e-006
	,9.056781440e-006
	,1.102527875e-005
	,1.330538190e-005
	,1.591768567e-005
	,1.887962632e-005
	,2.220540762e-005
	,2.590613092e-005
	,2.999007398e-005
	,3.446307396e-005
	,3.932893445e-005
	,4.458983609e-005
	,5.024672270e-005
	,5.629964651e-005
	,6.274804479e-005
	,6.959099614e-005
	,7.682732506e-005
	,8.445610907e-005
	,9.247604656e-005
	,1.008866276e-004
	,1.096867055e-004
	,1.186963993e-004
	,1.277842697e-004
	,1.372300400e-004
	,1.470271876e-004
	,1.571698691e-004
	,1.676523135e-004
	,1.784692172e-004
	,1.896156614e-004
	,2.010879467e-004
	,2.128806737e-004
	,2.249896048e-004
	,2.374107686e-004
	,2.501404823e-004
	,-2.042684751e-004
	,-1.905871020e-004
	,-1.772445735e-004
	,-1.642492297e-004
	,-1.516172965e-004
	,-1.393974204e-004
	,-1.276158897e-004
	,-1.162610841e-004
	,-1.053292642e-004
	,-9.487519040e-005
	,-8.494328974e-005
	,-7.554424167e-005
	,-6.670072682e-005
	,-5.843849493e-005
	,-5.076460413e-005
	,-4.367934152e-005
	,-3.718366793e-005
	,-3.128029555e-005
	,-2.597140844e-005
	,-2.125332941e-005
	,-1.711216087e-005
	,-1.353411763e-005
	,-1.052135239e-005
	,-8.051025924e-006
	,-6.069427399e-006
	,-4.511605506e-006
	,-3.310080671e-006
	,-2.399586616e-006
	,-1.720246905e-006
	,-1.220395435e-006
	,-8.579467934e-007
	,-5.975804448e-007
	,-4.118605888e-007
	,-2.806911789e-007
	,-1.885917053e-007
	,-1.241447167e-007
	,-7.914728461e-008
	,-4.777024979e-008
	,-2.590034482e-008
	,-1.064999387e-008
	,7.571203822e-018
	,7.457310835e-009
	,1.270093133e-008
	,1.641039910e-008
	,1.905664230e-008
	,2.096558886e-008
	,2.236256997e-008
	,2.340324548e-008
	,2.419509964e-008
	,2.481231729e-008
	,2.530594601e-008
	,2.571095807e-008
	,2.605240149e-008
	,2.634911753e-008
	,2.661437611e-008
	,2.685736062e-008
	,2.708455728e-008
	,2.730060817e-008
	,2.750885698e-008
	,2.771172006e-008
	,2.791094438e-008
	,2.810779332e-008
	,2.830318183e-008
	,2.849777278e-008
	,2.869205003e-008
	,2.888636926e-008
	,2.908099110e-008
	,2.927610748e-008
	,2.947186140e-008
	,2.966836002e-008
	,2.986568434e-008
	,3.006389601e-008
	,3.026304143e-008
	,3.046315716e-008
	,3.066427409e-008
	,3.086641871e-008
	,3.106961245e-008
	,3.127387211e-008
	,3.147921145e-008
	,3.168564182e-008
	,3.189317289e-008
	,3.210181289e-008
	,3.231156872e-008
	,3.252244619e-008
	,3.273444928e-008
	,3.294758048e-008
	,3.316184531e-008
	,3.337724763e-008
	,3.359378982e-008
	,3.381147371e-008
	,3.403030133e-008
	,3.425027435e-008
	,3.447139368e-008
	,3.469365995e-008
	,3.491707367e-008
	,3.514163507e-008
	,3.536734419e-008
	,3.559420097e-008
	,3.582220520e-008
	,3.605135660e-008
	,3.628165437e-008
	,3.651309829e-008
	,3.674568871e-008
	,3.697942610e-008
	,3.721431093e-008
	,3.745034394e-008
	,3.768752631e-008
	,3.792585933e-008
	,3.816534522e-008
	,3.840598673e-008
	,3.864778726e-008
	,3.889075152e-008
	,3.913488505e-008
	,3.938019503e-008
	,3.962669031e-008
	,3.987438184e-008
	,4.012328318e-008
	,4.037341128e-008
	,4.062478699e-008
	,4.087743673e-008
	,4.113139394e-008
	,4.138670112e-008
	,4.164341289e-008
	,4.190155830e-008
	,4.216119717e-008
	,4.242246244e-008
	,4.268548703e-008
	,4.295044604e-008
	,4.321757065e-008
	,4.348716842e-008
	,4.375965002e-008
	,4.403556471e-008
	,4.431565043e-008
	,4.460087258e-008
	,4.489112580e-008
	,4.518863626e-008
	,4.549529844e-008
	,4.581361625e-008
	,4.614690418e-008
	,4.649955036e-008
	,4.687736428e-008
	,4.728805202e-008
	,4.774183676e-008
	,4.825227718e-008
	,4.883736481e-008
	,4.952097364e-008
	,5.033480034e-008
	,5.132091668e-008
	,5.253517074e-008
	,5.405169222e-008
	,5.596886390e-008
	,5.841721005e-008
	,6.156985287e-008
	,6.565641781e-008
	,7.098116284e-008
	,7.794715418e-008
	,8.701408861e-008
	,9.890283517e-008
	,1.145382051e-007
	,1.351142003e-007
	,1.621942700e-007
	,1.978183664e-007
	,2.446366985e-007
	,3.060742447e-007
	,3.865292543e-007
	,4.916067430e-007
	,6.283845494e-007
	,8.057037994e-007
	,1.034467896e-006
	,1.327924397e-006
	,1.701894485e-006
	,2.174906254e-006
	,2.768181439e-006
	,3.505435211e-006
	,4.412461415e-006
	,5.516519084e-006
	,6.845508349e-006
	,8.427073922e-006
	,1.028769733e-005
	,1.245188145e-005
	,1.494151332e-005
	,1.777546035e-005
	,2.096940558e-005
	,2.453589830e-005
	,2.848457635e-005
	,3.282250471e-005
	,3.755457240e-005
	,4.268389841e-005
	,4.821221988e-005
	,5.414024558e-005
	,6.046795513e-005
	,6.719504551e-005
	,7.432063348e-005
	,8.184400812e-005
	,8.976449668e-005
	,9.808093123e-005
	,1.066702234e-004
	,1.152950511e-004
	,1.242856497e-004
	,1.336349026e-004
	,1.433370066e-004
	,-2.151254489e-004
	,-2.011312206e-004
	,-1.874718309e-004
	,-1.740995381e-004
	,-1.610233271e-004
	,-1.482810348e-004
	,-1.358805448e-004
	,-1.238505461e-004
	,-1.122791921e-004
	,-1.012189367e-004
	,-9.067992587e-005
	,-8.068939979e-005
	,-7.128423965e-005
	,-6.247772616e-005
	,-5.427434558e-005
	,-4.668045299e-005
	,-3.970462449e-005
	,-3.335285109e-005
	,-2.761949378e-005
	,-2.249199248e-005
	,-1.800413553e-005
	,-1.418159812e-005
	,-1.099701987e-005
	,-8.397419319e-006
	,-6.317701129e-006
	,-4.686605132e-006
	,-3.431257412e-006
	,-2.481135975e-006
	,-1.774209075e-006
	,-1.256016055e-006
	,-8.804993265e-007
	,-6.119505491e-007
	,-4.215793424e-007
	,-2.873995068e-007
	,-1.932085419e-007
	,-1.272790600e-007
	,-8.121889879e-008
	,-4.907209813e-008
	,-2.663799291e-008
	,-1.096800154e-008
	,-7.834152948e-019
	,7.704077033e-009
	,1.314477841e-008
	,1.701662197e-008
	,1.979853090e-008
	,2.182152294e-008
	,2.332219866e-008
	,2.446234383e-008
	,2.535254897e-008
	,2.606875404e-008
	,2.666306935e-008
	,2.717118234e-008
	,2.761746662e-008
	,2.801851539e-008
	,2.838559283e-008
	,2.872634216e-008
	,2.904598238e-008
	,2.934815116e-008
	,2.963549727e-008
	,2.991008911e-008
	,3.017368117e-008
	,3.042786716e-008
	,3.067414699e-008
	,3.091393529e-008
	,3.114854021e-008
	,3.137913541e-008
	,3.160674070e-008
	,3.183221595e-008
	,3.205626822e-008
	,3.227946755e-008
	,3.250226690e-008
	,3.272502304e-008
	,3.294801600e-008
	,3.317146393e-008
	,3.339553645e-008
	,3.362036541e-008
	,3.384605363e-008
	,3.407268238e-008
	,3.430031603e-008
	,3.452900665e-008
	,3.475879687e-008
	,3.498972094e-008
	,3.522180666e-008
	,3.545507685e-008
	,3.568955057e-008
	,3.592524361e-008
	,3.616216904e-008
	,3.640033758e-008
	,3.663975935e-008
	,3.688044399e-008
	,3.712239912e-008
	,3.736563061e-008
	,3.761014133e-008
	,3.785593469e-008
	,3.810301726e-008
	,3.835139312e-008
	,3.860106501e-008
	,3.885203500e-008
	,3.910430483e-008
	,3.935787600e-008
	,3.961274935e-008
	,3.986892549e-008
	,4.012640456e-008
	,4.038518712e-008
	,4.064527385e-008
	,4.090666482e-008
	,4.116935962e-008
	,4.143335798e-008
	,4.169866088e-008
	,4.196526913e-008
	,4.223318353e-008
	,4.250240493e-008
	,4.277293474e-008
	,4.304477450e-008
	,4.331792631e-008
	,4.359239297e-008
	,4.386817780e-008
	,4.414528508e-008
	,4.442372018e-008
	,4.470348951e-008
	,4.498460067e-008
	,4.526706277e-008
	,4.555088633e-008
	,4.583608430e-008
	,4.612267160e-008
	,4.641066635e-008
	,4.670009017e-008
	,4.699096907e-008
	,4.728333489e-008
	,4.757721618e-008
	,4.787262921e-008
	,4.816964921e-008
	,4.846834245e-008
	,4.876879167e-008
	,4.907110350e-008
	,4.937541523e-008
	,4.968190606e-008
	,4.999081138e-008
	,5.030244255e-008
	,5.061721392e-008
	,5.093527237e-008
	,5.125719222e-008
	,5.158389941e-008
	,5.191640898e-008
	,5.225605841e-008
	,5.260460836e-008
	,5.296438237e-008
	,5.333845017e-008
	,5.373087100e-008
	,5.414701672e-008
	,5.459399967e-008
	,5.508123353e-008
	,5.562118541e-008
	,5.623041759e-008
	,5.693087305e-008
	,5.775165410e-008
	,5.873136303e-008
	,5.992120600e-008
	,6.138911349e-008
	,6.322519754e-008
	,6.554898341e-008
	,6.851898354e-008
	,7.234531944e-008
	,7.730670441e-008
	,8.371003921e-008
	,9.205377973e-008
	,1.029820705e-007
	,1.173218413e-007
	,1.361591975e-007
	,1.609168387e-007
	,1.934523040e-007
	,2.361812301e-007
	,2.922298343e-007
	,3.656202001e-007
	,4.614903852e-007
	,5.863481948e-007
	,7.483525691e-007
	,9.576132080e-007
	,1.226479707e-006
	,1.569794911e-006
	,2.005068758e-006
	,2.552525738e-006
	,3.234980504e-006
	,4.077508891e-006
	,5.106901851e-006
	,6.350930202e-006
	,7.837477148e-006
	,9.593648426e-006
	,1.164490797e-005
	,1.401434964e-005
	,1.672223395e-005
	,1.978571505e-005
	,2.321882321e-005
	,2.703263837e-005
	,3.123553111e-005
	,3.583357848e-005
	,4.083094384e-005
	,4.623027962e-005
	,5.203315263e-005
	,5.824018423e-005
	,6.485146868e-005
	,-2.240731830e-004
	,-2.098346387e-004
	,-1.958918458e-004
	,-1.822201943e-004
	,-1.688401368e-004
	,-1.557423290e-004
	,-1.429412336e-004
	,-1.305229313e-004
	,-1.185388953e-004
	,-1.069941372e-004
	,-9.591580757e-005
	,-8.537377448e-005
	,-7.541726797e-005
	,-6.607265124e-005
	,-5.735771623e-005
	,-4.928430458e-005
	,-4.185455053e-005
	,-3.505226562e-005
	,-2.888482603e-005
	,-2.342512739e-005
	,-1.870535925e-005
	,-1.470620403e-005
	,-1.138281449e-005
	,-8.675367450e-006
	,-6.513789054e-006
	,-4.821762012e-006
	,-3.520859922e-006
	,-2.538844368e-006
	,-1.810006302e-006
	,-1.278243911e-006
	,-8.952092734e-007
	,-6.220205740e-007
	,-4.285350219e-007
	,-2.921999672e-007
	,-1.964980970e-007
	,-1.294999310e-007
	,-8.267769508e-008
	,-4.998272796e-008
	,-2.715029207e-008
	,-1.118716683e-008
	,7.414554713e-018
	,7.870443531e-009
	,1.343486395e-008
	,1.740055398e-008
	,2.026267003e-008
	,2.236288469e-008
	,2.393713203e-008
	,2.514829823e-008
	,2.610876976e-008
	,2.689602174e-008
	,2.756339411e-008
	,2.814754095e-008
	,2.867357870e-008
	,2.915864355e-008
	,2.961434879e-008
	,3.004848486e-008
	,3.046619451e-008
	,3.087078765e-008
	,3.126430665e-008
	,3.164792141e-008
	,3.202220767e-008
	,3.238734792e-008
	,3.274328144e-008
	,3.308982221e-008
	,3.342675756e-008
	,3.375393473e-008
	,3.407133661e-008
	,3.437914298e-008
	,3.467776923e-008
	,3.496787364e-008
	,3.525032889e-008
	,3.552616178e-008
	,3.579647436e-008
	,3.606236465e-008
	,3.632486151e-008
	,3.658488210e-008
	,3.684321208e-008
	,3.710050405e-008
	,3.735728756e-008
	,3.761398505e-008
	,3.787092964e-008
	,3.812838170e-008
	,3.838654398e-008
	,3.864557375e-008
	,3.890559344e-008
	,3.916670151e-008
	,3.942897633e-008
	,3.969247865e-008
	,3.995725616e-008
	,4.022334609e-008
	,4.049077947e-008
	,4.075958317e-008
	,4.102977890e-008
	,4.130138420e-008
	,4.157441352e-008
	,4.184887905e-008
	,4.212479100e-008
	,4.240215783e-008
	,4.268098685e-008
	,4.296128263e-008
	,4.324304585e-008
	,4.352628151e-008
	,4.381099759e-008
	,4.409719831e-008
	,4.438488631e-008
	,4.467406357e-008
	,4.496473165e-008
	,4.525689175e-008
	,4.555054471e-008
	,4.584569123e-008
	,4.614233173e-008
	,4.644046622e-008
	,4.674009400e-008
	,4.704121464e-008
	,4.734382924e-008
	,4.764793849e-008
	,4.795354311e-008
	,4.826064491e-008
	,4.856924572e-008
	,4.887934762e-008
	,4.919095295e-008
	,4.950406469e-008
	,4.981868631e-008
	,5.013482238e-008
	,5.045247823e-008
	,5.077166029e-008
	,5.109237613e-008
	,5.141463458e-008
	,5.173844589e-008
	,5.206382190e-008
	,5.239077572e-008
	,5.271932301e-008
	,5.304948140e-008
	,5.338127156e-008
	,5.371471712e-008
	,5.404984516e-008
	,5.438666331e-008
	,5.472522163e-008
	,5.506556003e-008
	,5.540772685e-008
	,5.575178033e-008
	,5.609779197e-008
	,5.644585065e-008
	,5.679606855e-008
	,5.714858922e-008
	,5.750359834e-008
	,5.786126300e-008
	,5.822167102e-008
	,5.858528808e-008
	,5.895254527e-008
	,5.932399943e-008
	,5.970037524e-008
	,6.008262425e-008
	,6.047199474e-008
	,6.087012781e-008
	,6.127918469e-008
	,6.170201654e-008
	,6.214238751e-008
	,6.260527242e-008
	,6.309725019e-008
	,6.362702646e-008
	,6.420610541e-008
	,6.484974008e-008
	,6.557815979e-008
	,6.641815492e-008
	,6.740523626e-008
	,6.858648206e-008
	,7.002431386e-008
	,7.180150665e-008
	,7.402783614e-008
	,7.684888589e-008
	,8.045780252e-008
	,8.505787469e-008
	,9.099337242e-008
	,9.871407656e-008
	,1.087919319e-007
	,1.219796788e-007
	,1.392659977e-007
	,1.619462841e-007
	,1.917127106e-007
	,2.307676542e-007
	,2.819647153e-007
	,3.489812061e-007
	,4.365244268e-007
	,5.505734815e-007
	,6.986511773e-007
	,8.901162843e-007
	,1.136459418e-006
	,1.451573542e-006
	,1.851961793e-006
	,2.356837743e-006
	,2.988071048e-006
	,3.769939922e-006
	,4.728672645e-006
	,5.891783424e-006
	,7.287255431e-006
	,8.942646994e-006
	,1.088421552e-005
	,1.313617013e-005
	,1.572010511e-005
	,1.865466048e-005
	,-2.317506270e-004
	,-2.174442192e-004
	,-2.033201057e-004
	,-1.893679165e-004
	,-1.755938932e-004
	,-1.620220304e-004
	,-1.487572543e-004
	,-1.358791482e-004
	,-1.234146075e-004
	,-1.113921711e-004
	,-9.988950300e-005
	,-8.896936430e-005
	,-7.865609423e-005
	,-6.896008319e-005
	,-5.988712216e-005
	,-5.143319684e-005
	,-4.357820649e-005
	,-3.636445198e-005
	,-2.988994539e-005
	,-2.420130253e-005
	,-1.929784154e-005
	,-1.514920669e-005
	,-1.170632311e-005
	,-8.905917964e-006
	,-6.673737446e-006
	,-4.927774861e-006
	,-3.586583927e-006
	,-2.578375536e-006
	,-1.835377349e-006
	,-1.295024154e-006
	,-9.066200665e-007
	,-6.298707276e-007
	,-4.339490818e-007
	,-2.959251857e-007
	,-1.990420145e-007
	,-1.312111197e-007
	,-8.379737297e-008
	,-5.067876636e-008
	,-2.753998269e-008
	,-1.135261606e-008
	,-1.054787639e-017
	,7.987715162e-009
	,1.364213928e-008
	,1.768326965e-008
	,2.060972063e-008
	,2.276647051e-008
	,2.439208893e-008
	,2.565149007e-008
	,2.665862325e-008
	,2.749218270e-008
	,2.820647842e-008
	,2.883895589e-008
	,2.941539509e-008
	,2.995350449e-008
	,3.046540439e-008
	,3.095934148e-008
	,3.144087389e-008
	,3.191368884e-008
	,3.238016732e-008
	,3.284177480e-008
	,3.329933146e-008
	,3.375319976e-008
	,3.420341508e-008
	,3.464977728e-008
	,3.509191668e-008
	,3.552934151e-008
	,3.596147054e-008
	,3.638765967e-008
	,3.680722524e-008
	,3.721946781e-008
	,3.762369741e-008
	,3.801926420e-008
	,3.840559439e-008
	,3.878223284e-008
	,3.914889023e-008
	,3.950549112e-008
	,3.985221366e-008
	,4.018951177e-008
	,4.051810691e-008
	,4.083894735e-008
	,4.115313612e-008
	,4.146184548e-008
	,4.176623258e-008
	,4.206737307e-008
	,4.236621920e-008
	,4.266358200e-008
	,4.296013123e-008
	,4.325640770e-008
	,4.355284005e-008
	,4.384976248e-008
	,4.414743488e-008
	,4.444606602e-008
	,4.474581819e-008
	,4.504681473e-008
	,4.534915090e-008
	,4.565290042e-008
	,4.595812130e-008
	,4.626485955e-008
	,4.657315271e-008
	,4.688303095e-008
	,4.719451812e-008
	,4.750763276e-008
	,4.782239113e-008
	,4.813880712e-008
	,4.845689270e-008
	,4.877665791e-008
	,4.909811019e-008
	,4.942125301e-008
	,4.974608582e-008
	,5.007261752e-008
	,5.040085485e-008
	,5.073080079e-008
	,5.106245768e-008
	,5.139582664e-008
	,5.173090860e-008
	,5.206770520e-008
	,5.240621805e-008
	,5.274644781e-008
	,5.308839407e-008
	,5.343205642e-008
	,5.377743598e-008
	,5.412453421e-008
	,5.447335216e-008
	,5.482389123e-008
	,5.517615301e-008
	,5.553013966e-008
	,5.588585389e-008
	,5.624329903e-008
	,5.660247915e-008
	,5.696339875e-008
	,5.732606381e-008
	,5.769048203e-008
	,5.805666178e-008
	,5.842461257e-008
	,5.879434534e-008
	,5.916587241e-008
	,5.953920765e-008
	,5.991436644e-008
	,6.029136636e-008
	,6.067022668e-008
	,6.105096925e-008
	,6.143361780e-008
	,6.181818960e-008
	,6.220471632e-008
	,6.259323240e-008
	,6.298377410e-008
	,6.337638237e-008
	,6.377110416e-008
	,6.416799442e-008
	,6.456711802e-008
	,6.496855350e-008
	,6.537239709e-008
	,6.577876882e-008
	,6.618767812e-008
	,6.659934353e-008
	,6.701396929e-008
	,6.743180546e-008
	,6.785316906e-008
	,6.827846804e-008
	,6.870822992e-008
	,6.914313996e-008
	,6.958409347e-008
	,7.003226141e-008
	,7.048918019e-008
	,7.095685956e-008
	,7.143794685e-008
	,7.193595325e-008
	,7.245549892e-008
	,7.300268602e-008
	,7.358556954e-008
	,7.421481713e-008
	,7.490454197e-008
	,7.567342226e-008
	,7.654619358e-008
	,7.755562217e-008
	,7.874512570e-008
	,8.017225336e-008
	,8.191330999e-008
	,8.406950790e-008
	,8.677516011e-008
	,9.016404894e-008
	,9.447336144e-008
	,1.000186565e-007
	,1.071955578e-007
	,1.165253989e-007
	,1.286941273e-007
	,1.446026239e-007
	,1.654313874e-007
	,1.927230472e-007
	,2.284866083e-007
	,2.753276008e-007
	,3.366085102e-007
	,4.166407633e-007
	,5.209139788e-007
	,6.563583099e-007
	,8.316270740e-007
	,1.057394032e-006
	,1.346636241e-006
	,1.714869190e-006
	,2.180292851e-006
	,2.763800061e-006
	,-2.381122429e-004
	,-2.237003042e-004
	,-2.093884093e-004
	,-1.951445017e-004
	,-1.809709990e-004
	,-1.669797348e-004
	,-1.533008477e-004
	,-1.400089544e-004
	,-1.271427753e-004
	,-1.147704068e-004
	,-1.029689512e-004
	,-9.176852861e-005
	,-8.117597558e-005
	,-7.119141669e-005
	,-6.180130542e-005
	,-5.297730112e-005
	,-4.478340143e-005
	,-3.732777750e-005
	,-3.066546779e-005
	,-2.481850705e-005
	,-1.977785902e-005
	,-1.551223173e-005
	,-1.197279664e-005
	,-9.095283935e-006
	,-6.801583085e-006
	,-5.004987379e-006
	,-3.632959147e-006
	,-2.608854284e-006
	,-1.855475026e-006
	,-1.308557282e-006
	,-9.158895784e-007
	,-6.362540680e-007
	,-4.383486435e-007
	,-2.989486584e-007
	,-2.011035942e-007
	,-1.325954557e-007
	,-8.470135267e-008
	,-5.123917901e-008
	,-2.785149325e-008
	,-1.147949283e-008
	,1.498592829e-017
	,8.080951831e-009
	,1.380943205e-008
	,1.791094160e-008
	,2.088802787e-008
	,2.308860645e-008
	,2.475344017e-008
	,2.604908111e-008
	,2.709070685e-008
	,2.795794053e-008
	,2.870580520e-008
	,2.937230611e-008
	,2.998367653e-008
	,3.055800695e-008
	,3.110775317e-008
	,3.164147060e-008
	,3.216501232e-008
	,3.268235553e-008
	,3.319617210e-008
	,3.370822214e-008
	,3.421962392e-008
	,3.473104050e-008
	,3.524280728e-008
	,3.575502016e-008
	,3.626759588e-008
	,3.678031442e-008
	,3.729284853e-008
	,3.780478539e-008
	,3.831564250e-008
	,3.882487974e-008
	,3.933190828e-008
	,3.983609755e-008
	,4.033678004e-008
	,4.083325493e-008
	,4.132479100e-008
	,4.181063025e-008
	,4.228999784e-008
	,4.276211775e-008
	,4.322622525e-008
	,4.368158804e-008
	,4.412753432e-008
	,4.456348934e-008
	,4.498901661e-008
	,4.540386503e-008
	,4.580801590e-008
	,4.620172151e-008
	,4.658552351e-008
	,4.696024115e-008
	,4.732692363e-008
	,4.768677333e-008
	,4.804105437e-008
	,4.839100482e-008
	,4.873776858e-008
	,4.908235281e-008
	,4.942560930e-008
	,4.976823355e-008
	,5.011078780e-008
	,5.045373170e-008
	,5.079742308e-008
	,5.114213556e-008
	,5.148807946e-008
	,5.183541657e-008
	,5.218427181e-008
	,5.253474169e-008
	,5.288690123e-008
	,5.324080886e-008
	,5.359651037e-008
	,5.395404182e-008
	,5.431343164e-008
	,5.467470264e-008
	,5.503787336e-008
	,5.540295916e-008
	,5.576997216e-008
	,5.613892144e-008
	,5.650981597e-008
	,5.688265661e-008
	,5.725744424e-008
	,5.763419254e-008
	,5.801290873e-008
	,5.839359592e-008
	,5.877625653e-008
	,5.916089193e-008
	,5.954750350e-008
	,5.993609196e-008
	,6.032665749e-008
	,6.071920029e-008
	,6.111372178e-008
	,6.151022322e-008
	,6.190870579e-008
	,6.230917163e-008
	,6.271162330e-008
	,6.311606333e-008
	,6.352249506e-008
	,6.393092239e-008
	,6.434135000e-008
	,6.475378369e-008
	,6.516823014e-008
	,6.558469729e-008
	,6.600319438e-008
	,6.642373187e-008
	,6.684632194e-008
	,6.727097810e-008
	,6.769771579e-008
	,6.812655199e-008
	,6.855750586e-008
	,6.899059854e-008
	,6.942585290e-008
	,6.986329334e-008
	,7.030294308e-008
	,7.074482932e-008
	,7.118898605e-008
	,7.163544696e-008
	,7.208424861e-008
	,7.253543046e-008
	,7.298903647e-008
	,7.344511536e-008
	,7.390372224e-008
	,7.436492074e-008
	,7.482878387e-008
	,7.529535662e-008
	,7.576471306e-008
	,7.623698427e-008
	,7.671229703e-008
	,7.719080648e-008
	,7.767270523e-008
	,7.815823462e-008
	,7.864770052e-008
	,7.914149371e-008
	,7.964011724e-008
	,8.014422196e-008
	,8.065465360e-008
	,8.117249454e-008
	,8.169919894e-008
	,8.223665724e-008
	,8.278735339e-008
	,8.335455692e-008
	,8.394257632e-008
	,8.455709152e-008
	,8.520560698e-008
	,8.589803532e-008
	,8.664748101e-008
	,8.747120362e-008
	,8.839210758e-008
	,8.944058083e-008
	,9.065682156e-008
	,9.209410941e-008
	,9.382311074e-008
	,9.593758831e-008
	,9.852474785e-008
	,1.017478295e-007
	,1.058295214e-007
	,1.110437882e-007
	,1.177518826e-007
	,1.264296153e-007
	,1.377028243e-007
	,1.523932925e-007
	,1.715778597e-007
	,1.966639677e-007
	,2.294854851e-007
	,2.724224074e-007
	,3.285484742e-007
	,-2.437985786e-004
	,-2.290956871e-004
	,-2.143657422e-004
	,-1.996072057e-004
	,-1.849613743e-004
	,-1.706092081e-004
	,-1.566494080e-004
	,-1.431133213e-004
	,-1.300330373e-004
	,-1.174830396e-004
	,-1.055056129e-004
	,-9.410818324e-005
	,-8.328708426e-005
	,-7.302229274e-005
	,-6.327944176e-005
	,-5.413730527e-005
	,-4.571950617e-005
	,-3.808545558e-005
	,-3.127465375e-005
	,-2.530063752e-005
	,-2.015094794e-005
	,-1.579350601e-005
	,-1.217850370e-005
	,-9.238252879e-006
	,-6.887616318e-006
	,-5.056582007e-006
	,-3.667897203e-006
	,-2.632474025e-006
	,-1.871392877e-006
	,-1.319524579e-006
	,-9.234943761e-007
	,-6.415305542e-007
	,-4.420025955e-007
	,-3.014668514e-007
	,-2.028231668e-007
	,-1.337506175e-007
	,-8.545511922e-008
	,-5.170410764e-008
	,-2.809885946e-008
	,-1.158096746e-008
	,3.759408848e-018
	,8.159306581e-009
	,1.394972535e-008
	,1.810134819e-008
	,2.112012090e-008
	,2.335648065e-008
	,2.505305700e-008
	,2.637778215e-008
	,2.744685467e-008
	,2.834065533e-008
	,2.911477323e-008
	,2.980764138e-008
	,3.044582284e-008
	,3.104766844e-008
	,3.162584825e-008
	,3.218910235e-008
	,3.274345117e-008
	,3.329303206e-008
	,3.384067748e-008
	,3.438831343e-008
	,3.493723441e-008
	,3.548829228e-008
	,3.604202609e-008
	,3.659875062e-008
	,3.715861627e-008
	,3.772165008e-008
	,3.828778259e-008
	,3.885686585e-008
	,3.942868515e-008
	,4.000296688e-008
	,4.057938366e-008
	,4.115755849e-008
	,4.173706785e-008
	,4.231744533e-008
	,4.289818499e-008
	,4.347874490e-008
	,4.405855091e-008
	,4.463699910e-008
	,4.521345759e-008
	,4.578726696e-008
	,4.635773906e-008
	,4.692415578e-008
	,4.748576822e-008
	,4.804179814e-008
	,4.859144277e-008
	,4.913388419e-008
	,4.966830222e-008
	,5.019389105e-008
	,5.070988494e-008
	,5.121560220e-008
	,5.171047566e-008
	,5.219408800e-008
	,5.266622121e-008
	,5.312690654e-008
	,5.357646287e-008
	,5.401551467e-008
	,5.444497673e-008
	,5.486600200e-008
	,5.527989910e-008
	,5.568803428e-008
	,5.609173529e-008
	,5.649221650e-008
	,5.689055969e-008
	,5.728770020e-008
	,5.768439974e-008
	,5.808126422e-008
	,5.847877052e-008
	,5.887729021e-008
	,5.927711074e-008
	,5.967845337e-008
	,6.008148829e-008
	,6.048634625e-008
	,6.089312788e-008
	,6.130191086e-008
	,6.171275548e-008
	,6.212570874e-008
	,6.254080734e-008
	,6.295808030e-008
	,6.337755062e-008
	,6.379923674e-008
	,6.422315294e-008
	,6.464931059e-008
	,6.507771460e-008
	,6.550835626e-008
	,6.594124270e-008
	,6.637639333e-008
	,6.681381865e-008
	,6.725352314e-008
	,6.769550894e-008
	,6.813977740e-008
	,6.858632914e-008
	,6.903516565e-008
	,6.948628930e-008
	,6.993970246e-008
	,7.039540714e-008
	,7.085340569e-008
	,7.131370064e-008
	,7.177629518e-008
	,7.224119328e-008
	,7.270839954e-008
	,7.317791945e-008
	,7.364975926e-008
	,7.412392714e-008
	,7.460043301e-008
	,7.507928782e-008
	,7.556050400e-008
	,7.604409540e-008
	,7.653007765e-008
	,7.701846824e-008
	,7.750928646e-008
	,7.800255365e-008
	,7.849829294e-008
	,7.899652962e-008
	,7.949729074e-008
	,8.000060462e-008
	,8.050650030e-008
	,8.101501359e-008
	,8.152618016e-008
	,8.204003797e-008
	,8.255662708e-008
	,8.307598952e-008
	,8.359817062e-008
	,8.412321916e-008
	,8.465118726e-008
	,8.518213215e-008
	,8.571611195e-008
	,8.625316539e-008
	,8.679338315e-008
	,8.733684701e-008
	,8.788365090e-008
	,8.843390440e-008
	,8.898773737e-008
	,8.954530287e-008
	,9.010678684e-008
	,9.067243109e-008
	,9.124253271e-008
	,9.181746409e-008
	,9.239770780e-008
	,9.298388293e-008
	,9.357679058e-008
	,9.417747265e-008
	,9.478728877e-008
	,9.540801803e-008
	,9.604199405e-008
	,9.669228257e-008
	,9.736291837e-008
	,9.805921554e-008
	,9.878814209e-008
	,9.955890906e-008
	,1.003837573e-007
	,1.012788169e-007
	,1.022654254e-007
	,1.033718287e-007
