		,1.940773365e-016
		,2.020635312e-016
		,2.062317704e-016
		,2.111947964e-016
		,2.225512501e-016
		,2.219841867e-016
		,2.249736552e-016
		,2.433689549e-016
		,2.857396660e-016
		,3.141266578e-016
		,3.400617842e-016
		,3.674064781e-016
		,3.786392042e-016
		,3.902482045e-016
		,3.917420441e-016
		,3.973414986e-016
		,4.026207504e-016
		,4.076679270e-016
		,4.124050985e-016
		,4.187041748e-016
		,4.238521160e-016
		,4.271686738e-016
		,4.305863075e-016
		,4.346355756e-016
		,4.391730236e-016
		,4.436144085e-016
		,4.474759806e-016
		,4.506347156e-016
		,4.531875841e-016
		,4.552835797e-016
		,4.570565484e-016
		,4.586137798e-016
		,1.705400447e-016
		,1.709616711e-016
		,1.714649551e-016
		,1.720808063e-016
		,1.728518274e-016
		,1.738363036e-016
		,1.751076402e-016
		,1.767496889e-016
		,1.789009851e-016
		,1.817955320e-016
		,1.855143905e-016
		,1.902820306e-016
		,1.979428601e-016
		,2.019408077e-016
		,2.110749409e-016
		,2.204973166e-016
		,2.186936507e-016
		,2.340376682e-016
		,2.714519527e-016
		,2.991371045e-016
		,3.376875073e-016
		,3.670468331e-016
		,3.885822030e-016
		,3.929345373e-016
		,3.974763348e-016
		,3.982361372e-016
		,4.047302480e-016
		,4.105974489e-016
		,4.147015637e-016
		,4.181312114e-016
		,4.213119057e-016
		,4.246532617e-016
		,4.285885967e-016
		,4.333146000e-016
		,4.384613603e-016
		,4.433419275e-016
		,4.475071215e-016
		,4.508878345e-016
		,4.536102232e-016
		,4.558332817e-016
		,4.576885946e-016
		,1.698084090e-016
		,1.701206467e-016
		,1.704657135e-016
		,1.708531583e-016
		,1.712957351e-016
		,1.718109423e-016
		,1.724222178e-016
		,1.731639147e-016
		,1.740847207e-016
		,1.752638591e-016
		,1.768375666e-016
		,1.790669861e-016
		,1.823206714e-016
		,1.869542419e-016
		,1.926959438e-016
		,1.984945865e-016
		,2.089188762e-016
		,2.153015532e-016
		,2.310305089e-016
		,2.618854702e-016
		,3.042244103e-016
		,3.365143029e-016
		,3.640424452e-016
		,3.827942534e-016
		,3.985732699e-016
		,4.069873353e-016
		,4.100764982e-016
		,4.137327037e-016
		,4.151968985e-016
		,4.154563437e-016
		,4.178739819e-016
		,4.213067717e-016
		,4.251343676e-016
		,4.295031880e-016
		,4.344336495e-016
		,4.394967672e-016
		,4.441216427e-016
		,4.480232264e-016
		,4.512170008e-016
		,4.538385723e-016
		,4.560291123e-016
		,1.692734115e-016
		,1.695603639e-016
		,1.698714295e-016
		,1.702084017e-016
		,1.705750762e-016
		,1.709763748e-016
		,1.714184733e-016
		,1.719097573e-016
		,1.724623555e-016
		,1.730963280e-016
		,1.738469218e-016
		,1.747738971e-016
		,1.759751800e-016
		,1.776658446e-016
		,1.801330675e-016
		,1.841767915e-016
		,1.894991164e-016
		,1.990593180e-016
		,2.155587418e-016
		,2.374678004e-016
		,2.728051117e-016
		,3.120782825e-016
		,3.435476820e-016
		,3.661888169e-016
		,3.821006266e-016
		,3.936005743e-016
		,4.020409109e-016
		,4.084217921e-016
		,4.132529370e-016
		,4.162464716e-016
		,4.181424698e-016
		,4.207695277e-016
		,4.236750744e-016
		,4.269334517e-016
		,4.311754800e-016
		,4.363629512e-016
		,4.414139049e-016
		,4.456304109e-016
		,4.489600613e-016
		,4.516255491e-016
		,4.538554733e-016
		,1.688428117e-016
		,1.690872858e-016
		,1.693847027e-016
		,1.697142096e-016
		,1.700700402e-016
		,1.704513079e-016
		,1.708588747e-016
		,1.712949108e-016
		,1.717636910e-016
		,1.722731534e-016
		,1.728372333e-016
		,1.734795627e-016
		,1.742403040e-016
		,1.751907973e-016
		,1.764685685e-016
		,1.783666068e-016
		,1.815627914e-016
		,1.876506700e-016
		,1.999108062e-016
		,2.224976201e-016
		,2.549247354e-016
		,2.893467569e-016
		,3.192034213e-016
		,3.434587488e-016
		,3.625244925e-016
		,3.767997319e-016
		,3.872429190e-016
		,3.949796982e-016
		,4.008916063e-016
		,4.055842533e-016
		,4.094872008e-016
		,4.129617631e-016
		,4.163952925e-016
		,4.202411463e-016
		,4.248745881e-016
		,4.302330408e-016
		,4.357141977e-016
		,4.406656446e-016
		,4.448074351e-016
		,4.481758561e-016
		,4.509207404e-016
		,1.690320674e-016
		,1.688360797e-016
		,1.689901142e-016
		,1.692785245e-016
		,1.696264712e-016
		,1.700086471e-016
		,1.704167821e-016
		,1.708490890e-016
		,1.713084452e-016
		,1.718023174e-016
		,1.723440169e-016
		,1.729555643e-016
		,1.736741463e-016
		,1.745870289e-016
		,1.758328740e-016
		,1.776214309e-016
		,1.805855650e-016
		,1.863939515e-016
		,1.971473672e-016
		,2.159414918e-016
		,2.386385961e-016
		,2.640202796e-016
		,2.968077714e-016
		,3.245510907e-016
		,3.468932269e-016
		,3.627436551e-016
		,3.739351142e-016
		,3.819550033e-016
		,3.888037664e-016
		,3.951941090e-016
		,3.990779639e-016
		,4.025923036e-016
		,4.061089666e-016
		,4.099457729e-016
		,4.142437481e-016
		,4.192384486e-016
		,4.249201726e-016
		,4.304227782e-016
		,4.354242209e-016
		,4.401984773e-016
		,4.448445971e-016
		,1.739743207e-016
		,1.704997872e-016
		,1.692897574e-016
		,1.690895199e-016
		,1.692771881e-016
		,1.696129068e-016
		,1.700135621e-016
		,1.704530653e-016
		,1.709272373e-016
		,1.714436417e-016
		,1.720151629e-016
		,1.726732522e-016
		,1.734869206e-016
		,1.745426136e-016
		,1.758915781e-016
		,1.780513938e-016
		,1.820361585e-016
		,1.874051977e-016
		,1.971171272e-016
		,2.114869466e-016
		,2.317317648e-016
		,2.523262415e-016
		,2.761797082e-016
		,2.996498638e-016
		,3.292911856e-016
		,3.485125925e-016
		,3.630550578e-016
		,3.717035517e-016
		,3.780102670e-016
		,3.830148146e-016
		,3.868613732e-016
		,3.908241362e-016
		,3.969785582e-016
		,4.014821726e-016
		,4.061841250e-016
		,4.116996304e-016
		,4.175722686e-016
		,4.231761094e-016
		,4.280692653e-016
		,4.321422864e-016
		,4.354826277e-016
		,1.989145357e-016
		,1.831558712e-016
		,1.748813041e-016
		,1.710474806e-016
		,1.697162197e-016
		,1.695034849e-016
		,1.697234789e-016
		,1.701151069e-016
		,1.705936190e-016
		,1.711369325e-016
		,1.717729565e-016
		,1.725519372e-016
		,1.735589858e-016
		,1.747756368e-016
		,1.765860425e-016
		,1.795937582e-016
		,1.835863509e-016
		,1.882466717e-016
		,1.950308296e-016
		,2.067355260e-016
		,2.192913610e-016
		,2.348284957e-016
		,2.536097335e-016
		,2.893441520e-016
		,3.108247266e-016
		,3.260125227e-016
		,3.446398902e-016
		,3.581443462e-016
		,3.682425851e-016
		,3.759627974e-016
		,3.789955985e-016
		,3.820752356e-016
		,3.850423540e-016
		,3.879730632e-016
		,3.930449653e-016
		,4.046905365e-016
		,4.133687705e-016
		,4.199421471e-016
		,4.255081378e-016
		,4.301399657e-016
		,4.339438809e-016
		,2.716640789e-016
		,2.352704562e-016
		,2.041655211e-016
		,1.855971998e-016
		,1.761237797e-016
		,1.718271952e-016
		,1.703479329e-016
		,1.701314470e-016
		,1.704169668e-016
		,1.709502170e-016
		,1.716716984e-016
		,1.726175539e-016
		,1.737285596e-016
		,1.753356076e-016
		,1.779477592e-016
		,1.815379721e-016
		,1.849295622e-016
		,1.916338385e-016
		,1.984234195e-016
		,2.027969025e-016
		,2.122209478e-016
		,2.167661076e-016
		,2.375272751e-016
		,2.577475610e-016
		,2.821422372e-016
		,3.099741358e-016
		,3.270230563e-016
		,3.409544113e-016
		,3.527511989e-016
		,3.590341186e-016
		,3.652437707e-016
		,3.710149066e-016
		,3.758733864e-016
		,3.797225798e-016
		,3.833916257e-016
		,3.874185258e-016
		,3.921580570e-016
		,4.004750947e-016
		,4.154093515e-016
		,4.238783165e-016
		,4.287754764e-016
		,3.343888701e-016
		,3.120765120e-016
		,2.823896264e-016
		,2.457057963e-016
		,2.111140373e-016
		,1.889784407e-016
		,1.778384664e-016
		,1.729450056e-016
		,1.713442794e-016
		,1.712683813e-016
		,1.719136499e-016
		,1.728675670e-016
		,1.742237276e-016
		,1.765005058e-016
		,1.796998445e-016
		,1.825617511e-016
		,1.870681039e-016
		,1.938746540e-016
		,1.993693092e-016
		,2.038149988e-016
		,2.072673302e-016
		,2.158645521e-016
		,2.261079976e-016
		,2.448805481e-016
		,2.539629175e-016
		,2.702758007e-016
		,3.010143453e-016
		,3.173584833e-016
		,3.233763041e-016
		,3.333136330e-016
		,3.467858944e-016
		,3.557497230e-016
		,3.619053636e-016
		,3.673426599e-016
		,3.722338783e-016
		,3.759399535e-016
		,3.786482678e-016
		,3.825018818e-016
		,3.871976915e-016
		,3.926443350e-016
		,4.070233985e-016
		,3.696563102e-016
		,3.577898790e-016
		,3.422928463e-016
		,3.216228970e-016
		,2.937034876e-016
		,2.576744314e-016
		,2.202413253e-016
		,1.938465141e-016
		,1.804627698e-016
		,1.749669859e-016
		,1.734245443e-016
		,1.737539364e-016
		,1.754994500e-016
		,1.783858688e-016
		,1.813861931e-016
		,1.833760988e-016
		,1.900144410e-016
		,1.958698819e-016
		,2.005803022e-016
		,2.018491882e-016
		,2.061973435e-016
		,2.096875914e-016
		,2.204856769e-016
		,2.280491101e-016
		,2.482142837e-016
		,2.637822423e-016
		,2.754417636e-016
		,2.928762717e-016
		,3.178371943e-016
		,3.302958502e-016
		,3.395727132e-016
		,3.485512981e-016
		,3.590719138e-016
		,3.646950520e-016
		,3.667110437e-016
		,3.712181667e-016
		,3.783303242e-016
		,3.851683261e-016
		,3.905888017e-016
		,3.944550524e-016
		,3.966328576e-016
		,3.896314383e-016
		,3.828646825e-016
		,3.744597285e-016
		,3.637721393e-016
		,3.498250072e-016
		,3.310989886e-016
		,3.054411198e-016
		,2.711656576e-016
		,2.323059914e-016
		,2.014434526e-016
		,1.849997157e-016
		,1.790035932e-016
		,1.786152907e-016
		,1.809104876e-016
		,1.817393875e-016
		,1.863211429e-016
		,1.924081280e-016
		,1.968329094e-016
		,2.010770698e-016
		,2.029365740e-016
		,2.025088590e-016
		,2.089258567e-016
		,2.165111303e-016
		,2.219143900e-016
		,2.333812273e-016
		,2.538021258e-016
		,2.661723876e-016
		,2.690903260e-016
		,2.841039487e-016
		,3.127297156e-016
		,3.299082634e-016
		,3.385304908e-016
		,3.416906657e-016
		,3.477300022e-016
		,3.586712294e-016
		,3.669425409e-016
		,3.743493944e-016
		,3.817970625e-016
		,3.893163919e-016
		,3.959902731e-016
		,4.009698913e-016
		,4.019775460e-016
		,3.977157492e-016
		,3.926313831e-016
		,3.864776567e-016
		,3.788839022e-016
		,3.692218375e-016
		,3.567252495e-016
		,3.399091281e-016
		,3.169263314e-016
		,2.856461350e-016
		,2.476286816e-016
		,2.136902064e-016
		,1.944691905e-016
		,1.863535547e-016
		,1.851507573e-016
		,1.898589064e-016
		,1.950333687e-016
		,1.972763254e-016
		,2.005457896e-016
		,2.037340797e-016
		,2.001896648e-016
		,2.057573341e-016
		,2.140041346e-016
		,2.175292587e-016
		,2.283245106e-016
		,2.407895659e-016
		,2.550464471e-016
		,2.615568750e-016
		,2.689732074e-016
		,2.798591528e-016
		,2.993342592e-016
		,3.201323389e-016
		,3.278116876e-016
		,3.366669266e-016
		,3.452106421e-016
		,3.564818561e-016
		,3.677644596e-016
		,3.764903665e-016
		,3.841146090e-016
		,3.909548824e-016
		,3.972134009e-016
		,4.101513296e-016
		,4.072488377e-016
		,4.039126281e-016
		,4.000063149e-016
		,3.953864913e-016
		,3.898486664e-016
		,3.829535866e-016
		,3.744032994e-016
		,3.631018285e-016
		,3.481155716e-016
		,3.275520609e-016
		,2.995871904e-016
		,2.620282177e-016
		,2.239263988e-016
		,2.027702983e-016
		,1.970512955e-016
		,1.978582073e-016
		,1.989580740e-016
		,2.005677133e-016
		,2.034346538e-016
		,1.994677922e-016
		,2.039031758e-016
		,2.092153172e-016
		,2.154406741e-016
		,2.246379343e-016
		,2.333298369e-016
		,2.416712387e-016
		,2.528630192e-016
		,2.626041074e-016
		,2.687224670e-016
		,2.720374218e-016
		,2.789313597e-016
		,3.086992750e-016
		,3.248347726e-016
		,3.347430233e-016
		,3.437262325e-016
		,3.534395812e-016
		,3.657626408e-016
		,3.761656087e-016
		,3.841168747e-016
		,3.906135087e-016
		,4.181454108e-016
		,4.160623591e-016
		,4.137459727e-016
		,4.111233692e-016
		,4.080978699e-016
		,4.043933511e-016
		,3.997811165e-016
		,3.935432344e-016
		,3.865332316e-016
		,3.766473679e-016
		,3.654894143e-016
		,3.502401733e-016
		,3.284169187e-016
		,2.989156361e-016
		,2.605815502e-016
		,2.267987415e-016
		,2.094935734e-016
		,2.043608328e-016
		,2.027777306e-016
		,2.035998398e-016
		,1.978101373e-016
		,2.039570792e-016
		,2.053248223e-016
		,2.130032193e-016
		,2.218386786e-016
		,2.302584766e-016
		,2.311367746e-016
		,2.408706455e-016
		,2.543581061e-016
		,2.626321021e-016
		,2.618938097e-016
		,2.644039427e-016
		,2.744472786e-016
		,2.913313058e-016
		,3.199904264e-016
		,3.310373433e-016
		,3.408191479e-016
		,3.503694805e-016
		,3.612708933e-016
		,3.727928830e-016
		,3.813538596e-016
		,4.243237086e-016
		,4.227048736e-016
		,4.209354465e-016
		,4.189806719e-016
		,4.166034268e-016
		,4.142559531e-016
		,4.113062526e-016
		,4.078227401e-016
		,4.033748086e-016
		,3.978717323e-016
		,3.902390150e-016
		,3.798721508e-016
		,3.644309653e-016
		,3.419595112e-016
		,3.136935509e-016
		,2.779338842e-016
		,2.438138858e-016
		,2.231639454e-016
		,2.133347680e-016
		,2.088685187e-016
		,2.023352500e-016
		,1.995189556e-016
		,2.027409934e-016
		,2.105889880e-016
		,2.194775515e-016
		,2.263036572e-016
		,2.282416183e-016
		,2.328590961e-016
		,2.415718106e-016
		,2.511444953e-016
		,2.534191203e-016
		,2.595007554e-016
		,2.646243063e-016
		,2.734492805e-016
		,2.802207060e-016
		,3.080612160e-016
		,3.242787828e-016
		,3.347789765e-016
		,3.448037832e-016
		,3.547143674e-016
		,3.656631585e-016
		,4.319192698e-016
		,4.301946065e-016
		,4.284880637e-016
		,4.267993934e-016
		,4.249237600e-016
		,4.227793492e-016
		,4.203638444e-016
		,4.175466517e-016
		,4.140652668e-016
		,4.097831074e-016
		,4.041575503e-016
		,3.964512402e-016
		,3.836721843e-016
		,3.681085514e-016
		,3.447948994e-016
		,3.161427024e-016
		,2.841593589e-016
		,2.560592208e-016
		,2.347179909e-016
		,2.238883197e-016
		,2.169191452e-016
		,2.033395001e-016
		,2.026590352e-016
		,2.111435684e-016
		,2.169730031e-016
		,2.208759948e-016
		,2.210136032e-016
		,2.287649113e-016
		,2.344577358e-016
		,2.354358573e-016
		,2.448425208e-016
		,2.529851128e-016
		,2.592554653e-016
		,2.635803558e-016
		,2.697409854e-016
		,2.762185456e-016
		,2.889551568e-016
		,3.151643599e-016
		,3.263872363e-016
		,3.365525061e-016
		,3.460647603e-016
		,4.383392568e-016
		,4.368953971e-016
		,4.353948977e-016
		,4.337725168e-016
		,4.320124653e-016
		,4.300846036e-016
		,4.279395466e-016
		,4.254530723e-016
		,4.225603523e-016
		,4.191672166e-016
		,4.147613242e-016
		,4.072871286e-016
		,3.994423024e-016
		,3.858411179e-016
		,3.663109630e-016
		,3.409537282e-016
		,3.157991711e-016
		,2.879577625e-016
		,2.633560970e-016
		,2.459014619e-016
		,2.375977322e-016
		,2.184495437e-016
		,2.132108272e-016
		,2.162323669e-016
		,2.192251978e-016
		,2.201499617e-016
		,2.203191837e-016
		,2.251683503e-016
		,2.273821102e-016
		,2.238250020e-016
		,2.252563683e-016
		,2.430107031e-016
		,2.520707610e-016
		,2.577154912e-016
		,2.613325037e-016
		,2.652129254e-016
		,2.711616677e-016
		,2.744640335e-016
		,2.989093786e-016
		,3.146126176e-016
		,3.246520779e-016
		,4.457237602e-016
		,4.443544977e-016
		,4.428798887e-016
		,4.412993376e-016
		,4.395937288e-016
		,4.377518026e-016
		,4.357466421e-016
		,4.335140480e-016
		,4.307883682e-016
		,4.277886387e-016
		,4.238667213e-016
		,4.175026868e-016
		,4.103316324e-016
		,3.973912733e-016
		,3.819864868e-016
		,3.633597072e-016
		,3.415525811e-016
		,3.179395955e-016
		,2.890729687e-016
		,2.698493982e-016
		,2.589576129e-016
		,2.362535531e-016
		,2.330994801e-016
		,2.314514931e-016
		,2.301056003e-016
		,2.252416889e-016
		,2.226762947e-016
		,2.243831769e-016
		,2.241424896e-016
		,2.235136618e-016
		,2.274993936e-016
		,2.300200444e-016
		,2.388534839e-016
		,2.427303189e-016
		,2.423218087e-016
		,2.534813978e-016
		,2.595937356e-016
		,2.641579646e-016
		,2.661330513e-016
		,2.751584777e-016
		,2.992823473e-016
		,4.547134888e-016
		,4.535051779e-016
		,4.521903305e-016
		,4.507599791e-016
		,4.492313950e-016
		,4.475999963e-016
		,4.458434922e-016
		,4.439252732e-016
		,4.418075734e-016
		,4.393895731e-016
		,4.363660787e-016
		,4.316396722e-016
		,4.167578762e-016
		,4.116261277e-016
		,3.973967082e-016
		,3.815886313e-016
		,3.610573375e-016
		,3.383837355e-016
		,3.109826000e-016
		,2.920171347e-016
		,2.856158470e-016
		,2.492430600e-016
		,2.529815886e-016
		,2.507053203e-016
		,2.472883248e-016
		,2.387424937e-016
		,2.347737147e-016
		,2.306436566e-016
		,2.236222816e-016
		,2.245735970e-016
		,2.269831685e-016
		,2.303575595e-016
		,2.321243144e-016
		,2.398681670e-016
		,2.455742834e-016
		,2.474830994e-016
		,2.465729983e-016
		,2.423752906e-016
		,2.324128330e-016
		,2.482895128e-016
		,2.555866842e-016
		,4.650778949e-016
		,4.639508271e-016
		,4.632105451e-016
		,4.623493723e-016
		,4.612862525e-016
		,4.601516781e-016
		,4.589494131e-016
		,4.576664180e-016
		,4.562907749e-016
		,4.522062625e-016
		,4.510908915e-016
		,4.465744414e-016
		,4.431946082e-016
		,4.299218515e-016
		,4.145684618e-016
		,3.985035832e-016
		,3.803404224e-016
		,3.584456177e-016
		,3.300549944e-016
		,3.061794285e-016
		,3.019685666e-016
		,2.706087656e-016
		,2.674546131e-016
		,2.703110793e-016
		,2.652106424e-016
		,2.551765594e-016
		,2.500298926e-016
		,2.431214640e-016
		,2.357423437e-016
		,2.325797678e-016
		,2.315505159e-016
		,2.308250497e-016
		,2.323688466e-016
		,2.326582735e-016
		,2.379785568e-016
		,2.440376430e-016
		,2.453586274e-016
		,2.447782459e-016
		,2.424102387e-016
		,2.389785546e-016
		,2.350552466e-016
		,1.723382372e-016
		,1.732124017e-016
		,1.743243108e-016
		,1.757290497e-016
		,1.774677581e-016
		,1.796115369e-016
		,1.821518461e-016
		,1.853555089e-016
		,1.893579297e-016
		,1.944074003e-016
		,2.024036728e-016
		,2.063359484e-016
		,2.112934291e-016
		,2.228759286e-016
		,2.223008544e-016
		,2.248895586e-016
		,2.388575909e-016
		,2.833557070e-016
		,3.128089486e-016
		,3.372049193e-016
		,3.636417252e-016
		,3.732490261e-016
		,3.870376406e-016
		,3.918797340e-016
		,3.978721379e-016
		,4.028513982e-016
		,4.073104096e-016
		,4.116500873e-016
		,4.160188904e-016
		,4.221060084e-016
		,4.267189483e-016
		,4.302415593e-016
		,4.341766360e-016
		,4.386505905e-016
		,4.431489415e-016
		,4.471359616e-016
		,4.504249354e-016
		,4.530850537e-016
		,4.552574709e-016
		,4.570705516e-016
		,4.586239407e-016
		,1.708124623e-016
		,1.712553315e-016
		,1.717845255e-016
		,1.724307231e-016
		,1.732356991e-016
		,1.742559045e-016
		,1.755575778e-016
		,1.772272266e-016
		,1.794036196e-016
		,1.822958062e-016
		,1.859570615e-016
		,1.907112130e-016
		,1.983685271e-016
		,2.021933225e-016
		,2.112878008e-016
		,2.207292754e-016
		,2.183469078e-016
		,2.303219281e-016
		,2.698926490e-016
		,2.970376610e-016
		,3.339897709e-016
		,3.628610800e-016
		,3.873551920e-016
		,3.920122841e-016
		,3.966429662e-016
		,3.965143796e-016
		,4.023594878e-016
		,4.103887484e-016
		,4.148990212e-016
		,4.183071240e-016
		,4.213634277e-016
		,4.245057984e-016
		,4.281648606e-016
		,4.326344058e-016
		,4.377147954e-016
		,4.427148740e-016
		,4.470466300e-016
		,4.505662095e-016
		,4.533908178e-016
		,4.556872810e-016
		,4.575948260e-016
		,1.700843039e-016
		,1.704156034e-016
		,1.707825936e-016
		,1.711941085e-016
		,1.716616360e-016
		,1.722015916e-016
		,1.728360519e-016
		,1.735971760e-016
		,1.745341677e-016
		,1.757269348e-016
		,1.773142400e-016
		,1.795594956e-016
		,1.828225679e-016
		,1.874373118e-016
		,1.930532950e-016
		,1.987568795e-016
		,2.091482842e-016
		,2.157212058e-016
		,2.293855063e-016
		,2.606759453e-016
		,3.011132125e-016
		,3.334213646e-016
		,3.630234728e-016
		,3.817747788e-016
		,3.964494468e-016
		,4.057480602e-016
		,4.091482676e-016
		,4.128025224e-016
		,4.140174726e-016
		,4.147864971e-016
		,4.176879229e-016
		,4.212199184e-016
		,4.250214863e-016
		,4.293350394e-016
		,4.342337505e-016
		,4.393090200e-016
		,4.439721723e-016
		,4.479119860e-016
		,4.511307889e-016
		,4.537624221e-016
		,4.559506500e-016
		,1.695629238e-016
		,1.698696778e-016
		,1.702023834e-016
		,1.705616081e-016
		,1.709495491e-016
		,1.713694431e-016
		,1.718261918e-016
		,1.723278126e-016
		,1.728871454e-016
		,1.735256423e-016
		,1.742810051e-016
		,1.752141675e-016
		,1.764263440e-016
		,1.781435709e-016
		,1.806372715e-016
		,1.846845567e-016
		,1.900055821e-016
		,1.996295596e-016
		,2.153324430e-016
		,2.372770030e-016
		,2.709753959e-016
		,3.103688308e-016
		,3.423587530e-016
		,3.651136744e-016
		,3.819049881e-016
		,3.935502619e-016
		,4.019901693e-016
		,4.083568536e-016
		,4.131587286e-016
		,4.160532958e-016
		,4.179992073e-016
		,4.206278730e-016
		,4.234377242e-016
		,4.265572774e-016
		,4.307526589e-016
		,4.359812858e-016
		,4.411614063e-016
		,4.455637056e-016
		,4.490431964e-016
		,4.517641313e-016
		,4.539547211e-016
		,1.691490438e-016
		,1.694148956e-016
		,1.697341454e-016
		,1.700845854e-016
		,1.704587809e-016
		,1.708543830e-016
		,1.712714812e-016
		,1.717124693e-016
		,1.721828682e-016
		,1.726926623e-016
		,1.732583002e-016
		,1.739061076e-016
		,1.746789920e-016
		,1.756512212e-016
		,1.769640169e-016
		,1.789161204e-016
		,1.821946065e-016
		,1.884014421e-016
		,2.007954468e-016
		,2.234262111e-016
		,2.557060777e-016
		,2.898877706e-016
		,3.195523247e-016
		,3.436873117e-016
		,3.626803057e-016
		,3.769106762e-016
		,3.873253497e-016
		,3.950432686e-016
		,4.009421555e-016
		,4.056254582e-016
		,4.095214826e-016
		,4.129907887e-016
		,4.164202581e-016
		,4.202629305e-016
		,4.248938101e-016
		,4.302500920e-016
		,4.357293414e-016
		,4.406791251e-016
		,4.448194977e-016
		,4.481867216e-016
		,4.509305918e-016
		,1.693503272e-016
		,1.691808738e-016
		,1.693578097e-016
		,1.696658073e-016
		,1.700291351e-016
		,1.704217194e-016
		,1.708353429e-016
		,1.712692226e-016
		,1.717279462e-016
		,1.722216205e-016
		,1.727661947e-016
		,1.733870800e-016
		,1.741229213e-016
		,1.750620012e-016
		,1.763555723e-016
		,1.782403769e-016
		,1.812757089e-016
		,1.873412689e-016
		,1.984399693e-016
		,2.179376057e-016
		,2.407501794e-016
		,2.667687645e-016
		,2.985464459e-016
		,3.261482434e-016
		,3.479940662e-016
		,3.635769917e-016
		,3.746175254e-016
		,3.825564768e-016
		,3.893119970e-016
		,3.959627358e-016
		,4.001489692e-016
		,4.033764082e-016
		,4.066263443e-016
		,4.104622754e-016
		,4.150897494e-016
		,4.204479446e-016
		,4.258156945e-016
		,4.308856267e-016
		,4.356429104e-016
		,4.401326476e-016
		,4.446228549e-016
		,1.742593379e-016
		,1.708428006e-016
		,1.696675319e-016
		,1.694892072e-016
		,1.696905862e-016
		,1.700337334e-016
		,1.704369064e-016
		,1.708761427e-016
		,1.713497569e-016
		,1.718679563e-016
		,1.724477180e-016
		,1.731169704e-016
		,1.739552655e-016
		,1.750555807e-016
		,1.764817418e-016
		,1.787050474e-016
		,1.828951927e-016
		,1.886838792e-016
		,1.986864403e-016
		,2.140090729e-016
		,2.341675871e-016
		,2.564541559e-016
		,2.796358907e-016
		,3.021433148e-016
		,3.311762443e-016
		,3.501997016e-016
		,3.649076098e-016
		,3.747132898e-016
		,3.799145174e-016
		,3.839356523e-016
		,3.876318998e-016
		,3.916916313e-016
		,3.990432981e-016
		,4.037353464e-016
		,4.075252455e-016
		,4.129039966e-016
		,4.187394077e-016
		,4.242473147e-016
		,4.290175405e-016
		,4.329763461e-016
		,4.362228768e-016
		,1.988418503e-016
		,1.833656770e-016
		,1.752144745e-016
		,1.714362885e-016
		,1.701298360e-016
		,1.699267565e-016
		,1.701494464e-016
		,1.705414985e-016
		,1.710223526e-016
		,1.715712781e-016
		,1.722178758e-016
		,1.730212068e-016
		,1.740718865e-016
		,1.753685948e-016
		,1.772036807e-016
		,1.803624361e-016
		,1.847188043e-016
		,1.895763867e-016
		,1.967388411e-016
		,2.094352421e-016
		,2.220999554e-016
		,2.390023497e-016
		,2.567415046e-016
		,2.931682217e-016
		,3.151820681e-016
		,3.321200256e-016
		,3.477255833e-016
		,3.595444309e-016
		,3.688899003e-016
		,3.768628995e-016
		,3.824204542e-016
		,3.845031141e-016
		,3.859806408e-016
		,3.888961771e-016
		,3.936889343e-016
		,4.051039580e-016
		,4.145542317e-016
		,4.211706338e-016
		,4.266288258e-016
		,4.311318268e-016
		,4.348268568e-016
		,2.709313057e-016
		,2.347309771e-016
		,2.040504085e-016
		,1.858080013e-016
		,1.764732779e-016
		,1.722284864e-016
		,1.707683070e-016
		,1.705608689e-016
		,1.708524536e-016
		,1.713970302e-016
		,1.721415600e-016
		,1.731341303e-016
		,1.743158165e-016
		,1.759474314e-016
		,1.786842157e-016
		,1.825640138e-016
		,1.862454625e-016
		,1.930279496e-016
		,2.004037826e-016
		,2.053571607e-016
		,2.156564994e-016
		,2.205527427e-016
		,2.403480524e-016
		,2.615970124e-016
		,2.893850348e-016
		,3.133781331e-016
		,3.293366628e-016
		,3.427414075e-016
		,3.564961487e-016
		,3.632597000e-016
		,3.661698527e-016
		,3.712592459e-016
		,3.761340802e-016
		,3.802247647e-016
		,3.842176166e-016
		,3.885723845e-016
		,3.934581921e-016
		,4.008912758e-016
		,4.156342937e-016
		,4.250420110e-016
		,4.302009751e-016
		,3.337971294e-016
		,3.114276222e-016
		,2.817076509e-016
		,2.451364532e-016
		,2.109181142e-016
		,1.891476158e-016
		,1.781803738e-016
		,1.733502819e-016
		,1.717821692e-016
		,1.717355128e-016
		,1.724295020e-016
		,1.734649312e-016
		,1.748220564e-016
		,1.772090022e-016
		,1.806321889e-016
		,1.839184835e-016
		,1.880829166e-016
		,1.956085745e-016
		,2.016618700e-016
		,2.062168249e-016
		,2.104163572e-016
		,2.190049816e-016
		,2.304276826e-016
		,2.508751738e-016
		,2.594599092e-016
		,2.744674890e-016
		,3.066034901e-016
		,3.265228260e-016
		,3.340758084e-016
		,3.390667008e-016
		,3.507351081e-016
		,3.590988308e-016
		,3.647274986e-016
		,3.701262625e-016
		,3.757861350e-016
		,3.800057950e-016
		,3.810623305e-016
		,3.759081739e-016
		,3.788627687e-016
		,3.889016309e-016
		,4.034164830e-016
		,3.693154301e-016
		,3.573774913e-016
		,3.417987705e-016
		,3.210529900e-016
		,2.930796659e-016
		,2.570951577e-016
		,2.199569267e-016
		,1.939627208e-016
		,1.808154333e-016
		,1.754444165e-016
		,1.740124630e-016
		,1.743480888e-016
		,1.761899645e-016
		,1.792452015e-016
		,1.826901809e-016
		,1.844017730e-016
		,1.913587298e-016
		,1.976928657e-016
		,2.030922597e-016
		,2.046159985e-016
		,2.087085182e-016
		,2.132142416e-016
		,2.235713534e-016
		,2.350006721e-016
		,2.519202116e-016
		,2.672584056e-016
		,2.798970648e-016
		,3.043529202e-016
		,3.235864250e-016
		,3.348205053e-016
		,3.438240544e-016
		,3.521765474e-016
		,3.626837580e-016
		,3.704152503e-016
		,3.762681861e-016
		,3.816620890e-016
		,3.859359461e-016
		,3.899209076e-016
		,3.947020692e-016
		,3.987245013e-016
		,4.013954344e-016
		,3.894405132e-016
		,3.826430699e-016
		,3.741970319e-016
		,3.634605568e-016
		,3.494413578e-016
		,3.306425501e-016
		,3.049196083e-016
		,2.706514905e-016
		,2.320274650e-016
		,2.016231357e-016
		,1.854442599e-016
		,1.796306542e-016
		,1.794208662e-016
		,1.820015493e-016
		,1.831222939e-016
		,1.872256590e-016
		,1.938941474e-016
		,1.990810194e-016
		,2.037428336e-016
		,2.053995971e-016
		,2.052603954e-016
		,2.120957121e-016
		,2.198276886e-016
		,2.270696233e-016
		,2.372980065e-016
		,2.577073589e-016
		,2.718621333e-016
		,2.776778566e-016
		,2.891749369e-016
		,3.194042741e-016
		,3.350202363e-016
		,3.445279336e-016
		,3.519859569e-016
		,3.589854754e-016
		,3.655796595e-016
		,3.714682818e-016
		,3.787273073e-016
		,3.860162703e-016
		,3.929871854e-016
		,3.994530228e-016
		,4.046585374e-016
		,4.018852403e-016
		,3.976070756e-016
		,3.925019956e-016
		,3.863364685e-016
		,3.786991607e-016
		,3.690543612e-016
		,3.565285115e-016
		,3.396934563e-016
		,3.166273215e-016
		,2.853791432e-016
		,2.475609781e-016
		,2.140591045e-016
		,1.952965525e-016
		,1.878445210e-016
		,1.859960651e-016
		,1.911239025e-016
		,1.966878962e-016
		,1.995059551e-016
		,2.035625028e-016
		,2.066286600e-016
		,2.024528765e-016
		,2.086411006e-016
		,2.179088330e-016
		,2.213367221e-016
		,2.310025843e-016
		,2.452956469e-016
		,2.627486317e-016
		,2.688156603e-016
		,2.732056706e-016
		,2.851164548e-016
		,3.081434719e-016
		,3.325209766e-016
		,3.401655865e-016
		,3.427715907e-016
		,3.496417915e-016
		,3.602215742e-016
		,3.722937853e-016
		,3.815672899e-016
		,3.891229905e-016
		,3.955115514e-016
		,4.010468555e-016
		,4.100991191e-016
		,4.071967287e-016
		,4.038498984e-016
		,3.999373921e-016
		,3.953364779e-016
		,3.897358215e-016
		,3.829144053e-016
		,3.742488281e-016
		,3.631260907e-016
		,3.480338489e-016
		,3.275932075e-016
		,2.999654127e-016
		,2.634118498e-016
		,2.248881200e-016
		,2.038692751e-016
		,1.985810809e-016
		,2.001311022e-016
		,2.009455231e-016
		,2.033455504e-016
		,2.071876251e-016
		,2.013488030e-016
		,2.060569873e-016
		,2.141199810e-016
		,2.175536921e-016
		,2.274986227e-016
		,2.369164656e-016
		,2.510246975e-016
		,2.590417126e-016
		,2.675163123e-016
		,2.738463593e-016
		,2.819766672e-016
		,2.932792837e-016
		,3.179978777e-016
		,3.297324024e-016
		,3.399501677e-016
		,3.494681848e-016
		,3.592129151e-016
		,3.711017468e-016
		,3.820208988e-016
		,3.900002696e-016
		,3.962403376e-016
		,4.181120113e-016
		,4.160526017e-016
		,4.137486456e-016
		,4.111360458e-016
		,4.080844232e-016
		,4.045829006e-016
		,4.001952373e-016
		,3.944244115e-016
		,3.867037088e-016
		,3.774506587e-016
		,3.650833368e-016
		,3.497165293e-016
		,3.288553367e-016
		,3.002211530e-016
		,2.624326665e-016
		,2.286373055e-016
		,2.118349300e-016
		,2.071088657e-016
		,2.051294875e-016
		,2.080453795e-016
		,1.987438070e-016
		,2.062659647e-016
		,2.096709459e-016
		,2.150037583e-016
		,2.245756294e-016
		,2.340894562e-016
		,2.397175978e-016
		,2.468871174e-016
		,2.595962024e-016
		,2.693035292e-016
		,2.747290824e-016
		,2.743588622e-016
		,2.791345824e-016
		,3.004240178e-016
		,3.256054706e-016
		,3.371942357e-016
		,3.478075270e-016
		,3.579316634e-016
		,3.684272358e-016
		,3.797272981e-016
		,3.885130303e-016
		,4.242315911e-016
		,4.226523204e-016
		,4.209126847e-016
		,4.189833857e-016
		,4.166959555e-016
		,4.142532673e-016
		,4.113993141e-016
		,4.078509244e-016
		,4.035064864e-016
		,3.978270703e-016
		,3.904520936e-016
		,3.796105571e-016
		,3.636813466e-016
		,3.427844879e-016
		,3.150369870e-016
		,2.801033598e-016
		,2.456476440e-016
		,2.260026542e-016
		,2.163262405e-016
		,2.130462375e-016
		,2.025257975e-016
		,2.030939040e-016
		,2.059785225e-016
		,2.121415387e-016
		,2.222184603e-016
		,2.306894355e-016
		,2.361129246e-016
		,2.370600722e-016
		,2.480746768e-016
		,2.602873361e-016
		,2.667118585e-016
		,2.650902204e-016
		,2.689595814e-016
		,2.787207504e-016
		,2.873183466e-016
		,3.181046276e-016
		,3.322044233e-016
		,3.435496781e-016
		,3.542842737e-016
		,3.643783473e-016
		,3.747666351e-016
		,4.319035548e-016
		,4.302621116e-016
		,4.284882752e-016
		,4.268170818e-016
		,4.249200550e-016
		,4.228308707e-016
		,4.204475437e-016
		,4.175874252e-016
		,4.141309896e-016
		,4.098943581e-016
		,4.040435991e-016
		,3.961363655e-016
		,3.833753277e-016
		,3.666583251e-016
		,3.457580894e-016
		,3.166183745e-016
		,2.860402415e-016
		,2.580323345e-016
		,2.376379468e-016
		,2.271640334e-016
		,2.175405705e-016
		,2.073201404e-016
		,2.049898862e-016
		,2.130626654e-016
		,2.199264949e-016
		,2.262502564e-016
		,2.282084013e-016
		,2.312290785e-016
		,2.396257053e-016
		,2.478017882e-016
		,2.549355470e-016
		,2.575857401e-016
		,2.637694028e-016
		,2.687120105e-016
		,2.762796200e-016
		,2.825648709e-016
		,3.019975167e-016
		,3.251035874e-016
		,3.371592993e-016
		,3.483887806e-016
		,3.586771400e-016
		,4.382449789e-016
		,4.368004852e-016
		,4.353072351e-016
		,4.336910577e-016
		,4.319359064e-016
		,4.300112000e-016
		,4.278119203e-016
		,4.253336475e-016
		,4.224631388e-016
		,4.189763731e-016
		,4.142795361e-016
		,4.070331399e-016
		,3.982087810e-016
		,3.847309754e-016
		,3.642866626e-016
		,3.412763466e-016
		,3.164043842e-016
		,2.895584872e-016
		,2.641177954e-016
		,2.476990104e-016
		,2.392039878e-016
		,2.226876144e-016
		,2.139065268e-016
		,2.187148716e-016
		,2.224855007e-016
		,2.266786910e-016
		,2.259918011e-016
		,2.298908079e-016
		,2.344921328e-016
		,2.368170400e-016
		,2.328175712e-016
		,2.426132653e-016
		,2.566498411e-016
		,2.632456869e-016
		,2.675803360e-016
		,2.730128492e-016
		,2.791209877e-016
		,2.861530996e-016
		,3.147264462e-016
		,3.283531695e-016
		,3.397446169e-016
		,4.441633105e-016
		,4.426782231e-016
		,4.410859547e-016
		,4.393741513e-016
		,4.375201766e-016
		,4.354831807e-016
		,4.332017105e-016
		,4.305947056e-016
		,4.274395662e-016
		,4.234109380e-016
		,4.164626392e-016
		,4.093955836e-016
		,3.972624608e-016
		,3.788429098e-016
		,3.612647306e-016
		,3.392107050e-016
		,3.163470711e-016
		,2.893294205e-016
		,2.703100437e-016
		,2.606296295e-016
		,2.398588238e-016
		,2.327341406e-016
		,2.336336434e-016
		,2.334997638e-016
		,2.330406905e-016
		,2.273668209e-016
		,2.293934067e-016
		,2.337796843e-016
		,2.342942815e-016
		,2.319873089e-016
		,2.359773773e-016
		,2.473243724e-016
		,2.520247252e-016
		,2.537061785e-016
		,2.504779479e-016
		,2.633182534e-016
		,2.741946272e-016
		,2.772359511e-016
		,2.870987292e-016
		,3.063295402e-016
		,3.174621363e-016
		,4.544667291e-016
		,4.532484870e-016
		,4.519233583e-016
		,4.504868466e-016
		,4.489326984e-016
		,4.472498764e-016
		,4.454095200e-016
		,4.432133795e-016
		,4.407634924e-016
		,4.378776944e-016
		,4.343695169e-016
		,4.286933807e-016
		,4.197967502e-016
		,4.082944493e-016
		,3.916696837e-016
		,3.759668192e-016
		,3.557792686e-016
		,3.358537459e-016
		,3.088611923e-016
		,2.916733635e-016
		,2.855061284e-016
		,2.529105884e-016
		,2.522832896e-016
		,2.522279239e-016
		,2.502738602e-016
		,2.462203471e-016
		,2.386796833e-016
		,2.367686894e-016
		,2.358931369e-016
		,2.312911793e-016
		,2.312608037e-016
		,2.355521626e-016
		,2.390030485e-016
		,2.501083335e-016
		,2.555374850e-016
		,2.588356863e-016
		,2.601750663e-016
		,2.602871023e-016
		,2.612649422e-016
		,2.521379703e-016
		,2.497421927e-016
		,4.639952071e-016
		,4.630584957e-016
		,4.621750072e-016
		,4.609869409e-016
		,4.596513803e-016
		,4.581671192e-016
		,4.564837496e-016
		,4.545345286e-016
		,4.520254118e-016
		,4.493351811e-016
		,4.419431570e-016
		,4.318788072e-016
		,4.236064147e-016
		,4.083684576e-016
		,3.925956341e-016
		,3.739940819e-016
		,3.526713305e-016
		,3.265731611e-016
		,3.049234213e-016
		,3.044070031e-016
		,3.022119436e-016
		,2.689746849e-016
		,2.676934309e-016
		,2.712582678e-016
		,2.681950292e-016
		,2.612459282e-016
		,2.535656237e-016
		,2.501162789e-016
		,2.457027367e-016
		,2.374181131e-016
		,2.357201632e-016
		,2.368731415e-016
		,2.392217411e-016
		,2.411508766e-016
		,2.504408496e-016
		,2.562471161e-016
		,2.588800257e-016
		,2.607108700e-016
		,2.612843789e-016
		,2.635118589e-016
		,2.634996162e-016
	};
// --------------------------------------------------    Cgd_FINISH	    --------------------------------------------------	

	real ids_value = 0;
	real Cgs_value = 0;
	real Cgd_value = 0;

	analog function real interpolate_smoothed_ids;
		input x, y, z;
		input [0:vds_width_int-1] x_points;
		input [0:vgs_width_int-1] y_points;
		input [0:vgd_width_int-1] z_points;
		input [0:vds_width_int*vgs_width_int*vgd_width_int-1] ids_table;

		real x, y, z;
		real x_points[0:vds_width_int-1];
		real y_points[0:vgs_width_int-1];
		real z_points[0:vgd_width_int-1];
		real ids_table[0:vds_width_int*vgs_width_int*vgd_width_int-1];

		integer i, j, k;
		integer ii, jj, kk;
		real x1, x2, dx;
		real y1, y2, alpha_y;
		real z1, z2, alpha_z;
		real id00, id01, id10, id11;
		real id_low, id_high;
		real ids;

		begin
			// --- Vds axis (linear interpolation between ii and ii+1) ---
			if (x <= x_points[0])
				ii = 0;
			else if (x >= x_points[vds_width_int - 1])
				ii = vds_width_int - 2;
			else
				for (i = 0; i < vds_width_int - 1; i = i + 1)
					if (x_points[i] <= x && x < x_points[i+1])
						ii = i;
			x1 = x_points[ii]; x2 = x_points[ii+1];
			dx = (x - x1) / (x2 - x1);

			// --- Vgs axis (smooth fractional blending) ---
			for (j = 0; j < vgs_width_int - 1; j = j + 1)
				if (y_points[j] <= y && y <= y_points[j+1]) begin
					jj = j;
					y1 = y_points[j]; y2 = y_points[j+1];
					alpha_y = (y - y1) / (y2 - y1);
				end

			if (y <= y_points[0]) begin
				jj = 0; alpha_y = 0;
			end else if (y >= y_points[vgs_width_int - 1]) begin
				jj = vgs_width_int - 2; alpha_y = 1;
			end

			// --- Vgd axis (smooth fractional blending) ---
			for (k = 0; k < vgd_width_int - 1; k = k + 1)
				if (z_points[k] <= z && z <= z_points[k+1]) begin
					kk = k;
					z1 = z_points[k]; z2 = z_points[k+1];
					alpha_z = (z - z1) / (z2 - z1);
				end

			if (z <= z_points[0]) begin
				kk = 0; alpha_z = 0;
			end else if (z >= z_points[vgd_width_int - 1]) begin
				kk = vgd_width_int - 2; alpha_z = 1;
			end

			// --- Fetch values for Vds = x_points[ii] ---
			id00 = ids_table[(jj*vds_width_int*vgd_width_int)+(kk*vds_width_int)+ii];
			id01 = ids_table[(jj*vds_width_int*vgd_width_int)+((kk+1)*vds_width_int)+ii];
			id10 = ids_table[((jj+1)*vds_width_int*vgd_width_int)+(kk*vds_width_int)+ii];
			id11 = ids_table[((jj+1)*vds_width_int*vgd_width_int)+((kk+1)*vds_width_int)+ii];

			id_low = id00 * (1 - alpha_y) * (1 - alpha_z) +
					 id01 * (1 - alpha_y) * alpha_z +
					 id10 * alpha_y * (1 - alpha_z) +
					 id11 * alpha_y * alpha_z;

			// --- Fetch values for Vds = x_points[ii+1] ---
			id00 = ids_table[(jj*vds_width_int*vgd_width_int)+(kk*vds_width_int)+(ii+1)];
			id01 = ids_table[(jj*vds_width_int*vgd_width_int)+((kk+1)*vds_width_int)+(ii+1)];
			id10 = ids_table[((jj+1)*vds_width_int*vgd_width_int)+(kk*vds_width_int)+(ii+1)];
			id11 = ids_table[((jj+1)*vds_width_int*vgd_width_int)+((kk+1)*vds_width_int)+(ii+1)];

			id_high = id00 * (1 - alpha_y) * (1 - alpha_z) +
					  id01 * (1 - alpha_y) * alpha_z +
					  id10 * alpha_y * (1 - alpha_z) +
					  id11 * alpha_y * alpha_z;

			// Final interpolation across Vds
			ids = id_low * (1 - dx) + id_high * dx;

			interpolate_smoothed_ids = ids;
		end
	endfunction
	
	analog function real interpolate_smoothed_Cgs;
		input x, y, z;
		input [0:vgs_width_int_Cgs-1] x_points;
		input [0:vds_width_int_Cgs-1] y_points;
		input [0:vgd_width_int_Cgs-1] z_points;
		input [0:vgs_width_int_Cgs*vds_width_int_Cgs*vgd_width_int_Cgs-1] Cgs_table;

		real x, y, z;
		real x_points[0:vgs_width_int_Cgs-1];
		real y_points[0:vds_width_int_Cgs-1];
		real z_points[0:vgd_width_int_Cgs-1];
		real Cgs_table[0:vgs_width_int_Cgs*vds_width_int_Cgs*vgd_width_int_Cgs-1];

		integer i, j, k;
		integer ii, jj, kk;
		real x1, x2, dx;
		real y1, y2, alpha_y;
		real z1, z2, alpha_z;
		real c00, c01, c10, c11;
		real c_low, c_high;
		real Cgs;

		begin
			// --- Vgs axis (x) ---
			if (x <= x_points[0])
				ii = 0;
			else if (x >= x_points[vgs_width_int_Cgs - 1])
				ii = vgs_width_int_Cgs - 2;
			else
				for (i = 0; i < vgs_width_int_Cgs - 1; i = i + 1)
					if (x_points[i] <= x && x < x_points[i+1])
						ii = i;
			x1 = x_points[ii]; x2 = x_points[ii+1];
			dx = (x - x1) / (x2 - x1);

			// --- Vds axis (y) ---
			for (j = 0; j < vds_width_int_Cgs - 1; j = j + 1)
				if (y_points[j] <= y && y <= y_points[j+1]) begin
					jj = j;
					y1 = y_points[j]; y2 = y_points[j+1];
					alpha_y = (y - y1) / (y2 - y1);
				end
			if (y <= y_points[0]) begin
				jj = 0; alpha_y = 0;
			end else if (y >= y_points[vds_width_int_Cgs - 1]) begin
				jj = vds_width_int_Cgs - 2; alpha_y = 1;
			end

			// --- Vgd axis (z) ---
			for (k = 0; k < vgd_width_int_Cgs - 1; k = k + 1)
				if (z_points[k] <= z && z <= z_points[k+1]) begin
					kk = k;
					z1 = z_points[k]; z2 = z_points[k+1];
					alpha_z = (z - z1) / (z2 - z1);
				end
			if (z <= z_points[0]) begin
				kk = 0; alpha_z = 0;
			end else if (z >= z_points[vgd_width_int_Cgs - 1]) begin
				kk = vgd_width_int_Cgs - 2; alpha_z = 1;
			end

			// --- Fetch values for x_points[ii] ---
			c00 = Cgs_table[(kk * vgs_width_int_Cgs * vds_width_int_Cgs) + (jj * vgs_width_int_Cgs) + ii];
			c01 = Cgs_table[((kk+1) * vgs_width_int_Cgs * vds_width_int_Cgs) + (jj * vgs_width_int_Cgs) + ii];
			c10 = Cgs_table[(kk * vgs_width_int_Cgs * vds_width_int_Cgs) + ((jj+1) * vgs_width_int_Cgs) + ii];
			c11 = Cgs_table[((kk+1) * vgs_width_int_Cgs * vds_width_int_Cgs) + ((jj+1) * vgs_width_int_Cgs) + ii];

			c_low = c00 * (1 - alpha_y) * (1 - alpha_z) +
					c01 * (1 - alpha_y) * alpha_z +
					c10 * alpha_y * (1 - alpha_z) +
					c11 * alpha_y * alpha_z;

			// --- Fetch values for x_points[ii+1] ---
			c00 = Cgs_table[(kk * vgs_width_int_Cgs * vds_width_int_Cgs) + (jj * vgs_width_int_Cgs) + (ii+1)];
			c01 = Cgs_table[((kk+1) * vgs_width_int_Cgs * vds_width_int_Cgs) + (jj * vgs_width_int_Cgs) + (ii+1)];
			c10 = Cgs_table[(kk * vgs_width_int_Cgs * vds_width_int_Cgs) + ((jj+1) * vgs_width_int_Cgs) + (ii+1)];
			c11 = Cgs_table[((kk+1) * vgs_width_int_Cgs * vds_width_int_Cgs) + ((jj+1) * vgs_width_int_Cgs) + (ii+1)];

			c_high = c00 * (1 - alpha_y) * (1 - alpha_z) +
					 c01 * (1 - alpha_y) * alpha_z +
					 c10 * alpha_y * (1 - alpha_z) +
					 c11 * alpha_y * alpha_z;

			// Final interpolation across Vgs
			Cgs = c_low * (1 - dx) + c_high * dx;

			interpolate_smoothed_Cgs = Cgs;
		end
	endfunction

	
	analog function real interpolate_smoothed_Cgd;
		input x, y, z;
		input [0:vgd_width_int_Cgd-1] x_points;
		input [0:vds_width_int_Cgd-1] y_points;
		input [0:vgs_width_int_Cgd-1] z_points;
		input [0:vgd_width_int_Cgd*vds_width_int_Cgd*vgs_width_int_Cgd-1] Cgd_table;

		real x, y, z;
		real x_points[0:vgd_width_int_Cgd-1];
		real y_points[0:vds_width_int_Cgd-1];
		real z_points[0:vgs_width_int_Cgd-1];
		real Cgd_table[0:vgd_width_int_Cgd*vds_width_int_Cgd*vgs_width_int_Cgd-1];

		integer i, j, k;
		integer ii, jj, kk;
		real x1, x2, dx;
		real y1, y2, alpha_y;
		real z1, z2, alpha_z;
		real c00, c01, c10, c11;
		real c_low, c_high;
		real Cgd;

		begin
			// --- Vgd axis (x) ---
			if (x <= x_points[0])
				ii = 0;
			else if (x >= x_points[vgd_width_int_Cgd - 1])
				ii = vgd_width_int_Cgd - 2;
			else
				for (i = 0; i < vgd_width_int_Cgd - 1; i = i + 1)
					if (x_points[i] <= x && x < x_points[i+1])
						ii = i;
			x1 = x_points[ii]; x2 = x_points[ii+1];
			dx = (x - x1) / (x2 - x1);

			// --- Vds axis (y) ---
			for (j = 0; j < vds_width_int_Cgd - 1; j = j + 1)
				if (y_points[j] <= y && y <= y_points[j+1]) begin
					jj = j;
					y1 = y_points[j]; y2 = y_points[j+1];
					alpha_y = (y - y1) / (y2 - y1);
				end
			if (y <= y_points[0]) begin
				jj = 0; alpha_y = 0;
			end else if (y >= y_points[vds_width_int_Cgd - 1]) begin
				jj = vds_width_int_Cgd - 2; alpha_y = 1;
			end

			// --- Vgs axis (z) ---
			for (k = 0; k < vgs_width_int_Cgd - 1; k = k + 1)
				if (z_points[k] <= z && z <= z_points[k+1]) begin
					kk = k;
					z1 = z_points[k]; z2 = z_points[k+1];
					alpha_z = (z - z1) / (z2 - z1);
				end
			if (z <= z_points[0]) begin
				kk = 0; alpha_z = 0;
			end else if (z >= z_points[vgs_width_int_Cgd - 1]) begin
				kk = vgs_width_int_Cgd - 2; alpha_z = 1;
			end

			// --- Fetch values for x_points[ii] ---
			c00 = Cgd_table[(kk * vgd_width_int_Cgd * vds_width_int_Cgd) + (jj * vgd_width_int_Cgd) + ii];
			c01 = Cgd_table[((kk+1) * vgd_width_int_Cgd * vds_width_int_Cgd) + (jj * vgd_width_int_Cgd) + ii];
			c10 = Cgd_table[(kk * vgd_width_int_Cgd * vds_width_int_Cgd) + ((jj+1) * vgd_width_int_Cgd) + ii];
			c11 = Cgd_table[((kk+1) * vgd_width_int_Cgd * vds_width_int_Cgd) + ((jj+1) * vgd_width_int_Cgd) + ii];

			c_low = c00 * (1 - alpha_y) * (1 - alpha_z) +
					c01 * (1 - alpha_y) * alpha_z +
					c10 * alpha_y * (1 - alpha_z) +
					c11 * alpha_y * alpha_z;

			// --- Fetch values for x_points[ii+1] ---
			c00 = Cgd_table[(kk * vgd_width_int_Cgd * vds_width_int_Cgd) + (jj * vgd_width_int_Cgd) + (ii+1)];
			c01 = Cgd_table[((kk+1) * vgd_width_int_Cgd * vds_width_int_Cgd) + (jj * vgd_width_int_Cgd) + (ii+1)];
			c10 = Cgd_table[(kk * vgd_width_int_Cgd * vds_width_int_Cgd) + ((jj+1) * vgd_width_int_Cgd) + (ii+1)];
			c11 = Cgd_table[((kk+1) * vgd_width_int_Cgd * vds_width_int_Cgd) + ((jj+1) * vgd_width_int_Cgd) + (ii+1)];

			c_high = c00 * (1 - alpha_y) * (1 - alpha_z) +
					 c01 * (1 - alpha_y) * alpha_z +
					 c10 * alpha_y * (1 - alpha_z) +
					 c11 * alpha_y * alpha_z;

			// Final interpolation in Vgd
			Cgd = c_low * (1 - dx) + c_high * dx;

			interpolate_smoothed_Cgd = Cgd;
		end
	endfunction
	
	
	// Put near your params
	parameter real EPS_DEN = 1e-12; // protects against zero/very-small denominators

	analog function real clip01;
		input a;
		real a;
		begin
			if (a <= 0.0) clip01 = 0.0;
			else if (a >= 1.0) clip01 = 1.0;
			else clip01 = a;
		end
	endfunction
	
	// ---------- numerical guard parameters ----------
	parameter real Cmin      = 1e-18;   // floor for caps (aF)
	parameter real gmin      = 1e-9;    // tiny DC rails to bulk (1 GΩ)
	parameter real gds_floor = 1e-12;    // tiny linear conductance in Ids path (helps Newton)
	parameter real VCLIP_K   = 5e-3;    // softness (V) for soft clamp
	parameter real MAXSTEP   = 5e-11;   // time-step bound suggestion (50 ps)

	// ---------- smooth softplus-based clamp to [lo, hi] ----------
	// analog function real soft_clip;
		// input x, lo, hi, k;
		// real x, lo, hi, k;
		// real t1, t2;
		// begin
			// // softplus: k*ln(1+exp((x-lo)/k)) grows smoothly; subtract softplus to clip at hi
			// t1 = k*ln(1.0 + exp((x - lo)/k));
			// t2 = k*ln(1.0 + exp((x - hi)/k));
			// soft_clip = lo + t1 - t2; // C^∞ smooth clamp to [lo, hi]
		// end
	// endfunction
	
	// Safe softplus: ln(1+exp(a)) without overflow
	analog function real softplus;
	  input a;
	  real a;
	  real r;
	  begin
		if (a > 0.0)
		  // for large +a, use exp(-a) which is tiny -> no overflow
		  r = a + ln(1.0 + exp(-a));
		else
		  // for a <= 0, exp(a) <= 1 -> safe
		  r = ln(1.0 + exp(a));
		softplus = r;
	  end
	endfunction
	
	// Smooth clamp x to [lo, hi] using softplus; k sets softness (V)
	analog function real soft_clip;
	  input x, lo, hi, k;
	  real x, lo, hi, k;
	  real u, v;
	  begin
		// lo + k*softplus((x-lo)/k) - k*softplus((x-hi)/k)
		u = k * softplus((x - lo)/k);
		v = k * softplus((x - hi)/k);
		soft_clip = lo + u - v;
	  end
	endfunction


	// ---------- smooth max(x, xmin) (C^1) ----------
	analog function real smooth_max;
		input x, xmin, k;
		real x, xmin, k, dx;
		begin
			dx = x - xmin;
			smooth_max = 0.5*(dx + sqrt(dx*dx + k)) + xmin;
		end
	endfunction



	analog function real interpolate_smoothed2_ids;
		input x, y, z;
		input [0:vds_width_int-1] x_points;
		input [0:vgs_width_int-1] y_points;
		input [0:vgd_width_int-1] z_points;
		input [0:vds_width_int*vgs_width_int*vgd_width_int-1] ids_table;

		real x, y, z;
		real x_points[0:vds_width_int-1];
		real y_points[0:vgs_width_int-1];
		real z_points[0:vgd_width_int-1];
		real ids_table[0:vds_width_int*vgs_width_int*vgd_width_int-1];

		integer i, j, k;
		integer ii, jj, kk;
		real x1, x2, dx, denx;
		real y1, y2, alpha_y, deny;
		real z1, z2, alpha_z, denz;
		real id00, id01, id10, id11;
		real id_low, id_high, ids;

		begin
			// --- Vds axis (locate ii) ---
			if (x <= x_points[0])
				ii = 0;
			else if (x >= x_points[vds_width_int-1])
				ii = vds_width_int-2;
			else
				for (i = 0; i < vds_width_int-1; i = i + 1)
					if (x_points[i] <= x && x < x_points[i+1])
						ii = i;

			x1 = x_points[ii]; x2 = x_points[ii+1];
			denx = x2 - x1; if (denx < EPS_DEN) denx = EPS_DEN;
			dx = (x - x1) / denx;  // do NOT clip dx; allows mild extrapolation near edges

			// --- Vgs axis (locate jj, compute alpha_y) ---
			for (j = 0; j < vgs_width_int-1; j = j + 1)
				if (y_points[j] <= y && y <= y_points[j+1]) begin
					jj = j;
					y1 = y_points[j]; y2 = y_points[j+1];
				end
			if (y <= y_points[0]) begin
				jj = 0; y1 = y_points[0]; y2 = y_points[1];
			end else if (y >= y_points[vgs_width_int-1]) begin
				jj = vgs_width_int-2; y1 = y_points[vgs_width_int-2]; y2 = y_points[vgs_width_int-1];
			end
			deny = y2 - y1; if (deny < EPS_DEN) deny = EPS_DEN;
			// alpha_y = clip01( (y - y1) / deny );
			alpha_y = (y - y1) / deny;   // no hard clip (we soft-clipped inputs already)

			// --- Vgd axis (locate kk, compute alpha_z) ---
			for (k = 0; k < vgd_width_int-1; k = k + 1)
				if (z_points[k] <= z && z <= z_points[k+1]) begin
					kk = k;
					z1 = z_points[k]; z2 = z_points[k+1];
				end
			if (z <= z_points[0]) begin
				kk = 0; z1 = z_points[0]; z2 = z_points[1];
			end else if (z >= z_points[vgd_width_int-1]) begin
				kk = vgd_width_int-2; z1 = z_points[vgd_width_int-2]; z2 = z_points[vgd_width_int-1];
			end
			denz = z2 - z1; if (denz < EPS_DEN) denz = EPS_DEN;
			// alpha_z = clip01( (z - z1) / denz );
			alpha_z = (z - z1) / denz; // no hard clip (we soft-clipped inputs already)
			
			// --- Fetch values for Vds = x_points[ii] ---
			id00 = ids_table[(jj*vds_width_int*vgd_width_int) + (kk*vds_width_int) + ii];
			id01 = ids_table[(jj*vds_width_int*vgd_width_int) + ((kk+1)*vds_width_int) + ii];
			id10 = ids_table[((jj+1)*vds_width_int*vgd_width_int) + (kk*vds_width_int) + ii];
			id11 = ids_table[((jj+1)*vds_width_int*vgd_width_int) + ((kk+1)*vds_width_int) + ii];

			id_low = id00*(1 - alpha_y)*(1 - alpha_z)
				   + id01*(1 - alpha_y)*alpha_z
				   + id10*alpha_y*(1 - alpha_z)
				   + id11*alpha_y*alpha_z;

			// --- Fetch values for Vds = x_points[ii+1] ---
			id00 = ids_table[(jj*vds_width_int*vgd_width_int) + (kk*vds_width_int) + (ii+1)];
			id01 = ids_table[(jj*vds_width_int*vgd_width_int) + ((kk+1)*vds_width_int) + (ii+1)];
			id10 = ids_table[((jj+1)*vds_width_int*vgd_width_int) + (kk*vds_width_int) + (ii+1)];
			id11 = ids_table[((jj+1)*vds_width_int*vgd_width_int) + ((kk+1)*vds_width_int) + (ii+1)];

			id_high = id00*(1 - alpha_y)*(1 - alpha_z)
					+ id01*(1 - alpha_y)*alpha_z
					+ id10*alpha_y*(1 - alpha_z)
					+ id11*alpha_y*alpha_z;

			// --- Final across Vds ---
			ids = id_low*(1 - dx) + id_high*dx;

			interpolate_smoothed2_ids = ids;
		end
	endfunction


	analog function real interpolate_smoothed2_Cgs;
		input x, y, z;
		input [0:vgs_width_int_Cgs-1] x_points;
		input [0:vds_width_int_Cgs-1] y_points;
		input [0:vgd_width_int_Cgs-1] z_points;
		input [0:vgs_width_int_Cgs*vds_width_int_Cgs*vgd_width_int_Cgs-1] Cgs_table;

		real x, y, z;
		real x_points[0:vgs_width_int_Cgs-1];
		real y_points[0:vds_width_int_Cgs-1];
		real z_points[0:vgd_width_int_Cgs-1];
		real Cgs_table[0:vgs_width_int_Cgs*vds_width_int_Cgs*vgd_width_int_Cgs-1];

		integer i, j, k;
		integer ii, jj, kk;
		real x1, x2, dx, denx;
		real y1, y2, alpha_y, deny;
		real z1, z2, alpha_z, denz;
		real c00, c01, c10, c11, c_low, c_high, Cgs;

		begin
			// x (Vgs)
			if (x <= x_points[0]) ii = 0;
			else if (x >= x_points[vgs_width_int_Cgs-1]) ii = vgs_width_int_Cgs-2;
			else for (i = 0; i < vgs_width_int_Cgs-1; i = i + 1)
				if (x_points[i] <= x && x < x_points[i+1]) ii = i;
			x1 = x_points[ii]; x2 = x_points[ii+1];
			denx = x2 - x1; if (denx < EPS_DEN) denx = EPS_DEN;
			dx = (x - x1) / denx;

			// y (Vds)
			for (j = 0; j < vds_width_int_Cgs-1; j = j + 1)
				if (y_points[j] <= y && y <= y_points[j+1]) begin
					jj = j; y1 = y_points[j]; y2 = y_points[j+1];
				end
			if (y <= y_points[0]) begin jj = 0; y1 = y_points[0]; y2 = y_points[1]; end
			else if (y >= y_points[vds_width_int_Cgs-1]) begin jj = vds_width_int_Cgs-2; y1 = y_points[vds_width_int_Cgs-2]; y2 = y_points[vds_width_int_Cgs-1]; end
			deny = y2 - y1; if (deny < EPS_DEN) deny = EPS_DEN;
			// alpha_y = clip01( (y - y1) / deny );
			alpha_y = (y - y1) / deny;   // no hard clip (we soft-clipped inputs already)

			// z (Vgd)
			for (k = 0; k < vgd_width_int_Cgs-1; k = k + 1)
				if (z_points[k] <= z && z <= z_points[k+1]) begin
					kk = k; z1 = z_points[k]; z2 = z_points[k+1];
				end
			if (z <= z_points[0]) begin kk = 0; z1 = z_points[0]; z2 = z_points[1]; end
			else if (z >= z_points[vgd_width_int_Cgs-1]) begin kk = vgd_width_int_Cgs-2; z1 = z_points[vgd_width_int_Cgs-2]; z2 = z_points[vgd_width_int_Cgs-1]; end
			denz = z2 - z1; if (denz < EPS_DEN) denz = EPS_DEN;
			// alpha_z = clip01( (z - z1) / denz );
			alpha_z = (z - z1) / denz; // no hard clip (we soft-clipped inputs already)

			// fetch at ii
			c00 = Cgs_table[(kk*vgs_width_int_Cgs*vds_width_int_Cgs) + (jj*vgs_width_int_Cgs) + ii];
			c01 = Cgs_table[((kk+1)*vgs_width_int_Cgs*vds_width_int_Cgs) + (jj*vgs_width_int_Cgs) + ii];
			c10 = Cgs_table[(kk*vgs_width_int_Cgs*vds_width_int_Cgs) + ((jj+1)*vgs_width_int_Cgs) + ii];
			c11 = Cgs_table[((kk+1)*vgs_width_int_Cgs*vds_width_int_Cgs) + ((jj+1)*vgs_width_int_Cgs) + ii];

			c_low = c00*(1 - alpha_y)*(1 - alpha_z)
				  + c01*(1 - alpha_y)*alpha_z
				  + c10*alpha_y*(1 - alpha_z)
				  + c11*alpha_y*alpha_z;

			// fetch at ii+1
			c00 = Cgs_table[(kk*vgs_width_int_Cgs*vds_width_int_Cgs) + (jj*vgs_width_int_Cgs) + (ii+1)];
			c01 = Cgs_table[((kk+1)*vgs_width_int_Cgs*vds_width_int_Cgs) + (jj*vgs_width_int_Cgs) + (ii+1)];
			c10 = Cgs_table[(kk*vgs_width_int_Cgs*vds_width_int_Cgs) + ((jj+1)*vgs_width_int_Cgs) + (ii+1)];
			c11 = Cgs_table[((kk+1)*vgs_width_int_Cgs*vds_width_int_Cgs) + ((jj+1)*vgs_width_int_Cgs) + (ii+1)];

			c_high = c00*(1 - alpha_y)*(1 - alpha_z)
				   + c01*(1 - alpha_y)*alpha_z
				   + c10*alpha_y*(1 - alpha_z)
				   + c11*alpha_y*alpha_z;

			Cgs = c_low*(1 - dx) + c_high*dx;
			interpolate_smoothed2_Cgs = Cgs;
		end
	endfunction


	analog function real interpolate_smoothed2_Cgd;
		input x, y, z;
		input [0:vgd_width_int_Cgd-1] x_points;
		input [0:vds_width_int_Cgd-1] y_points;
		input [0:vgs_width_int_Cgd-1] z_points;
		input [0:vgd_width_int_Cgd*vds_width_int_Cgd*vgs_width_int_Cgd-1] Cgd_table;

		real x, y, z;
		real x_points[0:vgd_width_int_Cgd-1];
		real y_points[0:vds_width_int_Cgd-1];
		real z_points[0:vgs_width_int_Cgd-1];
		real Cgd_table[0:vgd_width_int_Cgd*vds_width_int_Cgd*vgs_width_int_Cgd-1];

		integer i, j, k;
		integer ii, jj, kk;
		real x1, x2, dx, denx;
		real y1, y2, alpha_y, deny;
		real z1, z2, alpha_z, denz;
		real c00, c01, c10, c11, c_low, c_high, Cgd;

		begin
			// x (Vgd)
			if (x <= x_points[0]) ii = 0;
			else if (x >= x_points[vgd_width_int_Cgd-1]) ii = vgd_width_int_Cgd-2;
			else for (i = 0; i < vgd_width_int_Cgd-1; i = i + 1)
				if (x_points[i] <= x && x < x_points[i+1]) ii = i;
			x1 = x_points[ii]; x2 = x_points[ii+1];
			denx = x2 - x1; if (denx < EPS_DEN) denx = EPS_DEN;
			dx = (x - x1) / denx;

			// y (Vds)
			for (j = 0; j < vds_width_int_Cgd-1; j = j + 1)
				if (y_points[j] <= y && y <= y_points[j+1]) begin
					jj = j; y1 = y_points[j]; y2 = y_points[j+1];
				end
			if (y <= y_points[0]) begin jj = 0; y1 = y_points[0]; y2 = y_points[1]; end
			else if (y >= y_points[vds_width_int_Cgd-1]) begin jj = vds_width_int_Cgd-2; y1 = y_points[vds_width_int_Cgd-2]; y2 = y_points[vds_width_int_Cgd-1]; end
			deny = y2 - y1; if (deny < EPS_DEN) deny = EPS_DEN;
			// alpha_y = clip01( (y - y1) / deny );
			alpha_y = (y - y1) / deny;   // no hard clip (we soft-clipped inputs already)

			// z (Vgs)
			for (k = 0; k < vgs_width_int_Cgd-1; k = k + 1)
				if (z_points[k] <= z && z <= z_points[k+1]) begin
					kk = k; z1 = z_points[k]; z2 = z_points[k+1];
				end
			if (z <= z_points[0]) begin kk = 0; z1 = z_points[0]; z2 = z_points[1]; end
			else if (z >= z_points[vgs_width_int_Cgd-1]) begin kk = vgs_width_int_Cgd-2; z1 = z_points[vgs_width_int_Cgd-2]; z2 = z_points[vgs_width_int_Cgd-1]; end
			denz = z2 - z1; if (denz < EPS_DEN) denz = EPS_DEN;
			// alpha_z = clip01( (z - z1) / denz );
			alpha_z = (z - z1) / denz; // no hard clip (we soft-clipped inputs already)

			// fetch at ii
			c00 = Cgd_table[(kk*vgd_width_int_Cgd*vds_width_int_Cgd) + (jj*vgd_width_int_Cgd) + ii];
			c01 = Cgd_table[((kk+1)*vgd_width_int_Cgd*vds_width_int_Cgd) + (jj*vgd_width_int_Cgd) + ii];
			c10 = Cgd_table[(kk*vgd_width_int_Cgd*vds_width_int_Cgd) + ((jj+1)*vgd_width_int_Cgd) + ii];
			c11 = Cgd_table[((kk+1)*vgd_width_int_Cgd*vds_width_int_Cgd) + ((jj+1)*vgd_width_int_Cgd) + ii];

			c_low = c00*(1 - alpha_y)*(1 - alpha_z)
				  + c01*(1 - alpha_y)*alpha_z
				  + c10*alpha_y*(1 - alpha_z)
				  + c11*alpha_y*alpha_z;

			// fetch at ii+1
			c00 = Cgd_table[(kk*vgd_width_int_Cgd*vds_width_int_Cgd) + (jj*vgd_width_int_Cgd) + (ii+1)];
			c01 = Cgd_table[((kk+1)*vgd_width_int_Cgd*vds_width_int_Cgd) + (jj*vgd_width_int_Cgd) + (ii+1)];
			c10 = Cgd_table[(kk*vgd_width_int_Cgd*vds_width_int_Cgd) + ((jj+1)*vgd_width_int_Cgd) + (ii+1)];
			c11 = Cgd_table[((kk+1)*vgd_width_int_Cgd*vds_width_int_Cgd) + ((jj+1)*vgd_width_int_Cgd) + (ii+1)];

			c_high = c00*(1 - alpha_y)*(1 - alpha_z)
				   + c01*(1 - alpha_y)*alpha_z
				   + c10*alpha_y*(1 - alpha_z)
				   + c11*alpha_y*alpha_z;

			Cgd = c_low*(1 - dx) + c_high*dx;
			interpolate_smoothed2_Cgd = Cgd;
		end
	endfunction
	
	real Cgs_eff, Cgd_eff, qgs, qgd;
	real vds_raw, vgs_raw, vgd_raw;
	real vds, vgs, vgd;

	// cache LUT bounds (assumes monotonically sorted arrays)
	real VDS_MIN, VDS_MAX, VGS_MIN, VGS_MAX, VGD_MIN, VGD_MAX;

	analog begin
		//// hint the integrator for sharp logic edges in the neuron
		// bound_step(MAXSTEP);

		// gmin rails to bulk to avoid floating cutsets
		I(d,  b) <+ gmin * V(d,  b);
		I(s,  b) <+ gmin * V(s,  b);
		I(gs, b) <+ gmin * V(gs, b);
		I(gd, b) <+ gmin * V(gd, b);
		// optional: prevent any bulk island from floating numerically
		I(b) <+ gmin * V(b);   // tiny (1/GΩ) anchor to global 0


		// raw terminal voltages
		vds_raw = V(d, s);   // Drain-Source voltage
		vgs_raw = V(gs, s);  // Gate-Source voltage
		vgd_raw = V(gd, s);  // Gate-Source voltage (not drain!)

		// LUT bounds (first/last entries)
		VDS_MIN = vds_points[0];
		VDS_MAX = vds_points[vds_width_int-1];
		VGS_MIN = vgs_points[0];
		VGS_MAX = vgs_points[vgs_width_int-1];
		VGD_MIN = vgd_points[0];
		VGD_MAX = vgd_points[vgd_width_int-1];

		// soft clamp voltages to LUT domain (smooth, no corners)
		vds = soft_clip(vds_raw, VDS_MIN, VDS_MAX, VCLIP_K);
		vgs = soft_clip(vgs_raw, VGS_MIN, VGS_MAX, VCLIP_K);
		vgd = soft_clip(vgd_raw, VGD_MIN, VGD_MAX, VCLIP_K);   // Corrected Vgd to be source-based

		// --- Interpolate Ids, Cgs, Cgd using your functions (no hard clip inside)
		ids_value = interpolate_smoothed2_ids(vds, vgs, vgd, vds_points, vgs_points, vgd_points, table_ids);

		Cgs_value = interpolate_smoothed2_Cgs(
						/* x=Vgs */ vgs,
						/* y=Vds */ vds,
						/* z=Vgd */ vgd_raw /* keep using Vgd_raw as it should be source-relative */,
						vgs_points_Cgs, vds_points_Cgs, vgd_points_Cgs, table_Cgs);

		Cgd_value = interpolate_smoothed2_Cgd(
						/* x=Vgd */ vgd,
						/* y=Vds */ vds,
						/* z=Vgs */ vgs_raw /* likewise: match your Cgd table’s axes */,
						vgd_points_Cgd, vds_points_Cgd, vgs_points_Cgd, table_Cgd);

		// Enforce strictly positive small caps (smooth)
		Cgs_eff = smooth_max(Cgs_value, Cmin, 1e-36);
		Cgd_eff = smooth_max(Cgd_value, Cmin, 1e-36);

		// ---- Charge-based stamping (dQ/dt) ----
		// Cgs between (gs - s)
		qgs = Cgs_eff * V(gs, s);
		I(gs, s) <+ ddt(qgs);

		// Cgd between (gd - s)  *** FIXED: gate-source not gate-drain ***
		qgd = Cgd_eff * V(gd, s);  // Correct Cgd to use source, not drain
		I(gd, s) <+ ddt(qgd);

		// ---- Ids path + tiny linear gds floor (stabilizer) ----
		I(d, s) <+ ids_value;
		I(d, s) <+ gds_floor * V(d, s); // helps when dIds/dV ≈ 0
	end
endmodule

/*
	
	// ---- parameters (top of module) ----
	parameter real Cmin = 1e-18;  // lower bound for caps (1 aF)
	parameter real gmin = 1e-9;   // tiny DC leakage (1 GΩ)
	
	// ---- tiny smooth clamp (min) helper ----
	analog function real smooth_max;
		input x, xmin, k;
		real x, xmin, k;
		real dx;
		begin 
			dx = x - xmin;
			smooth_max = 0.5*(dx + sqrt(dx*dx + k)) + xmin; // C1 clamp
		end
	endfunction
	
	real Cgs_eff, Cgd_eff, qgs, qgd;
	
    analog begin
		
		// gmin rails: avoid floating DC cutsets
		I(d,  b) <+ gmin * V(d,  b);
		I(s,  b) <+ gmin * V(s,  b);
		I(gs, b) <+ gmin * V(gs, b);
		I(gd, b) <+ gmin * V(gd, b);
		
        // Compute Ids using 1D interpolation
		// ids_value = interpolate_smoothed_ids(V(d, s), V(gs, s), V(gd, s), vds_points, vgs_points, vgd_points, table_ids);
		// Cgs_value = interpolate_smoothed_Cgs(V(gs, s), V(d, s), V(gd, s), vgs_points_Cgs, vds_points_Cgs, vgd_points_Cgs, table_Cgs);
		// Cgd_value = interpolate_smoothed_Cgd(V(gd, s), V(d, s), V(gs, s), vgd_points_Cgd, vds_points_Cgd, vgs_points_Cgd, table_Cgd);
		
		ids_value = interpolate_smoothed2_ids(V(d, s), V(gs, s), V(gd, s), vds_points, vgs_points, vgd_points, table_ids);
		Cgs_value = interpolate_smoothed2_Cgs(V(gs, s), V(d, s), V(gd, s), vgs_points_Cgs, vds_points_Cgs, vgd_points_Cgs, table_Cgs);
		Cgd_value = interpolate_smoothed2_Cgd(V(gd, s), V(d, s), V(gs, s), vgd_points_Cgd, vds_points_Cgd, vgs_points_Cgd, table_Cgd);
		
		// Smoothly enforce positive, nonzero caps (avoid negative/exact-zero table bins)
		Cgs_eff = smooth_max(Cgs_value, Cmin, 1e-36);
		Cgd_eff = smooth_max(Cgd_value, Cmin, 1e-36);

		// Charge-based stamping (better than C*ddt(V))
		qgs = Cgs_eff * V(gs, s);
		qgd = Cgd_eff * V(gd, s);
		I(gs, s) <+ ddt(qgs);
		I(gd, s) <+ ddt(qgd);
        
        // Define currents and charges
        I(d, s) <+ ids_value;
		// //I(gs) <+ Cgs_value * ddt(V(gs, s));
		// //I(gd) <+ Cgd_value * ddt(V(gd, s));
    end
endmodule

*/
