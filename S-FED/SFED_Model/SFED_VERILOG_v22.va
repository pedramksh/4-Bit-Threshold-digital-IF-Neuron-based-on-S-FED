		,4.349219300e-016
		,4.965932869e-016
		,5.093707226e-016
		,5.164600731e-016
		,5.102791465e-016
		,5.031208650e-016
		,4.975837167e-016
		,4.935791225e-016
		,4.906815988e-016
		,1.698182963e-016
		,1.695745011e-016
		,1.693393133e-016
		,1.691102078e-016
		,1.688860306e-016
		,1.686665037e-016
		,1.684516555e-016
		,1.682417200e-016
		,1.680367624e-016
		,1.678366115e-016
		,1.676409334e-016
		,1.674492481e-016
		,1.672611078e-016
		,1.670764705e-016
		,1.668965966e-016
		,1.667268594e-016
		,1.665860591e-016
		,1.665372249e-016
		,1.667823430e-016
		,1.678792612e-016
		,1.713132800e-016
		,1.792816385e-016
		,1.922103181e-016
		,2.116726696e-016
		,2.341807042e-016
		,2.557720251e-016
		,2.736837106e-016
		,2.848316458e-016
		,3.251349482e-016
		,3.601550888e-016
		,3.876325848e-016
		,4.027664726e-016
		,4.291715282e-016
		,4.948724790e-016
		,5.100625453e-016
		,5.200205380e-016
		,5.145687511e-016
		,5.069379928e-016
		,5.007431568e-016
		,4.961616867e-016
		,4.928301234e-016
		,1.700466495e-016
		,1.697770366e-016
		,1.695317278e-016
		,1.692946009e-016
		,1.690637237e-016
		,1.688376015e-016
		,1.686166847e-016
		,1.684005333e-016
		,1.681896215e-016
		,1.679836066e-016
		,1.677822536e-016
		,1.675851965e-016
		,1.673920662e-016
		,1.672024254e-016
		,1.670160562e-016
		,1.668344035e-016
		,1.666630692e-016
		,1.665218033e-016
		,1.664765500e-016
		,1.667358099e-016
		,1.678809542e-016
		,1.714367399e-016
		,1.794355754e-016
		,1.925655451e-016
		,2.122396726e-016
		,2.348682575e-016
		,2.566057856e-016
		,2.749015051e-016
		,2.871644780e-016
		,3.159255990e-016
		,3.574914299e-016
		,3.850292122e-016
		,4.051067725e-016
		,4.814973979e-016
		,5.102106363e-016
		,5.210608002e-016
		,5.194097556e-016
		,5.113739891e-016
		,5.044024272e-016
		,4.991560060e-016
		,4.953201872e-016
		,1.804721822e-016
		,1.800087090e-016
		,1.797821299e-016
		,1.797076759e-016
		,1.797638580e-016
		,1.799565926e-016
		,1.803163222e-016
		,1.809176607e-016
		,1.819417143e-016
		,1.838499566e-016
		,1.878325101e-016
		,1.964761251e-016
		,2.110991874e-016
		,2.296575670e-016
		,2.439437058e-016
		,2.540242490e-016
		,2.610864702e-016
		,2.678849179e-016
		,2.715604639e-016
		,2.711742523e-016
		,2.784511267e-016
		,2.887585882e-016
		,2.965634953e-016
		,3.036317638e-016
		,3.166218920e-016
		,3.307129579e-016
		,3.458067755e-016
		,3.607499856e-016
		,3.732576909e-016
		,3.836698268e-016
		,3.927306298e-016
		,4.010155946e-016
		,4.082011149e-016
		,4.139141004e-016
		,4.188016643e-016
		,4.230717397e-016
		,4.268290889e-016
		,4.301614594e-016
		,4.331248302e-016
		,4.357554344e-016
		,4.380884404e-016
		,1.788332229e-016
		,1.784464694e-016
		,1.782308178e-016
		,1.781183619e-016
		,1.780855280e-016
		,1.781254461e-016
		,1.782408664e-016
		,1.784441068e-016
		,1.787620522e-016
		,1.792512234e-016
		,1.800401882e-016
		,1.814531831e-016
		,1.843619694e-016
		,1.909144756e-016
		,2.039402395e-016
		,2.237120740e-016
		,2.417955238e-016
		,2.543823716e-016
		,2.622127899e-016
		,2.695247952e-016
		,2.783544519e-016
		,2.841336664e-016
		,2.918419605e-016
		,3.066034543e-016
		,3.241016786e-016
		,3.400896365e-016
		,3.542876924e-016
		,3.665432218e-016
		,3.780383759e-016
		,3.894677002e-016
		,3.991583781e-016
		,4.071210591e-016
		,4.138863019e-016
		,4.196387272e-016
		,4.245400719e-016
		,4.287355458e-016
		,4.323487704e-016
		,4.354815724e-016
		,4.382129726e-016
		,4.406006974e-016
		,4.426895962e-016
		,1.774179492e-016
		,1.770848135e-016
		,1.768886670e-016
		,1.767746995e-016
		,1.767199242e-016
		,1.767129033e-016
		,1.767483303e-016
		,1.768258963e-016
		,1.769506335e-016
		,1.771343796e-016
		,1.773995118e-016
		,1.777889613e-016
		,1.783948347e-016
		,1.794439720e-016
		,1.815512935e-016
		,1.863531941e-016
		,1.970109176e-016
		,2.162057476e-016
		,2.380821987e-016
		,2.547571200e-016
		,2.665373960e-016
		,2.763401286e-016
		,2.919110152e-016
		,3.095595960e-016
		,3.263612040e-016
		,3.437116014e-016
		,3.612616343e-016
		,3.771129795e-016
		,3.896467030e-016
		,3.995729031e-016
		,4.074197910e-016
		,4.143535963e-016
		,4.204102196e-016
		,4.254938259e-016
		,4.297497758e-016
		,4.333730065e-016
		,4.364986237e-016
		,4.392243534e-016
		,4.416252578e-016
		,4.437578744e-016
		,4.456741393e-016
		,1.762932907e-016
		,1.759734912e-016
		,1.757633354e-016
		,1.756220740e-016
		,1.755324570e-016
		,1.754849885e-016
		,1.754734824e-016
		,1.754939464e-016
		,1.755445711e-016
		,1.756261792e-016
		,1.757430018e-016
		,1.759040046e-016
		,1.761256499e-016
		,1.764387736e-016
		,1.769078171e-016
		,1.776885064e-016
		,1.792041697e-016
		,1.826370066e-016
		,1.907894295e-016
		,2.077893079e-016
		,2.323937898e-016
		,2.563627119e-016
		,2.781352953e-016
		,2.990708341e-016
		,3.250231802e-016
		,3.508775355e-016
		,3.720549639e-016
		,3.881965762e-016
		,4.003132088e-016
		,4.098875691e-016
		,4.175402751e-016
		,4.236573082e-016
		,4.284831372e-016
		,4.323612393e-016
		,4.359456406e-016
		,4.391525627e-016
		,4.419613393e-016
		,4.444223384e-016
		,4.465944830e-016
		,4.485493322e-016
		,4.503387206e-016
		,1.754257511e-016
		,1.751202976e-016
		,1.748971987e-016
		,1.747250765e-016
		,1.745911115e-016
		,1.744890156e-016
		,1.744155142e-016
		,1.743691440e-016
		,1.743496663e-016
		,1.743576693e-016
		,1.743943361e-016
		,1.744614945e-016
		,1.745621215e-016
		,1.747015486e-016
		,1.748899355e-016
		,1.751477676e-016
		,1.755200785e-016
		,1.761180526e-016
		,1.772480683e-016
		,1.798039129e-016
		,1.862573708e-016
		,2.017705913e-016
		,2.312118298e-016
		,2.717207094e-016
		,3.141459362e-016
		,3.503650435e-016
		,3.772145933e-016
		,3.959820772e-016
		,4.091854268e-016
		,4.187987806e-016
		,4.260776384e-016
		,4.317881716e-016
		,4.364048540e-016
		,4.402309858e-016
		,4.434673155e-016
		,4.462511882e-016
		,4.486794396e-016
		,4.508222156e-016
		,4.527315836e-016
		,4.544470603e-016
		,4.559992516e-016
		,1.746564816e-016
		,1.743790424e-016
		,1.741634655e-016
		,1.739845406e-016
		,1.738315853e-016
		,1.736991723e-016
		,1.735845094e-016
		,1.734866097e-016
		,1.734059089e-016
		,1.733439522e-016
		,1.733030646e-016
		,1.732860144e-016
		,1.732957336e-016
		,1.733352050e-016
		,1.734077150e-016
		,1.735178869e-016
		,1.736745164e-016
		,1.738982095e-016
		,1.742432436e-016
		,1.748632652e-016
		,1.762075549e-016
		,1.797106237e-016
		,1.896411879e-016
		,2.147582286e-016
		,2.664574659e-016
		,3.315853323e-016
		,3.777350981e-016
		,4.042180300e-016
		,4.211489671e-016
		,4.301922919e-016
		,4.362815130e-016
		,4.409181539e-016
		,4.446501928e-016
		,4.477580696e-016
		,4.504122585e-016
		,4.527351236e-016
		,4.548154306e-016
		,4.566726875e-016
		,4.583513482e-016
		,4.599809045e-016
		,4.614161051e-016
		,1.738166592e-016
		,1.735740483e-016
		,1.733803545e-016
		,1.732146273e-016
		,1.730675324e-016
		,1.729340194e-016
		,1.728112524e-016
		,1.726979296e-016
		,1.725939388e-016
		,1.725000754e-016
		,1.724177775e-016
		,1.723489032e-016
		,1.722955936e-016
		,1.722602614e-016
		,1.722457638e-016
		,1.722559540e-016
		,1.722972762e-016
		,1.723837082e-016
		,1.725524998e-016
		,1.729137846e-016
		,1.737977080e-016
		,1.761221042e-016
		,1.818957219e-016
		,1.966254073e-016
		,2.271652774e-016
		,2.752437660e-016
		,3.500661768e-016
		,4.066976550e-016
		,4.300974784e-016
		,4.389599242e-016
		,4.471047106e-016
		,4.516895236e-016
		,4.539375926e-016
		,4.558329659e-016
		,4.575468365e-016
		,4.591083667e-016
		,4.605314093e-016
		,4.618299461e-016
		,4.630202442e-016
		,4.641239215e-016
		,4.651758992e-016
		,1.729223527e-016
		,1.726840784e-016
		,1.724896839e-016
		,1.723220445e-016
		,1.721732541e-016
		,1.720387151e-016
		,1.719154989e-016
		,1.718018147e-016
		,1.716967311e-016
		,1.715999385e-016
		,1.715115234e-016
		,1.714317890e-016
		,1.713611637e-016
		,1.713002397e-016
		,1.712500093e-016
		,1.712125118e-016
		,1.711926444e-016
		,1.712037135e-016
		,1.712851903e-016
		,1.715591150e-016
		,1.723977761e-016
		,1.748339515e-016
		,1.810250806e-016
		,1.939026785e-016
		,2.165377457e-016
		,2.525782639e-016
		,3.010860899e-016
		,3.721203568e-016
		,4.318604093e-016
		,4.509507448e-016
		,4.540245278e-016
		,4.548004816e-016
		,4.582234837e-016
		,4.628252668e-016
		,4.641146529e-016
		,4.649437949e-016
		,4.657524735e-016
		,4.665505085e-016
		,4.673214786e-016
		,4.680548613e-016
		,4.687470092e-016
		,1.721304779e-016
		,1.718864947e-016
		,1.716783303e-016
		,1.714916876e-016
		,1.713201593e-016
		,1.711603388e-016
		,1.710104379e-016
		,1.708697694e-016
		,1.707384023e-016
		,1.706168324e-016
		,1.705056725e-016
		,1.704054078e-016
		,1.703162633e-016
		,1.702382238e-016
		,1.701712827e-016
		,1.701161589e-016
		,1.700763832e-016
		,1.700648150e-016
		,1.701247331e-016
		,1.703972651e-016
		,1.713213111e-016
		,1.740897636e-016
		,1.811741223e-016
		,1.956589703e-016
		,2.153592519e-016
		,2.414340063e-016
		,2.844842438e-016
		,3.311336948e-016
		,3.965803394e-016
		,4.521328261e-016
		,4.668921158e-016
		,4.658793030e-016
		,4.636909074e-016
		,4.626191259e-016
		,4.634953077e-016
		,4.677447932e-016
		,4.699766780e-016
		,4.705810833e-016
		,4.710229072e-016
		,4.714518262e-016
		,4.718809675e-016
		,1.711642391e-016
		,1.709413187e-016
		,1.707368692e-016
		,1.705452934e-016
		,1.703636101e-016
		,1.701902664e-016
		,1.700246716e-016
		,1.698668705e-016
		,1.697172406e-016
		,1.695762276e-016
		,1.694441637e-016
		,1.693212042e-016
		,1.692074090e-016
		,1.691030407e-016
		,1.690093634e-016
		,1.689310352e-016
		,1.688838476e-016
		,1.689203829e-016
		,1.692128045e-016
		,1.702970091e-016
		,1.735678022e-016
		,1.818612998e-016
		,1.977978348e-016
		,2.171742537e-016
		,2.381845545e-016
		,2.713887252e-016
		,3.153912239e-016
		,3.481376079e-016
		,3.690115888e-016
		,4.204967891e-016
		,4.643102641e-016
		,4.751851911e-016
		,4.729490551e-016
		,4.701145599e-016
		,4.683647509e-016
		,4.676308000e-016
		,4.678275660e-016
		,4.696378992e-016
		,4.741222011e-016
		,4.780100201e-016
		,4.831096277e-016
		,1.706228891e-016
		,1.703840508e-016
		,1.701610198e-016
		,1.699487473e-016
		,1.697445613e-016
		,1.695471084e-016
		,1.693559146e-016
		,1.691710608e-016
		,1.689928839e-016
		,1.688217255e-016
		,1.686577727e-016
		,1.685010200e-016
		,1.683513781e-016
		,1.682090087e-016
		,1.680752424e-016
		,1.679554007e-016
		,1.678681868e-016
		,1.678772559e-016
		,1.681938851e-016
		,1.694711989e-016
		,1.732944744e-016
		,1.825720835e-016
		,1.986573423e-016
		,2.169443973e-016
		,2.379618794e-016
		,2.580972175e-016
		,3.025493159e-016
		,3.414953971e-016
		,3.697368914e-016
		,3.876336176e-016
		,4.391791618e-016
		,4.726295375e-016
		,4.831856050e-016
		,4.911694522e-016
		,4.896043122e-016
		,4.823129085e-016
		,4.789581537e-016
		,4.772601762e-016
		,4.766254892e-016
		,4.781770522e-016
		,4.809810188e-016
		,1.706745993e-016
		,1.704047266e-016
		,1.701587427e-016
		,1.699264952e-016
		,1.697033465e-016
		,1.694868530e-016
		,1.692757974e-016
		,1.690697655e-016
		,1.688688224e-016
		,1.686732185e-016
		,1.684831522e-016
		,1.682986310e-016
		,1.681194541e-016
		,1.679453375e-016
		,1.677762513e-016
		,1.676133329e-016
		,1.674616850e-016
		,1.673396963e-016
		,1.673103568e-016
		,1.675824343e-016
		,1.687914386e-016
		,1.724473209e-016
		,1.812933466e-016
		,1.963643413e-016
		,2.146514193e-016
		,2.362843071e-016
		,2.555854651e-016
		,2.840962343e-016
		,3.272840777e-016
		,3.627491835e-016
		,3.957851150e-016
		,4.799912493e-016
		,5.023643532e-016
		,5.012637901e-016
		,4.935951615e-016
		,4.877834085e-016
		,4.839297932e-016
		,4.814639341e-016
		,4.799454631e-016
		,4.790367235e-016
		,4.787584417e-016
		,1.705666242e-016
		,1.703001480e-016
		,1.700555248e-016
		,1.698234626e-016
		,1.695997259e-016
		,1.693821198e-016
		,1.691695955e-016
		,1.689618393e-016
		,1.687589516e-016
		,1.685611594e-016
		,1.683685952e-016
		,1.681811786e-016
		,1.679986180e-016
		,1.678205437e-016
		,1.676468313e-016
		,1.674784378e-016
		,1.673199160e-016
		,1.671876588e-016
		,1.671373642e-016
		,1.673520287e-016
		,1.683837560e-016
		,1.716116227e-016
		,1.797095291e-016
		,1.937478895e-016
		,2.120854441e-016
		,2.339617061e-016
		,2.541733151e-016
		,2.700253597e-016
		,3.157264299e-016
		,3.557446067e-016
		,3.937852416e-016
		,4.429736482e-016
		,4.975906724e-016
		,5.080509304e-016
		,5.028553825e-016
		,4.954880119e-016
		,4.901080933e-016
		,4.864972783e-016
		,4.841043889e-016
		,4.825334319e-016
		,4.814728680e-016
		,1.699580681e-016
		,1.697268071e-016
		,1.695033301e-016
		,1.692856775e-016
		,1.690729634e-016
		,1.688649747e-016
		,1.686618525e-016
		,1.684638136e-016
		,1.682709467e-016
		,1.680831159e-016
		,1.678999809e-016
		,1.677211409e-016
		,1.675464568e-016
		,1.673768578e-016
		,1.672167565e-016
		,1.670818816e-016
		,1.670252122e-016
		,1.672194606e-016
		,1.681749666e-016
		,1.711970502e-016
		,1.788185187e-016
		,1.919942362e-016
		,2.102581016e-016
		,2.322047071e-016
		,2.536036702e-016
		,2.704360876e-016
		,3.038912034e-016
		,3.476139263e-016
		,3.831613944e-016
		,4.067124874e-016
		,4.229268979e-016
		,4.721872670e-016
		,4.996773981e-016
		,5.076916860e-016
		,5.112057448e-016
		,5.033966865e-016
		,4.964958900e-016
		,4.915998519e-016
		,4.882647010e-016
		,4.859843967e-016
		,4.844213094e-016
		,1.703632032e-016
		,1.701025217e-016
		,1.698605648e-016
		,1.696294959e-016
		,1.694057833e-016
		,1.691876813e-016
		,1.689744499e-016
		,1.687659620e-016
		,1.685623876e-016
		,1.683639261e-016
		,1.681706203e-016
		,1.679822812e-016
		,1.677985271e-016
		,1.676189377e-016
		,1.674433842e-016
		,1.672728448e-016
		,1.671118681e-016
		,1.669765733e-016
		,1.669209762e-016
		,1.671203296e-016
		,1.680807564e-016
		,1.711164133e-016
		,1.786930325e-016
		,1.915294699e-016
		,2.100468178e-016
		,2.322632822e-016
		,2.537169243e-016
		,2.710787124e-016
		,2.924844647e-016
		,3.402283933e-016
		,3.743250212e-016
		,4.048609413e-016
		,4.559049859e-016
		,5.061846580e-016
		,5.149802815e-016
		,5.108676830e-016
		,5.029253061e-016
		,4.967863042e-016
		,4.924805719e-016
		,4.894920718e-016
		,4.873891961e-016
		,1.702706461e-016
		,1.700113122e-016
		,1.697694117e-016
		,1.695377261e-016
		,1.693130304e-016
		,1.690937761e-016
		,1.688793564e-016
		,1.686697192e-016
		,1.684650551e-016
		,1.682655416e-016
		,1.680711760e-016
		,1.678817205e-016
		,1.676967586e-016
		,1.675158588e-016
		,1.673389112e-016
		,1.671669642e-016
		,1.670047621e-016
		,1.668690554e-016
		,1.668158781e-016
		,1.670267988e-016
		,1.680159686e-016
		,1.711363998e-016
		,1.788011118e-016
		,1.914757625e-016
		,2.102059267e-016
		,2.324620204e-016
		,2.540309822e-016
		,2.719146750e-016
		,2.847607745e-016
		,3.348623890e-016
		,3.683023752e-016
		,3.988110566e-016
		,4.299327174e-016
		,5.023560595e-016
		,5.138225433e-016
		,5.163921008e-016
		,5.084249935e-016
		,5.013106591e-016
		,4.961159919e-016
		,4.924756328e-016
		,4.899036890e-016
		,1.694576739e-016
		,1.692315727e-016
		,1.690107388e-016
		,1.687946851e-016
		,1.685834226e-016
		,1.683771546e-016
		,1.681760327e-016
		,1.679800099e-016
		,1.677888047e-016
		,1.676019736e-016
		,1.674190822e-016
		,1.672400479e-016
		,1.670660009e-016
		,1.669019087e-016
		,1.667652505e-016
		,1.667144612e-016
		,1.669383794e-016
		,1.679634586e-016
		,1.711885317e-016
		,1.789568977e-016
		,1.916009946e-016
		,2.105754383e-016
		,2.328907175e-016
		,2.545376270e-016
		,2.727749113e-016
		,2.847194266e-016
		,3.246048027e-016
		,3.633803558e-016
		,3.940059976e-016
		,4.127870598e-016
		,4.237256259e-016
		,4.494682080e-016
		,4.896350910e-016
		,5.060842584e-016
		,5.131660842e-016
		,5.200128220e-016
		,5.137765309e-016
		,5.058561892e-016
		,4.997396437e-016
		,4.953552012e-016
		,4.922256916e-016
		,1.696234848e-016
		,1.693897833e-016
		,1.691623796e-016
		,1.689400699e-016
		,1.687224700e-016
		,1.685096397e-016
		,1.683017823e-016
		,1.680990161e-016
		,1.679012460e-016
		,1.677081477e-016
		,1.675192528e-016
		,1.673341272e-016
		,1.671527186e-016
		,1.669762428e-016
		,1.668099126e-016
		,1.666719988e-016
		,1.666236258e-016
		,1.668612226e-016
		,1.679271964e-016
		,1.712676295e-016
		,1.791169613e-016
		,1.918489199e-016
		,2.110641339e-016
		,2.334628818e-016
		,2.551819342e-016
		,2.736840769e-016
		,2.865835924e-016
		,3.143500144e-016
		,3.590217470e-016
		,3.894647685e-016
		,4.138772892e-016
		,4.354191661e-016
		,4.873248543e-016
		,5.045191272e-016
		,5.132507265e-016
		,5.203375899e-016
		,5.186219330e-016
		,5.104202188e-016
		,5.035424381e-016
		,4.984780583e-016
		,4.948346207e-016
		,1.698075273e-016
		,1.695646430e-016
		,1.693302177e-016
		,1.691017973e-016
		,1.688783255e-016
		,1.686595074e-016
		,1.684454378e-016
		,1.682363096e-016
		,1.680322001e-016
		,1.678329629e-016
		,1.676382303e-016
		,1.674475102e-016
		,1.672603690e-016
		,1.670767856e-016
		,1.668980606e-016
		,1.667296734e-016
		,1.665907506e-016
		,1.665453811e-016
		,1.667971995e-016
		,1.679098898e-016
		,1.713740506e-016
		,1.792756932e-016
		,1.921924025e-016
		,2.116389237e-016
		,2.341477585e-016
		,2.559530519e-016
		,2.746820286e-016
		,2.883498340e-016
		,3.059584272e-016
		,3.553120344e-016
		,3.851701189e-016
		,4.102764947e-016
		,4.426629208e-016
		,5.077538990e-016
		,5.150182074e-016
		,5.190593168e-016
		,5.227835334e-016
		,5.153512746e-016
		,5.085363885e-016
		,5.037152449e-016
		,4.991875079e-016
		,1.695100502e-016
		,1.692750463e-016
		,1.690458034e-016
		,1.688213990e-016
		,1.686016178e-016
		,1.683865775e-016
		,1.681764533e-016
		,1.679712765e-016
		,1.677708481e-016
		,1.675747592e-016
		,1.673824967e-016
		,1.671936303e-016
		,1.670081703e-016
		,1.668275029e-016
		,1.666573805e-016
		,1.665178229e-016
		,1.664759782e-016
		,1.667417740e-016
		,1.679050693e-016
		,1.714944401e-016
		,1.794197787e-016
		,1.925733271e-016
		,2.122307973e-016
		,2.348530672e-016
		,2.567461877e-016
		,2.756723057e-016
		,2.899670533e-016
		,2.990697117e-016
		,3.515528272e-016
		,3.809281806e-016
		,4.065986662e-016
		,4.200142412e-016
		,4.306511921e-016
		,4.939200197e-016
		,5.172557185e-016
		,5.221086574e-016
		,5.281752125e-016
		,5.217916295e-016
		,5.131613224e-016
		,5.062834751e-016
		,5.012179322e-016
		,1.697012438e-016
		,1.694579301e-016
		,1.692222815e-016
		,1.689922058e-016
		,1.687669015e-016
		,1.685462262e-016
		,1.683303170e-016
		,1.681193081e-016
		,1.679131879e-016
		,1.677116806e-016
		,1.675143628e-016
		,1.673207027e-016
		,1.671302725e-016
		,1.669430916e-016
		,1.667606561e-016
		,1.665889859e-016
		,1.664490366e-016
		,1.664110763e-016
		,1.666907831e-016
		,1.679066947e-016
		,1.716186442e-016
		,1.795464312e-016
		,1.929569541e-016
		,2.128006256e-016
		,2.355180784e-016
		,2.574735509e-016
		,2.765323628e-016
		,2.912870836e-016
		,2.987730485e-016
		,3.425925512e-016
		,3.780482613e-016
		,4.046681495e-016
		,4.226582800e-016
		,4.598344464e-016
		,5.130980588e-016
		,5.226721217e-016
		,5.285253868e-016
		,5.261800124e-016
		,5.173670310e-016
		,5.097751799e-016
		,5.040516710e-016
		,1.806996208e-016
		,1.802434605e-016
		,1.800234506e-016
		,1.799567787e-016
		,1.800226238e-016
		,1.802270502e-016
		,1.806005624e-016
		,1.812183495e-016
		,1.822635299e-016
		,1.842021140e-016
		,1.882304897e-016
		,1.969724860e-016
		,2.116742146e-016
		,2.303343098e-016
		,2.451985313e-016
		,2.549383065e-016
		,2.627483639e-016
		,2.691343992e-016
		,2.744787288e-016
		,2.732430372e-016
		,2.787102922e-016
		,2.892480566e-016
		,2.989857049e-016
		,3.063561705e-016
		,3.175722279e-016
		,3.323242069e-016
		,3.467050744e-016
		,3.605812206e-016
		,3.733493254e-016
		,3.839061584e-016
		,3.929393810e-016
		,4.011758486e-016
		,4.084524563e-016
		,4.141689507e-016
		,4.189439886e-016
		,4.231247218e-016
		,4.268270213e-016
		,4.301133397e-016
		,4.330417737e-016
		,4.356549361e-016
		,4.379821149e-016
		,1.791062660e-016
		,1.787232849e-016
		,1.785082100e-016
		,1.783956594e-016
		,1.783635537e-016
		,1.784060581e-016
		,1.785266473e-016
		,1.787380975e-016
		,1.790675890e-016
		,1.795721153e-016
		,1.803817306e-016
		,1.818247328e-016
		,1.847805776e-016
		,1.914241870e-016
		,2.045506674e-016
		,2.244000351e-016
		,2.430111935e-016
		,2.553340779e-016
		,2.640276246e-016
		,2.705966390e-016
		,2.799675735e-016
		,2.875489561e-016
		,2.936144470e-016
		,3.069291476e-016
		,3.244800436e-016
		,3.416169262e-016
		,3.557055550e-016
		,3.682539389e-016
		,3.795906027e-016
		,3.897993481e-016
		,3.991245554e-016
		,4.068450872e-016
		,4.135271755e-016
		,4.192733414e-016
		,4.242000699e-016
		,4.284347818e-016
		,4.320922282e-016
		,4.352693535e-016
		,4.380449071e-016
		,4.404798807e-016
		,4.426201623e-016
		,1.777052981e-016
		,1.773887725e-016
		,1.772030095e-016
		,1.770945939e-016
		,1.770417210e-016
		,1.770343009e-016
		,1.770684912e-016
		,1.771454231e-016
		,1.772714273e-016
		,1.774594304e-016
		,1.777326977e-016
		,1.781350281e-016
		,1.787599926e-016
		,1.798379448e-016
		,1.819915567e-016
		,1.868784379e-016
		,1.976505080e-016
		,2.169542142e-016
		,2.392643047e-016
		,2.557845410e-016
		,2.683961784e-016
		,2.776772106e-016
		,2.930336893e-016
		,3.111607951e-016
		,3.290982065e-016
		,3.454055747e-016
		,3.616572028e-016
		,3.771298078e-016
		,3.899875960e-016
		,3.999243550e-016
		,4.081109080e-016
		,4.146747454e-016
		,4.202171193e-016
		,4.252684799e-016
		,4.295978499e-016
		,4.332815942e-016
		,4.364573256e-016
		,4.392239636e-016
		,4.416561974e-016
		,4.438097164e-016
		,4.457261159e-016
		,1.765383579e-016
		,1.762418379e-016
		,1.760532240e-016
		,1.759318322e-016
		,1.758596810e-016
		,1.758264294e-016
		,1.758253381e-016
		,1.758524076e-016
		,1.759064525e-016
		,1.759894668e-016
		,1.761072072e-016
		,1.762703083e-016
		,1.764968957e-016
		,1.768194739e-016
		,1.773045266e-016
		,1.781113781e-016
		,1.796710586e-016
		,1.831844947e-016
		,1.914613619e-016
		,2.085960699e-016
		,2.335184998e-016
		,2.574937158e-016
		,2.797302376e-016
		,3.007665183e-016
		,3.258974131e-016
		,3.513318165e-016
		,3.723849530e-016
		,3.884771294e-016
		,4.006663235e-016
		,4.100967993e-016
		,4.177558461e-016
		,4.239599640e-016
		,4.290218072e-016
		,4.331515183e-016
		,4.364350346e-016
		,4.392808668e-016
		,4.419750016e-016
		,4.444073355e-016
		,4.465763769e-016
		,4.485118855e-016
		,4.502560487e-016
		,1.756498854e-016
		,1.753580390e-016
		,1.751487443e-016
		,1.749917117e-016
		,1.748744716e-016
		,1.747906574e-016
		,1.747365313e-016
		,1.747097983e-016
		,1.747091113e-016
		,1.747338850e-016
		,1.747843682e-016
		,1.748620041e-016
		,1.749701350e-016
		,1.751152304e-016
		,1.753092384e-016
		,1.755749438e-016
		,1.759602845e-016
		,1.765807527e-016
		,1.777508163e-016
		,1.803801648e-016
		,1.869584197e-016
		,2.026062123e-016
		,2.320383478e-016
		,2.723643699e-016
		,3.145844919e-016
		,3.506550375e-016
		,3.774109829e-016
		,3.961212082e-016
		,4.092885850e-016
		,4.188782348e-016
		,4.261407122e-016
		,4.318394568e-016
		,4.364473683e-016
		,4.402667948e-016
		,4.434978820e-016
		,4.462775779e-016
		,4.487024478e-016
		,4.508424478e-016
		,4.527495091e-016
		,4.544630487e-016
		,4.560135981e-016
		,1.749261443e-016
		,1.746509329e-016
		,1.744373112e-016
		,1.742612159e-016
		,1.741125923e-016
		,1.739864746e-016
		,1.738804485e-016
		,1.737938158e-016
		,1.737271587e-016
		,1.736819492e-016
		,1.736601321e-016
		,1.736637312e-016
		,1.736945936e-016
		,1.737544362e-016
		,1.738454039e-016
		,1.739714942e-016
		,1.741417563e-016
		,1.743781777e-016
		,1.747377389e-016
		,1.753786138e-016
		,1.767581646e-016
		,1.802812255e-016
		,1.902141371e-016
		,2.150468656e-016
		,2.644315223e-016
		,3.290218988e-016
		,3.757895548e-016
		,4.023952351e-016
		,4.199680406e-016
		,4.302913465e-016
		,4.365883766e-016
		,4.412817849e-016
		,4.450264363e-016
		,4.481288500e-016
		,4.507660242e-016
		,4.530558801e-016
		,4.550905164e-016
		,4.569262179e-016
		,4.585617466e-016
		,4.600231371e-016
		,4.613715286e-016
		,1.742127044e-016
		,1.739653118e-016
		,1.737647369e-016
		,1.735914634e-016
		,1.734370070e-016
		,1.732969424e-016
		,1.731689482e-016
		,1.730521738e-016
		,1.729469190e-016
		,1.728543647e-016
		,1.727763086e-016
		,1.727149273e-016
		,1.726726005e-016
		,1.726518326e-016
		,1.726553357e-016
		,1.726864913e-016
		,1.727509048e-016
		,1.728614161e-016
		,1.730540107e-016
		,1.734374659e-016
		,1.743394287e-016
		,1.766697227e-016
		,1.824077488e-016
		,1.963910909e-016
		,2.259046486e-016
		,2.712959599e-016
		,3.396928227e-016
		,4.026601783e-016
		,4.302365486e-016
		,4.399923317e-016
		,4.458279952e-016
		,4.524916248e-016
		,4.553226211e-016
		,4.571467019e-016
		,4.587513964e-016
		,4.602121816e-016
		,4.615466759e-016
		,4.627665126e-016
		,4.638837062e-016
		,4.649119015e-016
		,4.658684142e-016
		,1.733826439e-016
		,1.731612397e-016
		,1.729792979e-016
		,1.728201687e-016
		,1.726761203e-016
		,1.725428064e-016
		,1.724177176e-016
		,1.722996431e-016
		,1.721883498e-016
		,1.720842922e-016
		,1.719883418e-016
		,1.719015767e-016
		,1.718251752e-016
		,1.717604495e-016
		,1.717090810e-016
		,1.716737547e-016
		,1.716599283e-016
		,1.716812569e-016
		,1.717769735e-016
		,1.720670890e-016
		,1.729161264e-016
		,1.753311055e-016
		,1.814097079e-016
		,1.940197900e-016
		,2.143881988e-016
		,2.492176968e-016
		,2.959979630e-016
		,3.569269275e-016
		,4.269311921e-016
		,4.536516838e-016
		,4.579559314e-016
		,4.580902226e-016
		,4.585817999e-016
		,4.621478505e-016
		,4.654825326e-016
		,4.664061391e-016
		,4.670695130e-016
		,4.677235429e-016
		,4.683720687e-016
		,4.690028604e-016
		,4.696079552e-016
		,1.725691185e-016
		,1.723388180e-016
		,1.721435136e-016
		,1.719700556e-016
		,1.718125217e-016
		,1.716676547e-016
		,1.715335544e-016
		,1.714091856e-016
		,1.712940663e-016
		,1.711880005e-016
		,1.710908587e-016
		,1.710024416e-016
		,1.709224562e-016
		,1.708506255e-016
		,1.707869900e-016
		,1.707326289e-016
		,1.706916780e-016
		,1.706776146e-016
		,1.707336202e-016
		,1.709975184e-016
		,1.718936072e-016
		,1.745639893e-016
		,1.813899718e-016
		,1.953739936e-016
		,2.146626804e-016
		,2.370988285e-016
		,2.802992334e-016
		,3.260359010e-016
		,3.764155679e-016
		,4.453182304e-016
		,4.692558037e-016
		,4.702045924e-016
		,4.677232008e-016
		,4.659080348e-016
		,4.651808225e-016
		,4.657701376e-016
		,4.690406671e-016
		,4.718064957e-016
		,4.725434712e-016
		,4.729417689e-016
		,4.732950521e-016
		,1.718376607e-016
		,1.716021556e-016
		,1.713956969e-016
		,1.712068662e-016
		,1.710304643e-016
		,1.708637377e-016
		,1.707053053e-016
		,1.705547273e-016
		,1.704121926e-016
		,1.702782230e-016
		,1.701534109e-016
		,1.700382338e-016
		,1.699329732e-016
		,1.698377668e-016
		,1.697528613e-016
		,1.696793503e-016
		,1.696214495e-016
		,1.695938984e-016
		,1.696463516e-016
		,1.699416984e-016
		,1.709857228e-016
		,1.740891105e-016
		,1.820007913e-016
		,1.974726311e-016
		,2.169122181e-016
		,2.387206394e-016
		,2.636672240e-016
		,3.102083231e-016
		,3.541529832e-016
		,3.973422693e-016
		,4.598417917e-016
		,4.787262449e-016
		,4.783575549e-016
		,4.748451597e-016
		,4.723192847e-016
		,4.709231634e-016
		,4.703908005e-016
		,4.705293790e-016
		,4.714211794e-016
		,4.751003819e-016
		,4.847171028e-016
		,1.711881902e-016
		,1.709416147e-016
		,1.707201614e-016
		,1.705138886e-016
		,1.703182905e-016
		,1.701310389e-016
		,1.699510322e-016
		,1.697779798e-016
		,1.696120834e-016
		,1.694537462e-016
		,1.693033374e-016
		,1.691610512e-016
		,1.690268874e-016
		,1.689007731e-016
		,1.687828985e-016
		,1.686746208e-016
		,1.685812059e-016
		,1.685208665e-016
		,1.685548695e-016
		,1.688846973e-016
		,1.701297676e-016
		,1.738243085e-016
		,1.830134331e-016
		,1.992144670e-016
		,2.182394931e-016
		,2.406412922e-016
		,2.602939698e-016
		,2.931553811e-016
		,3.374348313e-016
		,3.748216826e-016
		,4.112790422e-016
		,4.686930461e-016
		,4.848761910e-016
		,4.894715226e-016
		,5.032994418e-016
		,4.899689472e-016
		,4.842290033e-016
		,4.813417451e-016
		,4.797730908e-016
		,4.788983670e-016
		,4.790024257e-016
		,1.707169942e-016
		,1.704587575e-016
		,1.702225990e-016
		,1.699995462e-016
		,1.697855247e-016
		,1.695784569e-016
		,1.693773978e-016
		,1.691821316e-016
		,1.689928551e-016
		,1.688098937e-016
		,1.686334861e-016
		,1.684636718e-016
		,1.683003005e-016
		,1.681431839e-016
		,1.679924732e-016
		,1.678496930e-016
		,1.677209657e-016
		,1.676278253e-016
		,1.676440093e-016
		,1.680136220e-016
		,1.694614135e-016
		,1.736985042e-016
		,1.835887312e-016
		,1.991447965e-016
		,2.181387563e-016
		,2.402572548e-016
		,2.600740027e-016
		,2.755398187e-016
		,3.228885383e-016
		,3.582096707e-016
		,3.903537976e-016
		,4.325771166e-016
		,5.114132303e-016
		,5.114639242e-016
		,5.033355556e-016
		,4.954812886e-016
		,4.900499722e-016
		,4.864628812e-016
		,4.841237653e-016
		,4.826176176e-016
		,4.815872983e-016
		,1.700271988e-016
		,1.697967362e-016
		,1.695740444e-016
		,1.693572342e-016
		,1.691454701e-016
		,1.689385763e-016
		,1.687367203e-016
		,1.685401387e-016
		,1.683489379e-016
		,1.681630028e-016
		,1.679820259e-016
		,1.678056656e-016
		,1.676339198e-016
		,1.674681233e-016
		,1.673140939e-016
		,1.671926974e-016
		,1.671756010e-016
		,1.675001288e-016
		,1.688535846e-016
		,1.728829083e-016
		,1.822419232e-016
		,1.967563006e-016
		,2.157328869e-016
		,2.378374667e-016
		,2.583247328e-016
		,2.738831629e-016
		,3.001770475e-016
		,3.443638373e-016
		,3.889803145e-016
		,4.166223075e-016
		,4.313778548e-016
		,4.537136782e-016
		,5.030199247e-016
		,5.124923925e-016
		,5.140351078e-016
		,5.051073686e-016
		,4.976325984e-016
		,4.924887357e-016
		,4.890422401e-016
		,4.867130791e-016
		,4.851321276e-016
		,1.699253764e-016
		,1.696949016e-016
		,1.694716430e-016
		,1.692539168e-016
		,1.690410232e-016
		,1.688328588e-016
		,1.686296041e-016
		,1.684314591e-016
		,1.682384630e-016
		,1.680504239e-016
		,1.678669634e-016
		,1.676876784e-016
		,1.675124928e-016
		,1.673425578e-016
		,1.671830398e-016
		,1.670523530e-016
		,1.670129584e-016
		,1.672700747e-016
		,1.684134677e-016
		,1.719628578e-016
		,1.805350714e-016
		,1.941870691e-016
		,2.132641254e-016
		,2.354122663e-016
		,2.562406991e-016
		,2.731354599e-016
		,2.872807518e-016
		,3.413093733e-016
		,3.777984328e-016
		,4.117479275e-016
		,4.422816656e-016
		,4.949906583e-016
		,5.112877787e-016
		,5.152274278e-016
		,5.187905404e-016
		,5.152827120e-016
		,5.062139330e-016
		,4.992749215e-016
		,4.944700676e-016
		,4.911664131e-016
		,4.888592703e-016
		,1.695967338e-016
		,1.693733501e-016
		,1.691553119e-016
		,1.689420473e-016
		,1.687335217e-016
		,1.685299291e-016
		,1.683314407e-016
		,1.681380432e-016
		,1.679494902e-016
		,1.677653626e-016
		,1.675852365e-016
		,1.674090287e-016
		,1.672378660e-016
		,1.670767455e-016
		,1.669433218e-016
		,1.668968190e-016
		,1.671294730e-016
		,1.681826004e-016
		,1.714873032e-016
		,1.795035456e-016
		,1.924750437e-016
		,2.116241606e-016
		,2.341909826e-016
		,2.561194304e-016
		,2.748136026e-016
		,2.876937071e-016
		,3.231375622e-016
		,3.678912104e-016
		,4.019702074e-016
		,4.241282321e-016
		,4.369074579e-016
		,4.529798171e-016
		,4.978712657e-016
		,5.154727759e-016
		,5.199387132e-016
		,5.228924908e-016
		,5.148221686e-016
		,5.062330298e-016
		,4.999623650e-016
		,4.955897223e-016
		,4.925149802e-016
		,1.697304142e-016
		,1.694997631e-016
		,1.692756520e-016
		,1.690567674e-016
		,1.688426518e-016
		,1.686333278e-016
		,1.684289946e-016
		,1.682297900e-016
		,1.680356492e-016
		,1.678462755e-016
		,1.676612164e-016
		,1.674800381e-016
		,1.673026729e-016
		,1.671303018e-016
		,1.669680535e-016
		,1.668339707e-016
		,1.667884371e-016
		,1.670262248e-016
		,1.680875651e-016
		,1.714114964e-016
		,1.793185113e-016
		,1.921014193e-016
		,2.113305567e-016
		,2.338410890e-016
		,2.557652035e-016
		,2.746862295e-016
		,2.886156840e-016
		,3.087695051e-016
		,3.599185479e-016
		,3.932733964e-016
		,4.224757099e-016
		,4.493267863e-016
		,5.073556709e-016
		,5.196363931e-016
		,5.228421027e-016
		,5.248266079e-016
		,5.229199785e-016
		,5.133674958e-016
		,5.056001708e-016
		,5.000241420e-016
		,4.960843480e-016
		,1.696428332e-016
		,1.694110595e-016
		,1.691855552e-016
		,1.689651710e-016
		,1.687495534e-016
		,1.685387734e-016
		,1.683330298e-016
		,1.681324262e-016
		,1.679368493e-016
		,1.677459589e-016
		,1.675592777e-016
		,1.673763710e-016
		,1.671971987e-016
		,1.670230173e-016
		,1.668591710e-016
		,1.667243700e-016
		,1.666812346e-016
		,1.669299197e-016
		,1.680224166e-016
		,1.714268789e-016
		,1.793027252e-016
		,1.921094069e-016
		,2.114486669e-016
		,2.339624139e-016
		,2.559177543e-016
		,2.750447915e-016
		,2.897182685e-016
		,2.994173233e-016
		,3.540366523e-016
		,3.862744216e-016
		,4.157829115e-016
		,4.331238669e-016
		,4.429848799e-016
		,4.735236868e-016
		,5.198798377e-016
		,5.241412739e-016
		,5.269991058e-016
		,5.195003891e-016
		,5.108707134e-016
		,5.042904783e-016
		,4.995543925e-016
		,1.693350226e-016
		,1.691079402e-016
		,1.688858528e-016
		,1.686684973e-016
		,1.684559814e-016
		,1.682484954e-016
		,1.680461050e-016
		,1.678486494e-016
		,1.676557501e-016
		,1.674669110e-016
		,1.672817032e-016
		,1.671001218e-016
		,1.669235079e-016
		,1.667574618e-016
		,1.666214739e-016
		,1.665808458e-016
		,1.668411488e-016
		,1.679743817e-016
		,1.714792990e-016
		,1.793331965e-016
		,1.922852234e-016
		,2.117498637e-016
		,2.342840346e-016
		,2.562569964e-016
		,2.755392347e-016
		,2.907708161e-016
		,2.990227283e-016
		,3.427435910e-016
		,3.811613411e-016
		,4.106186192e-016
		,4.287489143e-016
		,4.376813728e-016
		,4.472532275e-016
		,4.823672046e-016
		,5.156830593e-016
		,5.251011818e-016
		,5.276232471e-016
		,5.243010962e-016
		,5.153103313e-016
		,5.079714891e-016
		,5.025733637e-016
		,1.695041312e-016
		,1.692699698e-016
		,1.690415514e-016
		,1.688180080e-016
		,1.685991515e-016
		,1.683851129e-016
		,1.681760631e-016
		,1.679720233e-016
		,1.677727829e-016
		,1.675779250e-016
		,1.673869360e-016
		,1.671993936e-016
		,1.670153281e-016
		,1.668361678e-016
		,1.666677838e-016
		,1.665305357e-016
		,1.664926454e-016
		,1.667649907e-016
		,1.679456653e-016
		,1.715628923e-016
		,1.794044646e-016
		,1.925738286e-016
		,2.121873389e-016
		,2.347691886e-016
		,2.567523674e-016
		,2.761187408e-016
		,2.917462465e-016
		,3.013003801e-016
		,3.307819761e-016
		,3.766600845e-016
		,4.057694220e-016
		,4.291407528e-016
		,4.505782451e-016
		,5.128194195e-016
		,5.233847730e-016
		,5.268110237e-016
		,5.275224555e-016
		,5.289334287e-016
		,5.205349992e-016
		,5.124656749e-016
		,5.063291027e-016
		,1.692115928e-016
		,1.689821262e-016
		,1.687574415e-016
		,1.685374137e-016
		,1.683221860e-016
		,1.681119019e-016
		,1.679065338e-016
		,1.677058198e-016
		,1.675093063e-016
		,1.673164635e-016
		,1.671268765e-016
		,1.669406097e-016
		,1.667591850e-016
		,1.665887519e-016
		,1.664506510e-016
		,1.664163488e-016
		,1.667025895e-016
		,1.679379883e-016
		,1.716782819e-016
		,1.795250704e-016
		,1.929590966e-016
		,2.127576493e-016
		,2.354255601e-016
		,2.574412096e-016
		,2.768661959e-016
		,2.927307164e-016
		,3.032325613e-016
		,3.206683662e-016
		,3.724077109e-016
		,4.008641801e-016
		,4.250441154e-016
		,4.371972309e-016
		,4.432190366e-016
		,4.636693713e-016
		,5.084631491e-016
		,5.254332090e-016
		,5.317019472e-016
		,5.360155254e-016
		,5.283941332e-016
		,5.186977516e-016
		,5.111368202e-016
		,1.691564537e-016
		,1.689260971e-016
		,1.687004592e-016
		,1.684794649e-016
		,1.682632645e-016
		,1.680519649e-016
		,1.678454907e-016
		,1.676435257e-016
		,1.674455863e-016
		,1.672511284e-016
		,1.670597464e-016
		,1.668715395e-016
		,1.666881270e-016
		,1.665159414e-016
		,1.663773620e-016
		,1.663472262e-016
		,1.666479260e-016
		,1.679400082e-016
		,1.717998730e-016
		,1.796498846e-016
		,1.933569839e-016
		,2.133339301e-016
		,2.360850997e-016
		,2.581316354e-016
		,2.776090874e-016
		,2.936850196e-016
		,3.049342989e-016
		,3.120495997e-016
		,3.682136512e-016
		,3.963057244e-016
		,4.227866933e-016
		,4.373062865e-016
		,4.428783319e-016
		,4.557910267e-016
		,5.124782591e-016
		,5.287486286e-016
		,5.338337100e-016
		,5.355105006e-016
		,5.322906209e-016
		,5.225887176e-016
		,5.144253723e-016
		,1.809045515e-016
		,1.804565775e-016
		,1.802443188e-016
		,1.801865353e-016
		,1.802628033e-016
		,1.804791345e-016
		,1.808659950e-016
		,1.814991606e-016
		,1.825637918e-016
		,1.845302500e-016
		,1.886005564e-016
		,1.974230934e-016
		,2.122074297e-016
		,2.309086257e-016
		,2.463060951e-016
		,2.558515410e-016
		,2.643434042e-016
		,2.702403078e-016
		,2.767005507e-016
		,2.761231089e-016
		,2.791648271e-016
		,2.893908686e-016
		,3.002929291e-016
		,3.091077189e-016
		,3.188674251e-016
		,3.325462372e-016
		,3.478376185e-016
		,3.613920185e-016
		,3.732992982e-016
		,3.840074817e-016
		,3.930643448e-016
		,4.012182091e-016
		,4.085141627e-016
		,4.143012260e-016
		,4.191167365e-016
		,4.232569847e-016
		,4.268730462e-016
		,4.300885386e-016
		,4.329699775e-016
		,4.355559233e-016
		,4.378730175e-016
		,1.793526057e-016
		,1.789712190e-016
		,1.787561147e-016
		,1.786439562e-016
		,1.786137493e-016
		,1.786603234e-016
		,1.787875330e-016
		,1.790082911e-016
		,1.793497981e-016
		,1.798693347e-016
		,1.806983433e-016
		,1.821689991e-016
		,1.851678011e-016
		,1.918895433e-016
		,2.051094947e-016
		,2.250051616e-016
		,2.440642208e-016
		,2.562089894e-016
		,2.656504714e-016
		,2.716898837e-016
		,2.812629251e-016
		,2.903260084e-016
		,2.962631764e-016
		,3.073774846e-016
		,3.244817069e-016
		,3.421369555e-016
		,3.572260495e-016
		,3.691304843e-016
		,3.804808398e-016
		,3.911144763e-016
		,3.995239811e-016
		,4.067345088e-016
		,4.132297268e-016
		,4.189249315e-016
		,4.238541144e-016
		,4.281124655e-016
		,4.318021867e-016
		,4.350142770e-016
		,4.378249494e-016
		,4.402951093e-016
		,4.424716276e-016
		,1.779863857e-016
		,1.776786441e-016
		,1.774961261e-016
		,1.773874375e-016
		,1.773323486e-016
		,1.773221848e-016
		,1.773543607e-016
		,1.774310704e-016
		,1.775594873e-016
		,1.777531508e-016
		,1.780357458e-016
		,1.784515094e-016
		,1.790951135e-016
		,1.802000601e-016
		,1.823960930e-016
		,1.873581915e-016
		,1.982316410e-016
		,2.176157959e-016
		,2.402696213e-016
		,2.566456195e-016
		,2.697654994e-016
		,2.792056963e-016
		,2.940416702e-016
		,3.123698090e-016
		,3.310965709e-016
		,3.474903590e-016
		,3.626879929e-016
		,3.771874313e-016
		,3.899058088e-016
		,4.001075018e-016
		,4.082597634e-016
		,4.150285186e-016
		,4.206815930e-016
		,4.252235681e-016
		,4.293973069e-016
		,4.331063527e-016
		,4.363147062e-016
		,4.391118267e-016
		,4.415720982e-016
		,4.437541126e-016
		,4.456994757e-016
		,1.767911244e-016
		,1.765167254e-016
		,1.763466855e-016
		,1.762401994e-016
		,1.761788584e-016
		,1.761522085e-016
		,1.761539270e-016
		,1.761809426e-016
		,1.762333529e-016
		,1.763145859e-016
		,1.764318082e-016
		,1.765969254e-016
		,1.768291593e-016
		,1.771620305e-016
		,1.776633833e-016
		,1.784954209e-016
		,1.800959097e-016
		,1.836818641e-016
		,1.920684871e-016
		,2.093109557e-016
		,2.344793166e-016
		,2.584275555e-016
		,2.807311597e-016
		,3.023360053e-016
		,3.266090752e-016
		,3.517106162e-016
		,3.726826566e-016
		,3.886811870e-016
		,4.009603878e-016
		,4.102858614e-016
		,4.178474391e-016
		,4.240565401e-016
		,4.291685282e-016
		,4.334180146e-016
		,4.369666954e-016
		,4.398994950e-016
		,4.423058666e-016
		,4.445404349e-016
		,4.466635141e-016
		,4.485928724e-016
		,4.503299185e-016
		,1.758608131e-016
		,1.755861841e-016
		,1.753943510e-016
		,1.752556441e-016
		,1.751574207e-016
		,1.750926575e-016
		,1.750566274e-016
		,1.750459071e-016
		,1.750581549e-016
		,1.750922128e-016
		,1.751483846e-016
		,1.752288415e-016
		,1.753382109e-016
		,1.754845984e-016
		,1.756817413e-016
		,1.759542846e-016
		,1.763522963e-016
		,1.769945383e-016
		,1.782021642e-016
		,1.808985127e-016
		,1.875877667e-016
		,2.033510823e-016
		,2.327691950e-016
		,2.729312675e-016
		,3.149705822e-016
		,3.509105717e-016
		,3.775842524e-016
		,3.962441166e-016
		,4.093798246e-016
		,4.189485874e-016
		,4.261966187e-016
		,4.318849583e-016
		,4.364851225e-016
		,4.402986219e-016
		,4.435250718e-016
		,4.463010707e-016
		,4.487229455e-016
		,4.508604851e-016
		,4.527655010e-016
		,4.544773219e-016
		,4.560264134e-016
		,1.751435582e-016
		,1.748751024e-016
		,1.746683730e-016
		,1.745003139e-016
		,1.743614176e-016
		,1.742470729e-016
		,1.741550601e-016
		,1.740846659e-016
		,1.740361711e-016
		,1.740103950e-016
		,1.740082789e-016
		,1.740306047e-016
		,1.740779863e-016
		,1.741512479e-016
		,1.742522951e-016
		,1.743857169e-016
		,1.745619825e-016
		,1.748052176e-016
		,1.751752509e-016
		,1.758343282e-016
		,1.772470983e-016
		,1.807961436e-016
		,1.907536739e-016
		,2.154399005e-016
		,2.632278654e-016
		,3.273568799e-016
		,3.745487195e-016
		,4.013879493e-016
		,4.181936320e-016
		,4.298870085e-016
		,4.365489127e-016
		,4.413600095e-016
		,4.451669225e-016
		,4.483053912e-016
		,4.509619052e-016
		,4.532561916e-016
		,4.552764289e-016
		,4.570942963e-016
		,4.587367392e-016
		,4.601988388e-016
		,4.615107526e-016
		,1.745044925e-016
		,1.742540260e-016
		,1.740500622e-016
		,1.738739942e-016
		,1.737178309e-016
		,1.735775174e-016
		,1.734510680e-016
		,1.733379563e-016
		,1.732387928e-016
		,1.731550343e-016
		,1.730886774e-016
		,1.730419564e-016
		,1.730170821e-016
		,1.730160762e-016
		,1.730408053e-016
		,1.730934897e-016
		,1.731784553e-016
		,1.733074885e-016
		,1.735161545e-016
		,1.739137134e-016
		,1.748289479e-016
		,1.771718755e-016
		,1.829160348e-016
		,1.963650266e-016
		,2.251296625e-016
		,2.686461752e-016
		,3.306930948e-016
		,3.974467864e-016
		,4.295336355e-016
		,4.409490605e-016
		,4.460147384e-016
		,4.516632026e-016
		,4.563260893e-016
		,4.583058097e-016
		,4.598462350e-016
		,4.612274025e-016
		,4.624877865e-016
		,4.636411011e-016
		,4.646980935e-016
		,4.656697519e-016
		,4.665683352e-016
		,1.738074093e-016
		,1.735837198e-016
		,1.733960891e-016
		,1.732292052e-016
		,1.730762548e-016
		,1.729336358e-016
		,1.727994707e-016
		,1.726730885e-016
		,1.725547194e-016
		,1.724452236e-016
		,1.723458425e-016
		,1.722580086e-016
		,1.721832519e-016
		,1.721232331e-016
		,1.720799563e-016
		,1.720563520e-016
		,1.720579616e-016
		,1.720982451e-016
		,1.722157719e-016
		,1.725289234e-016
		,1.733976355e-016
		,1.758127617e-016
		,1.818260582e-016
		,1.942161345e-016
		,2.128326832e-016
		,2.462648464e-016
		,2.913129478e-016
		,3.457101361e-016
		,4.179208622e-016
		,4.552143479e-016
		,4.618074020e-016
		,4.616926862e-016
		,4.610824845e-016
		,4.618272423e-016
		,4.655146180e-016
		,4.677131943e-016
		,4.683857070e-016
		,4.689321693e-016
		,4.694716423e-016
		,4.700070253e-016
		,4.705295645e-016
		,1.727806245e-016
		,1.726025024e-016
		,1.724443321e-016
		,1.722997633e-016
		,1.721650793e-016
		,1.720380401e-016
		,1.719174646e-016
		,1.718029501e-016
		,1.716946011e-016
		,1.715927817e-016
		,1.714979340e-016
		,1.714105036e-016
		,1.713310018e-016
		,1.712602702e-016
		,1.712001730e-016
		,1.711555821e-016
		,1.711405591e-016
		,1.711983269e-016
		,1.714646474e-016
		,1.723540159e-016
		,1.749710373e-016
		,1.816182665e-016
		,1.951785735e-016
		,2.139361398e-016
		,2.347699061e-016
		,2.746160956e-016
		,3.211505083e-016
		,3.571177881e-016
		,3.816543504e-016
		,4.327397510e-016
		,4.707138417e-016
		,4.742057154e-016
		,4.709875576e-016
		,4.684238468e-016
		,4.670821118e-016
		,4.667485499e-016
		,4.673604524e-016
		,4.701224973e-016
		,4.729401819e-016
		,4.737841140e-016
		,4.741905805e-016
		,1.720352806e-016
		,1.718383751e-016
		,1.716589135e-016
		,1.714923418e-016
		,1.713363734e-016
		,1.711899473e-016
		,1.710527742e-016
		,1.709249910e-016
		,1.708068483e-016
		,1.706984568e-016
		,1.705996401e-016
		,1.705099233e-016
		,1.704286762e-016
		,1.703554646e-016
		,1.702908723e-016
		,1.702387899e-016
		,1.702136242e-016
		,1.702637497e-016
		,1.705464269e-016
		,1.715458810e-016
		,1.745056138e-016
		,1.820563419e-016
		,1.968622833e-016
		,2.159885578e-016
		,2.385955244e-016
		,2.589567287e-016
		,3.052027561e-016
		,3.484762380e-016
		,3.790899150e-016
		,3.983699013e-016
		,4.396916665e-016
		,4.777878601e-016
		,4.834080062e-016
		,4.797230684e-016
		,4.764184516e-016
		,4.743458453e-016
		,4.732486822e-016
		,4.728547918e-016
		,4.729476316e-016
		,4.734578052e-016
		,4.757824615e-016
		,1.713441433e-016
		,1.711373006e-016
		,1.709452500e-016
		,1.707638096e-016
		,1.705908129e-016
		,1.704252413e-016
		,1.702668365e-016
		,1.701158011e-016
		,1.699725295e-016
		,1.698373971e-016
		,1.697106423e-016
		,1.695923591e-016
		,1.694826154e-016
		,1.693817608e-016
		,1.692912618e-016
		,1.692162713e-016
		,1.691741252e-016
		,1.692226542e-016
		,1.695510075e-016
		,1.707364506e-016
		,1.742277587e-016
		,1.830014786e-016
		,1.987720845e-016
		,2.184216742e-016
		,2.411988755e-016
		,2.615496834e-016
		,2.831838292e-016
		,3.329514798e-016
		,3.708922663e-016
		,3.963780188e-016
		,4.120844061e-016
		,4.466828614e-016
		,4.833896877e-016
		,4.918303979e-016
		,5.060010608e-016
		,5.024010176e-016
		,4.904734503e-016
		,4.858471958e-016
		,4.833261111e-016
		,4.818511890e-016
		,4.808741348e-016
		,1.709792409e-016
		,1.707373268e-016
		,1.705161580e-016
		,1.703076830e-016
		,1.701082663e-016
		,1.699161103e-016
		,1.697304695e-016
		,1.695512639e-016
		,1.693787695e-016
		,1.692133483e-016
		,1.690552506e-016
		,1.689045246e-016
		,1.687610415e-016
		,1.686246533e-016
		,1.684955669e-016
		,1.683753502e-016
		,1.682700984e-016
		,1.682010045e-016
		,1.682397738e-016
		,1.686224723e-016
		,1.700433053e-016
		,1.742383556e-016
		,1.842481983e-016
		,1.999348089e-016
		,2.194705691e-016
		,2.425174943e-016
		,2.634983060e-016
		,2.783638552e-016
		,3.104044246e-016
		,3.536034539e-016
		,3.864561651e-016
		,4.155587156e-016
		,4.892403551e-016
		,5.191862402e-016
		,5.133064947e-016
		,5.033466247e-016
		,4.961127802e-016
		,4.912600350e-016
		,4.880603085e-016
		,4.859429642e-016
		,4.845306446e-016
		,1.700698174e-016
		,1.698462131e-016
		,1.696303613e-016
		,1.694206750e-016
		,1.692165375e-016
		,1.690179215e-016
		,1.688250797e-016
		,1.686382849e-016
		,1.684576551e-016
		,1.682830887e-016
		,1.681143189e-016
		,1.679510972e-016
		,1.677936215e-016
		,1.676437098e-016
		,1.675085804e-016
		,1.674136281e-016
		,1.674453180e-016
		,1.678869639e-016
		,1.695198587e-016
		,1.742000842e-016
		,1.845761292e-016
		,1.995478392e-016
		,2.192580649e-016
		,2.414675374e-016
		,2.619756796e-016
		,2.781706452e-016
		,2.889977141e-016
		,3.386633155e-016
		,3.732311113e-016
		,4.262680458e-016
		,4.511551329e-016
		,4.869796518e-016
		,5.143178345e-016
		,5.192761634e-016
		,5.211408979e-016
		,5.148318116e-016
		,5.053501792e-016
		,4.985130924e-016
		,4.938789369e-016
		,4.907251444e-016
		,4.885423447e-016
		,1.701359416e-016
		,1.698965566e-016
		,1.696669916e-016
		,1.694442265e-016
		,1.692268306e-016
		,1.690142731e-016
		,1.688065469e-016
		,1.686038630e-016
		,1.684064031e-016
		,1.682141634e-016
		,1.680269111e-016
		,1.678442526e-016
		,1.676658169e-016
		,1.674916590e-016
		,1.673233483e-016
		,1.671674668e-016
		,1.670475741e-016
		,1.670445953e-016
		,1.674252187e-016
		,1.689190097e-016
		,1.733138207e-016
		,1.830061718e-016
		,1.970106679e-016
		,2.167312242e-016
		,2.389771668e-016
		,2.597621582e-016
		,2.767966239e-016
		,2.884303478e-016
		,3.196932497e-016
		,3.731859236e-016
		,4.082274780e-016
		,4.320106506e-016
		,4.458648238e-016
		,4.732556998e-016
		,5.238460132e-016
		,5.249259100e-016
		,5.159654166e-016
		,5.069041393e-016
		,5.004462340e-016
		,4.959970288e-016
		,4.928896144e-016
		,1.700336664e-016
		,1.697947231e-016
		,1.695649421e-016
		,1.693415718e-016
		,1.691233515e-016
		,1.689098561e-016
		,1.687011246e-016
		,1.684973606e-016
		,1.682986982e-016
		,1.681050668e-016
		,1.679161664e-016
		,1.677315492e-016
		,1.675508007e-016
		,1.673739109e-016
		,1.672022509e-016
		,1.670416351e-016
		,1.669126781e-016
		,1.668853113e-016
		,1.671871612e-016
		,1.684471047e-016
		,1.723159939e-016
		,1.811340655e-016
		,1.946231435e-016
		,2.142666091e-016
		,2.364203747e-016
		,2.574751388e-016
		,2.778651126e-016
		,2.932187933e-016
		,3.041609108e-016
		,3.614022071e-016
		,3.964476247e-016
		,4.285702832e-016
		,4.537616670e-016
		,4.816533864e-016
		,5.266956228e-016
		,5.286037467e-016
		,5.262597718e-016
		,5.160395538e-016
		,5.076410575e-016
		,5.016795457e-016
		,4.974973508e-016
		,1.694654656e-016
		,1.692416019e-016
		,1.690227918e-016
		,1.688087075e-016
		,1.685994290e-016
		,1.683951512e-016
		,1.681959659e-016
		,1.680017463e-016
		,1.678121429e-016
		,1.676266762e-016
		,1.674449208e-016
		,1.672668675e-016
		,1.670938670e-016
		,1.669315804e-016
		,1.667998141e-016
		,1.667650898e-016
		,1.670392636e-016
		,1.682080786e-016
		,1.718237412e-016
		,1.800165936e-016
		,1.932257169e-016
		,2.129860449e-016
		,2.357815089e-016
		,2.579558446e-016
		,2.774118766e-016
		,2.929737536e-016
		,3.019969811e-016
		,3.425493194e-016
		,3.865293079e-016
		,4.190897078e-016
		,4.398898928e-016
		,4.513300023e-016
		,4.708057238e-016
		,5.268021345e-016
		,5.323473871e-016
		,5.320454789e-016
		,5.316106209e-016
		,5.251814819e-016
		,5.151600644e-016
		,5.075425723e-016
		,5.021229556e-016
		,1.698398729e-016
		,1.696006649e-016
		,1.693696833e-016
		,1.691446556e-016
		,1.689246263e-016
		,1.687093549e-016
		,1.684989539e-016
		,1.682936043e-016
		,1.680933545e-016
		,1.678980256e-016
		,1.677072244e-016
		,1.675204477e-016
		,1.673372689e-016
		,1.671577001e-016
		,1.669831374e-016
		,1.668193707e-016
		,1.666865353e-016
		,1.666522358e-016
		,1.669277232e-016
		,1.681058972e-016
		,1.717245251e-016
		,1.796850009e-016
		,1.928700840e-016
		,2.125579728e-016
		,2.352344422e-016
		,2.573246303e-016
		,2.768636906e-016
		,2.929016831e-016
		,3.036517613e-016
		,3.253297498e-016
		,3.784813774e-016
		,4.104119888e-016
		,4.381445679e-016
		,4.580651686e-016
		,4.874016590e-016
		,5.332237491e-016
		,5.334741759e-016
		,5.319667203e-016
		,5.222679381e-016
		,5.133352995e-016
		,5.067479973e-016
		,1.695169772e-016
		,1.692845251e-016
		,1.690578231e-016
		,1.688360506e-016
		,1.686190441e-016
		,1.684069407e-016
		,1.681999039e-016
		,1.679979395e-016
		,1.678008209e-016
		,1.676081196e-016
		,1.674193176e-016
		,1.672339964e-016
		,1.670522027e-016
		,1.668754117e-016
		,1.667096474e-016
		,1.665757875e-016
		,1.665438312e-016
		,1.668280356e-016
		,1.680428920e-016
		,1.717331980e-016
		,1.795903862e-016
		,1.929042007e-016
		,2.126354310e-016
		,2.353036948e-016
		,2.574000101e-016
		,2.770265907e-016
		,2.933492256e-016
		,3.049807467e-016
		,3.135528605e-016
		,3.721082405e-016
		,4.029850041e-016
		,4.308853266e-016
		,4.470537084e-016
		,4.557612698e-016
		,4.804704869e-016
		,5.352880989e-016
		,5.349792419e-016
		,5.342944379e-016
		,5.289744837e-016
		,5.192830067e-016
		,5.115998537e-016
		,1.694459550e-016
		,1.692120714e-016
		,1.689837286e-016
		,1.687602256e-016
		,1.685414618e-016
		,1.683275872e-016
		,1.681187396e-016
		,1.679148784e-016
		,1.677157304e-016
		,1.675208347e-016
		,1.673296624e-016
		,1.671418076e-016
		,1.669573552e-016
		,1.667778761e-016
		,1.666096590e-016
		,1.664745149e-016
		,1.664453397e-016
		,1.667407743e-016
		,1.680023145e-016
		,1.717856122e-016
		,1.795860868e-016
		,1.930889708e-016
		,2.129022997e-016
		,2.355789652e-016
		,2.576754483e-016
		,2.773683640e-016
		,2.939332450e-016
		,3.062928395e-016
		,3.107911536e-016
		,3.613268912e-016
		,3.974076811e-016
		,4.254118479e-016
		,4.465981656e-016
		,4.600096050e-016
		,5.099098963e-016
		,5.318363653e-016
		,5.357593935e-016
		,5.341130376e-016
		,5.334800548e-016
		,5.245525171e-016
		,5.161419233e-016
		,1.691490615e-016
		,1.689193915e-016
		,1.686944815e-016
		,1.684742808e-016
		,1.682589404e-016
		,1.680485638e-016
		,1.678430600e-016
		,1.676421072e-016
		,1.674452128e-016
		,1.672518378e-016
		,1.670615885e-016
		,1.668745854e-016
		,1.666924984e-016
		,1.665218942e-016
		,1.663856012e-016
		,1.663597257e-016
		,1.666677454e-016
		,1.679810187e-016
		,1.718640244e-016
		,1.796363939e-016
		,1.933681659e-016
		,2.132924517e-016
		,2.359950095e-016
		,2.580873336e-016
		,2.778230504e-016
		,2.945674204e-016
		,3.074698488e-016
		,3.135537863e-016
		,3.473476093e-016
		,3.923230262e-016
		,4.198935128e-016
		,4.421815364e-016
		,4.535250508e-016
		,4.574883067e-016
		,4.784231787e-016
		,5.300081968e-016
		,5.363958005e-016
		,5.365255386e-016
		,5.385629267e-016
		,5.354909936e-016
		,5.239391367e-016
		,1.693271615e-016
		,1.690912194e-016
		,1.688604823e-016
		,1.686344495e-016
		,1.684131090e-016
		,1.681966048e-016
		,1.679850002e-016
		,1.677781520e-016
		,1.675756911e-016
		,1.673770960e-016
		,1.671818195e-016
		,1.669894803e-016
		,1.668002354e-016
		,1.666158541e-016
		,1.664432136e-016
		,1.663062192e-016
		,1.662845000e-016
		,1.666073889e-016
		,1.679792705e-016
		,1.719682995e-016
		,1.797543862e-016
		,1.937652033e-016
		,2.138354883e-016
		,2.366017943e-016
		,2.586783646e-016
		,2.783877591e-016
		,2.951924830e-016
		,3.084567730e-016
		,3.158232488e-016
		,3.351779919e-016
		,3.875511812e-016
		,4.145148627e-016
		,4.378859209e-016
		,4.512028195e-016
		,4.600564817e-016
		,4.888579775e-016
		,5.440385981e-016
		,5.432704367e-016
		,5.417217190e-016
		,5.373944790e-016
		,5.269743119e-016
		,1.810911374e-016
		,1.806523317e-016
		,1.804488898e-016
		,1.804008439e-016
		,1.804879623e-016
		,1.807160763e-016
		,1.811155969e-016
		,1.817629720e-016
		,1.828454773e-016
		,1.848376898e-016
		,1.889468399e-016
		,1.978297159e-016
		,2.127168075e-016
		,2.314196764e-016
		,2.471809029e-016
		,2.568873707e-016
		,2.658060707e-016
		,2.713062216e-016
		,2.783213493e-016
		,2.792945855e-016
		,2.802518932e-016
		,2.893269552e-016
		,3.009899417e-016
		,3.109445910e-016
		,3.208922929e-016
		,3.329386956e-016
		,3.475707198e-016
		,3.622495475e-016
		,3.742327336e-016
		,3.840786390e-016
		,3.931343611e-016
		,4.012344726e-016
		,4.085211902e-016
		,4.143170089e-016
		,4.191465538e-016
		,4.233387267e-016
		,4.269807077e-016
		,4.301525729e-016
		,4.329604547e-016
		,4.354877874e-016
		,4.377724187e-016
		,1.795728087e-016
		,1.791928307e-016
		,1.789784806e-016
		,1.788680431e-016
		,1.788412980e-016
		,1.788934765e-016
		,1.790285687e-016
		,1.792593988e-016
		,1.796130182e-016
		,1.801469282e-016
		,1.809939769e-016
		,1.824901408e-016
		,1.855285173e-016
		,1.923144752e-016
		,2.056329639e-016
		,2.255588430e-016
		,2.449075033e-016
		,2.571348832e-016
		,2.669563877e-016
		,2.729466202e-016
		,2.823854846e-016
		,2.923947627e-016
		,2.993590882e-016
		,3.083810286e-016
		,3.243411241e-016
		,3.420827773e-016
		,3.580451613e-016
		,3.704017084e-016
		,3.808611137e-016
		,3.914480426e-016
		,4.006641775e-016
		,4.072889522e-016
		,4.131004994e-016
		,4.186316731e-016
		,4.235257068e-016
		,4.277898003e-016
		,4.315005529e-016
		,4.347393330e-016
		,4.375782246e-016
		,4.400770999e-016
		,4.422831610e-016
		,1.782520672e-016
		,1.779467699e-016
		,1.777628272e-016
		,1.776509464e-016
		,1.775923362e-016
		,1.775794358e-016
		,1.776105398e-016
		,1.776885179e-016
		,1.778210171e-016
		,1.780218375e-016
		,1.783147586e-016
		,1.787441875e-016
		,1.794057170e-016
		,1.805358329e-016
		,1.827709257e-016
		,1.877985718e-016
		,1.987684484e-016
		,2.182163364e-016
		,2.410958114e-016
		,2.575039387e-016
		,2.707388718e-016
		,2.808929185e-016
		,2.949706552e-016
		,3.133932700e-016
		,3.324928647e-016
		,3.492484097e-016
		,3.642825675e-016
		,3.777277868e-016
		,3.898098240e-016
		,3.999391430e-016
		,4.083268974e-016
		,4.150977498e-016
		,4.207426895e-016
		,4.255927055e-016
		,4.295815038e-016
		,4.329814858e-016
		,4.361487198e-016
		,4.389564662e-016
		,4.414331041e-016
		,4.436323650e-016
		,4.455989892e-016
		,1.770527218e-016
		,1.767958535e-016
		,1.766381985e-016
		,1.765393518e-016
		,1.764813300e-016
		,1.764544727e-016
		,1.764535829e-016
		,1.764768841e-016
		,1.765257676e-016
		,1.766048373e-016
		,1.767222536e-016
		,1.768907097e-016
		,1.771300212e-016
		,1.774742337e-016
		,1.779920983e-016
		,1.788482683e-016
		,1.804866507e-016
		,1.841378117e-016
		,1.926240270e-016
		,2.099545175e-016
		,2.352834400e-016
		,2.592887161e-016
		,2.814919042e-016
		,3.037694191e-016
		,3.272816259e-016
		,3.520668286e-016
		,3.729463377e-016
		,3.888641230e-016
		,4.011583032e-016
		,4.105033629e-016
		,4.179212473e-016
		,4.240871542e-016
		,4.292024401e-016
		,4.334786100e-016
		,4.370878519e-016
		,4.401563427e-016
		,4.427657886e-016
		,4.449653287e-016
		,4.468581935e-016
		,4.486831106e-016
		,4.504107398e-016
		,1.760730215e-016
		,1.758182076e-016
		,1.756458112e-016
		,1.755261794e-016
		,1.754459558e-016
		,1.753971056e-016
		,1.753739065e-016
		,1.753722519e-016
		,1.753896492e-016
		,1.754254006e-016
		,1.754808008e-016
		,1.755593559e-016
		,1.756671625e-016
		,1.758137645e-016
		,1.760142175e-016
		,1.762943921e-016
		,1.767057657e-016
		,1.773695865e-016
		,1.786127358e-016
		,1.813706330e-016
		,1.881596963e-016
		,2.040236437e-016
		,2.334244960e-016
		,2.734379023e-016
		,3.153155650e-016
		,3.511391075e-016
		,3.777393950e-016
		,3.963542940e-016
		,4.094617023e-016
		,4.190117848e-016
		,4.262468864e-016
		,4.319259064e-016
		,4.365191266e-016
		,4.403273101e-016
		,4.435495983e-016
		,4.463222772e-016
		,4.487414608e-016
		,4.508767886e-016
		,4.527799645e-016
		,4.544902385e-016
		,4.560380175e-016
		,1.753349109e-016
		,1.750768478e-016
		,1.748810220e-016
		,1.747252278e-016
		,1.746003290e-016
		,1.745018018e-016
		,1.744272262e-016
		,1.743753526e-016
		,1.743455761e-016
		,1.743375583e-016
		,1.743510076e-016
		,1.743856899e-016
		,1.744417136e-016
		,1.745200954e-016
		,1.746236421e-016
		,1.747584073e-016
		,1.749366758e-016
		,1.751845899e-016
		,1.755642712e-016
		,1.762411890e-016
		,1.776862695e-016
		,1.812650610e-016
		,1.912553513e-016
		,2.158493918e-016
		,2.624975206e-016
		,3.259434586e-016
		,3.738480841e-016
		,4.011503354e-016
		,4.173097548e-016
		,4.294232265e-016
		,4.365954201e-016
		,4.414425946e-016
		,4.452414629e-016
		,4.483664304e-016
		,4.510108701e-016
		,4.532944392e-016
		,4.553009517e-016
		,4.570985450e-016
		,4.587358466e-016
		,4.602128365e-016
		,4.615335268e-016
		,1.747275570e-016
		,1.744786289e-016
		,1.742762207e-016
		,1.741025019e-016
		,1.739499351e-016
		,1.738148285e-016
		,1.736955248e-016
		,1.735917878e-016
		,1.735044447e-016
		,1.734350353e-016
		,1.733854265e-016
		,1.733574241e-016
		,1.733524548e-016
		,1.733714215e-016
		,1.734148834e-016
		,1.734838455e-016
		,1.735818649e-016
		,1.737207196e-016
		,1.739368955e-016
		,1.743414980e-016
		,1.752659073e-016
		,1.776229895e-016
		,1.833878388e-016
		,1.964453838e-016
		,2.247772115e-016
		,2.673693298e-016
		,3.244931230e-016
		,3.914522246e-016
		,4.273167789e-016
		,4.410753135e-016
		,4.466419071e-016
		,4.507870081e-016
		,4.563153014e-016
		,4.592033868e-016
		,4.607862499e-016
		,4.621262755e-016
		,4.633354069e-016
		,4.644388093e-016
		,4.654491016e-016
		,4.663768282e-016
		,4.672324296e-016
		,1.738998370e-016
		,1.737048893e-016
		,1.735309931e-016
		,1.733717783e-016
		,1.732239572e-016
		,1.730859172e-016
		,1.729572336e-016
		,1.728383810e-016
		,1.727304712e-016
		,1.726350069e-016
		,1.725536838e-016
		,1.724882737e-016
		,1.724406096e-016
		,1.724127248e-016
		,1.724073401e-016
		,1.724294588e-016
		,1.724916403e-016
		,1.726312688e-016
		,1.729654128e-016
		,1.738523142e-016
		,1.762770899e-016
		,1.822751473e-016
		,1.945916872e-016
		,2.126278289e-016
		,2.434184771e-016
		,2.870139843e-016
		,3.255002227e-016
		,3.534454731e-016
		,4.050895456e-016
		,4.547388273e-016
		,4.651796903e-016
		,4.651643896e-016
		,4.638048554e-016
		,4.633523670e-016
		,4.647456625e-016
		,4.681776009e-016
		,4.694940154e-016
		,4.700122101e-016
		,4.704661205e-016
		,4.709180887e-016
		,4.713668550e-016
		,1.732183050e-016
		,1.730408806e-016
		,1.728799085e-016
		,1.727297572e-016
		,1.725874219e-016
		,1.724513702e-016
		,1.723210934e-016
		,1.721967979e-016
		,1.720791238e-016
		,1.719689008e-016
		,1.718669825e-016
		,1.717741939e-016
		,1.716914160e-016
		,1.716198651e-016
		,1.715617921e-016
		,1.715224565e-016
		,1.715162679e-016
		,1.715866415e-016
		,1.718689307e-016
		,1.727746925e-016
		,1.753920742e-016
		,1.819783190e-016
		,1.952547893e-016
		,2.133667863e-016
		,2.340083084e-016
		,2.681042713e-016
		,3.160959716e-016
		,3.524979004e-016
		,3.769080182e-016
		,4.197258967e-016
		,4.710817648e-016
		,4.784564650e-016
		,4.747150917e-016
		,4.713678066e-016
		,4.694224310e-016
		,4.685741090e-016
		,4.685093651e-016
		,4.691640557e-016
		,4.718159899e-016
		,4.742853998e-016
		,4.750174011e-016
		,1.724374812e-016
		,1.722562429e-016
		,1.720928384e-016
		,1.719423670e-016
		,1.718019644e-016
		,1.716698823e-016
		,1.715451291e-016
		,1.714272177e-016
		,1.713159368e-016
		,1.712111620e-016
		,1.711127422e-016
		,1.710204870e-016
		,1.709342768e-016
		,1.708543576e-016
		,1.707820992e-016
		,1.707222137e-016
		,1.706898510e-016
		,1.707336684e-016
		,1.710091844e-016
		,1.719901851e-016
		,1.748771651e-016
		,1.821854677e-016
		,1.963445217e-016
		,2.149459093e-016
		,2.377228206e-016
		,2.588367120e-016
		,2.965386570e-016
		,3.450259311e-016
		,3.766559456e-016
		,3.955096142e-016
		,4.236006266e-016
		,4.740423243e-016
		,4.853234753e-016
		,4.826954343e-016
		,4.791103334e-016
		,4.766591490e-016
		,4.752282363e-016
		,4.745262236e-016
		,4.743442760e-016
		,4.744590282e-016
		,4.747949059e-016
		,1.715618110e-016
		,1.713779224e-016
		,1.712043412e-016
		,1.710393477e-016
		,1.708823413e-016
		,1.707334369e-016
		,1.705931338e-016
		,1.704620117e-016
		,1.703404874e-016
		,1.702286708e-016
		,1.701263436e-016
		,1.700330804e-016
		,1.699485834e-016
		,1.698735613e-016
		,1.698123222e-016
		,1.697810950e-016
		,1.698353378e-016
		,1.701562233e-016
		,1.712896071e-016
		,1.746060015e-016
		,1.829158462e-016
		,1.978973221e-016
		,2.175675121e-016
		,2.410231881e-016
		,2.626996575e-016
		,2.785302722e-016
		,3.257040255e-016
		,3.646440294e-016
		,3.913244965e-016
		,4.071558639e-016
		,4.286156892e-016
		,4.664224208e-016
		,4.854328048e-016
		,4.931267793e-016
		,4.948749763e-016
		,5.205075871e-016
		,5.002211021e-016
		,4.913822149e-016
		,4.873560381e-016
		,4.850614094e-016
		,4.836181908e-016
		,1.708991966e-016
		,1.707031376e-016
		,1.705163101e-016
		,1.703370963e-016
		,1.701648436e-016
		,1.699994931e-016
		,1.698412814e-016
		,1.696904907e-016
		,1.695472790e-016
		,1.694116176e-016
		,1.692833422e-016
		,1.691623229e-016
		,1.690488344e-016
		,1.689445118e-016
		,1.688553375e-016
		,1.688015274e-016
		,1.688504919e-016
		,1.692225292e-016
		,1.705569722e-016
		,1.745075718e-016
		,1.841081395e-016
		,1.996098620e-016
		,2.200488351e-016
		,2.434223885e-016
		,2.643343771e-016
		,2.803515357e-016
		,2.989482139e-016
		,3.492131068e-016
		,3.823141386e-016
		,4.049221126e-016
		,4.183834590e-016
		,4.433428235e-016
		,5.424577276e-016
		,5.285952879e-016
		,5.234284509e-016
		,5.120623404e-016
		,5.026337535e-016
		,4.962233153e-016
		,4.919672781e-016
		,4.891244181e-016
		,4.872040981e-016
		,1.705466114e-016
		,1.703248780e-016
		,1.701139380e-016
		,1.699108703e-016
		,1.697143224e-016
		,1.695238362e-016
		,1.693394792e-016
		,1.691615451e-016
		,1.689903101e-016
		,1.688258812e-016
		,1.686681529e-016
		,1.685168783e-016
		,1.683718571e-016
		,1.682333605e-016
		,1.681032853e-016
		,1.679888426e-016
		,1.679149957e-016
		,1.679659365e-016
		,1.684173673e-016
		,1.700361329e-016
		,1.747887464e-016
		,1.854774427e-016
		,2.006646951e-016
		,2.209165047e-016
		,2.433975655e-016
		,2.649637968e-016
		,2.816556389e-016
		,2.920066068e-016
		,3.232767456e-016
		,3.660416713e-016
		,4.154272879e-016
		,4.483765175e-016
		,4.591372025e-016
		,4.835230329e-016
		,5.264126525e-016
		,5.237208980e-016
		,5.129329103e-016
		,5.043232771e-016
		,4.984402115e-016
		,4.944467032e-016
		,4.916744266e-016
		,1.696980305e-016
		,1.694803263e-016
		,1.692682576e-016
		,1.690614663e-016
		,1.688600504e-016
		,1.686642673e-016
		,1.684743054e-016
		,1.682901530e-016
		,1.681115809e-016
		,1.679382337e-016
		,1.677698395e-016
		,1.676066854e-016
		,1.674509697e-016
		,1.673112314e-016
		,1.672175904e-016
		,1.672728479e-016
		,1.678075575e-016
		,1.696726661e-016
		,1.748399253e-016
		,1.852274400e-016
		,1.997577953e-016
		,2.201475193e-016
		,2.424026393e-016
		,2.630499599e-016
		,2.801115860e-016
		,2.924108420e-016
		,2.995015768e-016
		,3.678612821e-016
		,4.048955588e-016
		,4.303101135e-016
		,4.448126760e-016
		,4.631925730e-016
		,4.814216142e-016
		,5.239189290e-016
		,5.309861908e-016
		,5.303496131e-016
		,5.253757576e-016
		,5.146121594e-016
		,5.064020890e-016
		,5.006950404e-016
		,4.967235582e-016
		,1.695360789e-016
		,1.693128435e-016
		,1.690946602e-016
		,1.688812343e-016
		,1.686726652e-016
		,1.684691574e-016
		,1.682708069e-016
		,1.680774916e-016
		,1.678888719e-016
		,1.677044905e-016
		,1.675239729e-016
		,1.673474530e-016
		,1.671767608e-016
		,1.670193181e-016
		,1.669015359e-016
		,1.669143907e-016
		,1.673495083e-016
		,1.689925333e-016
		,1.737313039e-016
		,1.833685142e-016
		,1.974731930e-016
		,2.176196396e-016
		,2.398292560e-016
		,2.605266387e-016
		,2.780751652e-016
		,2.952022663e-016
		,3.077334854e-016
		,3.413958395e-016
		,3.908055326e-016
		,4.248131403e-016
		,4.471175699e-016
		,4.598045168e-016
		,4.726260576e-016
		,5.084544583e-016
		,5.332359438e-016
		,5.354221809e-016
		,5.334553404e-016
		,5.256992281e-016
		,5.152869153e-016
		,5.076047768e-016
		,5.022086133e-016
		,1.696628209e-016
		,1.694330427e-016
		,1.692091062e-016
		,1.689900993e-016
		,1.687758057e-016
		,1.685663467e-016
		,1.683619016e-016
		,1.681625110e-016
		,1.679679884e-016
		,1.677779379e-016
		,1.675918615e-016
		,1.674093528e-016
		,1.672304837e-016
		,1.670568497e-016
		,1.668949842e-016
		,1.667678126e-016
		,1.667533789e-016
		,1.670959498e-016
		,1.684874162e-016
		,1.726608847e-016
		,1.813778827e-016
		,1.952084297e-016
		,2.150828453e-016
		,2.373177297e-016
		,2.604032087e-016
		,2.805523736e-016
		,2.967439171e-016
		,3.079351607e-016
		,3.201749803e-016
		,3.798975130e-016
		,4.135372526e-016
		,4.438974189e-016
		,4.620719182e-016
		,4.717788222e-016
		,4.931791658e-016
		,5.390858993e-016
		,5.365423225e-016
		,5.348488740e-016
		,5.248906447e-016
		,5.152100510e-016
		,5.081511991e-016
		,1.693328352e-016
		,1.691080376e-016
		,1.688881387e-016
		,1.686729925e-016
		,1.684627373e-016
		,1.682575265e-016
		,1.680573500e-016
		,1.678619663e-016
		,1.676709372e-016
		,1.674837431e-016
		,1.672999762e-016
		,1.671197182e-016
		,1.669445579e-016
		,1.667809101e-016
		,1.666510464e-016
		,1.666298184e-016
		,1.669445758e-016
		,1.682549449e-016
		,1.721869057e-016
		,1.803520102e-016
		,1.941404411e-016
		,2.143118526e-016
		,2.372491802e-016
		,2.594803443e-016
		,2.792425012e-016
		,2.959138063e-016
		,3.085508657e-016
		,3.136235818e-016
		,3.629462439e-016
		,4.035570013e-016
		,4.344964480e-016
		,4.539418907e-016
		,4.644316048e-016
		,4.734759841e-016
		,4.885233047e-016
		,5.299389987e-016
		,5.415965786e-016
		,5.384099762e-016
		,5.335688886e-016
		,5.229306495e-016
		,5.142975924e-016
		,1.692391382e-016
		,1.690128084e-016
		,1.687913594e-016
		,1.685747073e-016
		,1.683630018e-016
		,1.681563679e-016
		,1.679547477e-016
		,1.677578504e-016
		,1.675652037e-016
		,1.673762744e-016
		,1.671906617e-016
		,1.670084703e-016
		,1.668313366e-016
		,1.666657678e-016
		,1.665343627e-016
		,1.665126423e-016
		,1.668250091e-016
		,1.681384421e-016
		,1.720394086e-016
		,1.799392643e-016
		,1.937064140e-016
		,2.137334430e-016
		,2.365263493e-016
		,2.586911088e-016
		,2.785428532e-016
		,2.955463745e-016
		,3.089914883e-016
		,3.163668075e-016
		,3.425241738e-016
		,3.953890564e-016
		,4.261708319e-016
		,4.520872485e-016
		,4.665578073e-016
		,4.732146771e-016
		,4.920980373e-016
		,5.424363993e-016
		,5.426430845e-016
		,5.399873681e-016
		,5.381911814e-016
		,5.305928378e-016
		,5.208272462e-016
		,1.691576945e-016
		,1.689295303e-016
		,1.687061978e-016
		,1.684876649e-016
		,1.682740844e-016
		,1.680655500e-016
		,1.678619564e-016
		,1.676629692e-016
		,1.674680889e-016
		,1.672767770e-016
		,1.670886480e-016
		,1.669038434e-016
		,1.667240898e-016
		,1.665561298e-016
		,1.664234117e-016
		,1.664039772e-016
		,1.667247651e-016
		,1.680760647e-016
		,1.720310087e-016
		,1.798259119e-016
		,1.937348602e-016
		,2.137672250e-016
		,2.365404161e-016
		,2.586755810e-016
		,2.785208399e-016
		,2.956187586e-016
		,3.094745657e-016
		,3.181741057e-016
		,3.282046818e-016
		,3.883374942e-016
		,4.175354818e-016
		,4.442300874e-016
		,4.597759374e-016
		,4.678827913e-016
		,4.708681860e-016
		,5.063045755e-016
		,5.387648419e-016
		,5.435650193e-016
		,5.401676580e-016
		,5.373269765e-016
		,5.276235960e-016
		,1.690882004e-016
		,1.688584031e-016
		,1.686333729e-016
		,1.684131158e-016
		,1.681977765e-016
		,1.679874099e-016
		,1.677818602e-016
		,1.675807495e-016
		,1.673835527e-016
		,1.671897278e-016
		,1.669989057e-016
		,1.668112672e-016
		,1.666286389e-016
		,1.664580663e-016
		,1.663239982e-016
		,1.663076897e-016
		,1.666410794e-016
		,1.680428539e-016
		,1.720672624e-016
		,1.798372317e-016
		,1.939413444e-016
		,2.140220514e-016
		,2.367992637e-016
		,2.589154897e-016
		,2.787728689e-016
		,2.959466104e-016
		,3.100777683e-016
		,3.197319501e-016
		,3.205155494e-016
		,3.805049514e-016
		,4.115103347e-016
		,4.377158698e-016
		,4.577239151e-016
		,4.688753135e-016
		,4.731910026e-016
		,5.218911149e-016
		,5.362739860e-016
		,5.425922843e-016
		,5.424455086e-016
		,5.406182768e-016
		,5.344260628e-016
		,1.690264840e-016
		,1.687953831e-016
		,1.685689979e-016
		,1.683473610e-016
		,1.681306000e-016
		,1.679187249e-016
		,1.677115273e-016
		,1.675085862e-016
		,1.673093524e-016
		,1.671132806e-016
		,1.669200167e-016
		,1.667297810e-016
		,1.665444985e-016
		,1.663715563e-016
		,1.662364741e-016
		,1.662235607e-016
		,1.665724386e-016
		,1.680287486e-016
		,1.721084868e-016
		,1.799221014e-016
		,1.942284253e-016
		,2.143894312e-016
		,2.371857488e-016
		,2.592867538e-016
		,2.791490146e-016
		,2.963861954e-016
		,3.107192802e-016
		,3.210218511e-016
		,3.233659000e-016
		,3.642764873e-016
		,4.059596146e-016
		,4.319623723e-016
		,4.533804510e-016
		,4.647851291e-016
		,4.703579253e-016
		,4.862631607e-016
		,5.527445361e-016
		,5.542800448e-016
		,5.516316659e-016
		,5.472437803e-016
		,5.415837169e-016
	};
// --------------------------------------------------    Cgs_FINISH	    --------------------------------------------------	
// --------------------------------------------------    Cgd_START    --------------------------------------------------	
	localparam integer vgd_width_int_Cgd = 41;
    parameter real vgd_points_Cgd[0:vgd_width_int_Cgd-1] =  // Vgd range in volts
	{
		-4.000000000e-001
		,-3.500000000e-001
		,-3.000000000e-001
		,-2.500000000e-001
		,-2.000000000e-001
		,-1.500000000e-001
		,-1.000000000e-001
		,-5.000000000e-002
		,0
		,5.000000000e-002
		,1.000000000e-001
		,1.500000000e-001
		,2.000000000e-001
		,2.500000000e-001
		,3.000000000e-001
		,3.500000000e-001
		,4.000000000e-001
		,4.500000000e-001
		,5.000000000e-001
		,5.500000000e-001
		,6.000000000e-001
		,6.500000000e-001
		,7.000000000e-001
		,7.500000000e-001
		,8.000000000e-001
		,8.500000000e-001
		,9.000000000e-001
		,9.500000000e-001
		,1.000000000e+000
		,1.050000000e+000
		,1.100000000e+000
		,1.150000000e+000
		,1.200000000e+000
		,1.250000000e+000
		,1.300000000e+000
		,1.350000000e+000
		,1.400000000e+000
		,1.450000000e+000
		,1.500000000e+000
		,1.550000000e+000
		,1.600000000e+000
	};

	localparam integer vds_width_int_Cgd = 21;
    parameter real vds_points_Cgd[0:vds_width_int_Cgd-1] =	// Vds range in volts
	{
		-0.4,
		-0.3,
		-0.2,
		-0.1,
		0.0,
		0.1,
		0.2,
		0.3,
		0.4,
		0.5,
		0.6,
		0.7,
		0.8,
		0.9,
		1.0,
		1.1,
		1.2,
		1.3,
		1.4,
		1.5,
		1.6
	};
	localparam integer vgs_width_int_Cgd = 21;
    parameter real vgs_points_Cgd[0:vgs_width_int_Cgd-1] = // Vgs range in volts
	{
		-0.4,
		-0.3,
		-0.2,
		-0.1,
		0.0,
		0.1,
		0.2,
		0.3,
		0.4,
		0.5,
		0.6,
		0.7,
		0.8,
		0.9,
		1.0,
		1.1,
		1.2,
		1.3,
		1.4,
		1.5,
		1.6
	};

	// Sample Cgd data: Each row corresponds to a fixed Vds, columns vary Vgd
    parameter real table_Cgd[0 : vgd_width_int_Cgd*vds_width_int_Cgd*vgs_width_int_Cgd-1] = 
	{
		1.670218852e-016
		,1.670226278e-016
		,1.671497175e-016
		,1.673431108e-016
		,1.675819830e-016
		,1.678663715e-016
		,1.682111398e-016
		,1.686572977e-016
		,1.693210333e-016
		,1.705692046e-016
		,1.736161722e-016
		,1.821469825e-016
		,2.035781500e-016
		,2.406833893e-016
		,2.819271499e-016
		,3.168931303e-016
		,3.436315948e-016
		,3.630734257e-016
		,3.769624004e-016
		,3.870250514e-016
		,3.945456593e-016
		,4.003858314e-016
		,4.051345184e-016
		,4.092520165e-016
		,4.131877567e-016
		,4.174354499e-016
		,4.223991912e-016
		,4.280380294e-016
		,4.337622819e-016
		,4.389243242e-016
		,4.432471664e-016
		,4.467709412e-016
		,4.496495830e-016
		,4.520368882e-016
		,4.540541479e-016
		,4.557901122e-016
		,4.573085154e-016
		,4.586553306e-016
		,4.598641924e-016
		,4.609601521e-016
		,4.619622204e-016
		,1.661355140e-016
		,1.662049999e-016
		,1.663495933e-016
		,1.665306231e-016
		,1.667344504e-016
		,1.669579208e-016
		,1.672028448e-016
		,1.674749216e-016
		,1.677861768e-016
		,1.681645012e-016
		,1.686869888e-016
		,1.695997765e-016
		,1.717447264e-016
		,1.778778440e-016
		,1.947185658e-016
		,2.281603528e-016
		,2.699791751e-016
		,3.074638309e-016
		,3.365638532e-016
		,3.577999459e-016
		,3.729986619e-016
		,3.840032012e-016
		,3.921904683e-016
		,3.984995286e-016
		,4.035801147e-016
		,4.079360015e-016
		,4.120461252e-016
		,4.164245033e-016
		,4.214910081e-016
		,4.272175693e-016
		,4.330214898e-016
		,4.382559862e-016
		,4.426434644e-016
		,4.462244669e-016
		,4.491539077e-016
		,4.515865028e-016
		,4.536442438e-016
		,4.554164088e-016
		,4.569671613e-016
		,4.583428518e-016
		,4.595774633e-016
		,1.653362941e-016
		,1.654473485e-016
		,1.656075710e-016
		,1.657905630e-016
		,1.659871413e-016
		,1.661943924e-016
		,1.664121068e-016
		,1.666415224e-016
		,1.668851944e-016
		,1.671475985e-016
		,1.674371600e-016
		,1.677727879e-016
		,1.682065482e-016
		,1.689064466e-016
		,1.704605616e-016
		,1.748965606e-016
		,1.878708117e-016
		,2.169428183e-016
		,2.580304174e-016
		,2.975020922e-016
		,3.288816264e-016
		,3.519242298e-016
		,3.684733627e-016
		,3.805058263e-016
		,3.894680176e-016
		,3.963453614e-016
		,4.018353495e-016
		,4.064849508e-016
		,4.108064000e-016
		,4.153381217e-016
		,4.205195343e-016
		,4.263389325e-016
		,4.322232638e-016
		,4.375282292e-016
		,4.419769242e-016
		,4.456115451e-016
		,4.485889857e-016
		,4.510654757e-016
		,4.531638996e-016
		,4.549739578e-016
		,4.565599632e-016
		,1.646080716e-016
		,1.647262774e-016
		,1.648876360e-016
		,1.650696065e-016
		,1.652637209e-016
		,1.654665462e-016
		,1.656767291e-016
		,1.658939737e-016
		,1.661187179e-016
		,1.663520744e-016
		,1.665959642e-016
		,1.668535832e-016
		,1.671307898e-016
		,1.674405694e-016
		,1.678186947e-016
		,1.683816923e-016
		,1.695445581e-016
		,1.727914096e-016
		,1.826824101e-016
		,2.072415855e-016
		,2.464418888e-016
		,2.872403104e-016
		,3.207463330e-016
		,3.455959534e-016
		,3.634815126e-016
		,3.765420898e-016
		,3.863335784e-016
		,3.938650203e-016
		,3.998491306e-016
		,4.048615116e-016
		,4.094459077e-016
		,4.141677843e-016
		,4.194894846e-016
		,4.254187225e-016
		,4.313940743e-016
		,4.367745869e-016
		,4.412847395e-016
		,4.449694735e-016
		,4.479890389e-016
		,4.505025781e-016
		,4.526350823e-016
		,1.641063325e-016
		,1.641157259e-016
		,1.642273003e-016
		,1.643821644e-016
		,1.645596529e-016
		,1.647515164e-016
		,1.649538158e-016
		,1.651643752e-016
		,1.653819695e-016
		,1.656060533e-016
		,1.658366641e-016
		,1.660744072e-016
		,1.663205364e-016
		,1.665772503e-016
		,1.668486231e-016
		,1.671436859e-016
		,1.674874014e-016
		,1.679617860e-016
		,1.688628954e-016
		,1.712778258e-016
		,1.787901905e-016
		,1.990822302e-016
		,2.354910160e-016
		,2.768822453e-016
		,3.122768491e-016
		,3.389248438e-016
		,3.581593783e-016
		,3.722044239e-016
		,3.827981487e-016
		,3.910174743e-016
		,3.975655314e-016
		,4.030136095e-016
		,4.079219906e-016
		,4.128808344e-016
		,4.183778305e-016
		,4.244434513e-016
		,4.305302380e-016
		,4.360014170e-016
		,4.405830576e-016
		,4.443231202e-016
		,4.473856695e-016
		,1.649570503e-016
		,1.640450660e-016
		,1.638166956e-016
		,1.638313657e-016
		,1.639393432e-016
		,1.640896939e-016
		,1.642641134e-016
		,1.644550218e-016
		,1.646584910e-016
		,1.648720209e-016
		,1.650938912e-016
		,1.653229885e-016
		,1.655587615e-016
		,1.658012164e-016
		,1.660509580e-016
		,1.663093697e-016
		,1.665792328e-016
		,1.668668702e-016
		,1.671899332e-016
		,1.676069266e-016
		,1.683313500e-016
		,1.701626119e-016
		,1.758758138e-016
		,1.923667361e-016
		,2.253753451e-016
		,2.666042091e-016
		,3.035840605e-016
		,3.319652567e-016
		,3.525947073e-016
		,3.676258529e-016
		,3.789534934e-016
		,3.878160958e-016
		,3.949485376e-016
		,4.008906160e-016
		,4.061864556e-016
		,4.114361621e-016
		,4.171504910e-016
		,4.233851510e-016
		,4.296094334e-016
		,4.351922450e-016
		,4.398619577e-016
		,1.739530625e-016
		,1.674892921e-016
		,1.648230302e-016
		,1.638715814e-016
		,1.636092579e-016
		,1.636008118e-016
		,1.636918223e-016
		,1.638287660e-016
		,1.639928235e-016
		,1.641764344e-016
		,1.643756455e-016
		,1.645877179e-016
		,1.648104859e-016
		,1.650422539e-016
		,1.652818270e-016
		,1.655285524e-016
		,1.657823655e-016
		,1.660439079e-016
		,1.663149422e-016
		,1.665998533e-016
		,1.669112327e-016
		,1.672913058e-016
		,1.678956333e-016
		,1.693153334e-016
		,1.736826895e-016
		,1.869276985e-016
		,2.162188905e-016
		,2.565522307e-016
		,2.947767110e-016
		,3.247694263e-016
		,3.468030945e-016
		,3.628878618e-016
		,3.749330341e-016
		,3.843516561e-016
		,3.920129548e-016
		,3.984608616e-016
		,4.041940824e-016
		,4.097907043e-016
		,4.157705442e-016
		,4.222125576e-016
		,4.286047095e-016
		,2.048885153e-016
		,1.845253721e-016
		,1.736370230e-016
		,1.675458531e-016
		,1.647985977e-016
		,1.637585367e-016
		,1.634467737e-016
		,1.634099263e-016
		,1.634797874e-016
		,1.635987999e-016
		,1.637473929e-016
		,1.639182785e-016
		,1.641078516e-016
		,1.643135055e-016
		,1.645329187e-016
		,1.647639882e-016
		,1.650049422e-016
		,1.652544631e-016
		,1.655117868e-016
		,1.657768165e-016
		,1.660504204e-016
		,1.663354978e-016
		,1.666410233e-016
		,1.669977499e-016
		,1.675200964e-016
		,1.686478991e-016
		,1.720139569e-016
		,1.825703432e-016
		,2.080798650e-016
		,2.468483440e-016
		,2.859425676e-016
		,3.174136728e-016
		,3.407889745e-016
		,3.579853530e-016
		,3.708203538e-016
		,3.807588182e-016
		,3.888476916e-016
		,3.957394145e-016
		,4.019163238e-016
		,4.079036753e-016
		,4.141995908e-016
		,2.561741702e-016
		,2.207190198e-016
		,1.993341995e-016
		,1.838091442e-016
		,1.739436908e-016
		,1.678177998e-016
		,1.648361280e-016
		,1.636852031e-016
		,1.633216390e-016
		,1.632551013e-016
		,1.633023354e-016
		,1.634010292e-016
		,1.635307061e-016
		,1.636844449e-016
		,1.638593251e-016
		,1.640533097e-016
		,1.642643576e-016
		,1.644903146e-016
		,1.647290648e-016
		,1.649787381e-016
		,1.652378955e-016
		,1.655056938e-016
		,1.657821452e-016
		,1.660689073e-016
		,1.663722482e-016
		,1.667146619e-016
		,1.671809865e-016
		,1.681005794e-016
		,1.707230040e-016
		,1.791008776e-016
		,2.009609093e-016
		,2.375956376e-016
		,2.771467958e-016
		,3.099713944e-016
		,3.345982471e-016
		,3.528837983e-016
		,3.666032396e-016
		,3.771272375e-016
		,3.855883600e-016
		,3.928125252e-016
		,3.993675635e-016
		,3.094429596e-016
		,2.680100742e-016
		,2.386094144e-016
		,2.149686695e-016
		,1.975142634e-016
		,1.847522568e-016
		,1.746204374e-016
		,1.681289176e-016
		,1.649128817e-016
		,1.636460980e-016
		,1.632290955e-016
		,1.631329119e-016
		,1.631576854e-016
		,1.632355069e-016
		,1.633445799e-016
		,1.634782425e-016
		,1.636343758e-016
		,1.638118338e-016
		,1.640092998e-016
		,1.642250345e-016
		,1.644569790e-016
		,1.647029922e-016
		,1.649611135e-016
		,1.652298107e-016
		,1.655082683e-016
		,1.657970283e-016
		,1.661002169e-016
		,1.664342219e-016
		,1.668623200e-016
		,1.676326278e-016
		,1.697025036e-016
		,1.763427865e-016
		,1.948214145e-016
		,2.288773709e-016
		,2.684471245e-016
		,3.024850758e-016
		,3.283061195e-016
		,3.475900130e-016
		,3.622205072e-016
		,3.734467346e-016
		,3.823320871e-016
		,3.537795455e-016
		,3.188990788e-016
		,2.808116807e-016
		,2.563172466e-016
		,2.287153884e-016
		,2.133329787e-016
		,1.991031578e-016
		,1.858459919e-016
		,1.753253173e-016
		,1.684833877e-016
		,1.650254481e-016
		,1.636362191e-016
		,1.631644125e-016
		,1.630391822e-016
		,1.630426891e-016
		,1.631005071e-016
		,1.631889871e-016
		,1.633014044e-016
		,1.634363136e-016
		,1.635935412e-016
		,1.637727799e-016
		,1.639731367e-016
		,1.641930934e-016
		,1.644306769e-016
		,1.646837338e-016
		,1.649502421e-016
		,1.652286611e-016
		,1.655185222e-016
		,1.658221710e-016
		,1.661513391e-016
		,1.665533425e-016
		,1.672160818e-016
		,1.688746013e-016
		,1.741441885e-016
		,1.895899141e-016
		,2.207559865e-016
		,2.599017876e-016
		,2.949734452e-016
		,3.219697845e-016
		,3.421678194e-016
		,3.576384698e-016
		,3.907122446e-016
		,3.641586742e-016
		,3.179579668e-016
		,2.951070744e-016
		,2.731245758e-016
		,2.410860990e-016
		,2.292876866e-016
		,2.151167440e-016
		,2.004709521e-016
		,1.869335676e-016
		,1.760697081e-016
		,1.688802693e-016
		,1.651705879e-016
		,1.636517669e-016
		,1.631229581e-016
		,1.629693451e-016
		,1.629532696e-016
		,1.629928711e-016
		,1.630621007e-016
		,1.631537537e-016
		,1.632667490e-016
		,1.634017182e-016
		,1.635593920e-016
		,1.637399637e-016
		,1.639428661e-016
		,1.641667872e-016
		,1.644098543e-016
		,1.646699325e-016
		,1.649450110e-016
		,1.652337898e-016
		,1.655371224e-016
		,1.658630911e-016
		,1.662470012e-016
		,1.668317260e-016
		,1.681830820e-016
		,1.723794165e-016
		,1.851753603e-016
		,2.132747704e-016
		,2.515649083e-016
		,2.874563334e-016
		,3.156036498e-016
		,4.132804957e-016
		,3.969044324e-016
		,3.653433022e-016
		,3.285716322e-016
		,3.097713016e-016
		,2.833888916e-016
		,2.542631406e-016
		,2.449178135e-016
		,2.313326237e-016
		,2.166413586e-016
		,2.018074343e-016
		,1.880544962e-016
		,1.768631700e-016
		,1.693196942e-016
		,1.653458878e-016
		,1.636892170e-016
		,1.631003526e-016
		,1.629189745e-016
		,1.628850553e-016
		,1.629086542e-016
		,1.629607932e-016
		,1.630333996e-016
		,1.631253820e-016
		,1.632378533e-016
		,1.633723718e-016
		,1.635301897e-016
		,1.637118804e-016
		,1.639171757e-016
		,1.641449802e-016
		,1.643935515e-016
		,1.646608386e-016
		,1.649450415e-016
		,1.652458563e-016
		,1.655684904e-016
		,1.659390801e-016
		,1.664665205e-016
		,1.675875094e-016
		,1.709473700e-016
		,1.814769970e-016
		,2.064596809e-016
		,2.434812825e-016
		,4.280422611e-016
		,4.217420317e-016
		,3.992671175e-016
		,3.566362028e-016
		,3.408793241e-016
		,3.233098846e-016
		,2.941874413e-016
		,2.662136432e-016
		,2.576506019e-016
		,2.470258149e-016
		,2.329812039e-016
		,2.180774668e-016
		,2.031423153e-016
		,1.892030721e-016
		,1.777017044e-016
		,1.697983016e-016
		,1.655492488e-016
		,1.637453976e-016
		,1.630932394e-016
		,1.628840814e-016
		,1.628339053e-016
		,1.628437315e-016
		,1.628812750e-016
		,1.629372601e-016
		,1.630102576e-016
		,1.631015041e-016
		,1.632130426e-016
		,1.633469312e-016
		,1.635048012e-016
		,1.636875655e-016
		,1.638952553e-016
		,1.641270156e-016
		,1.643812914e-016
		,1.646562784e-016
		,1.649509800e-016
		,1.652684412e-016
		,1.656277714e-016
		,1.661120193e-016
		,1.670590311e-016
		,1.697684217e-016
		,1.783925706e-016
		,4.422455096e-016
		,4.390523729e-016
		,4.264752685e-016
		,3.975752852e-016
		,3.576342920e-016
		,3.447424305e-016
		,3.325851341e-016
		,3.044501445e-016
		,2.774373998e-016
		,2.707865386e-016
		,2.600461268e-016
		,2.479147123e-016
		,2.345319436e-016
		,2.194944207e-016
		,2.044671036e-016
		,1.903756404e-016
		,1.785723091e-016
		,1.703144792e-016
		,1.657781619e-016
		,1.638184917e-016
		,1.630988427e-016
		,1.628613036e-016
		,1.627961696e-016
		,1.627942463e-016
		,1.628196492e-016
		,1.628616739e-016
		,1.629183092e-016
		,1.629906177e-016
		,1.630807758e-016
		,1.631912878e-016
		,1.633245509e-016
		,1.634825222e-016
		,1.636664435e-016
		,1.638766599e-016
		,1.641126018e-016
		,1.643730335e-016
		,1.646568662e-016
		,1.649657439e-016
		,1.653134978e-016
		,1.657634435e-016
		,1.665774793e-016
		,4.527619603e-016
		,4.524192623e-016
		,4.503160771e-016
		,4.325212220e-016
		,3.888738698e-016
		,3.656043729e-016
		,3.540128609e-016
		,3.388202591e-016
		,3.067170541e-016
		,2.869985821e-016
		,2.825989005e-016
		,2.734046432e-016
		,2.618075262e-016
		,2.486617892e-016
		,2.359562045e-016
		,2.208677670e-016
		,2.057917474e-016
		,1.915487411e-016
		,1.794767849e-016
		,1.708627691e-016
		,1.660333533e-016
		,1.639066816e-016
		,1.631151559e-016
		,1.628480869e-016
		,1.627688360e-016
		,1.627568322e-016
		,1.627722980e-016
		,1.628029206e-016
		,1.628459596e-016
		,1.629021031e-016
		,1.629733838e-016
		,1.630624052e-016
		,1.631719566e-016
		,1.633047128e-016
		,1.634629382e-016
		,1.636482079e-016
		,1.638612124e-016
		,1.641017713e-016
		,1.643693389e-016
		,1.646649829e-016
		,1.649988075e-016
		,4.612825378e-016
		,4.621316842e-016
		,4.621263437e-016
		,4.568561488e-016
		,4.288341936e-016
		,3.888357966e-016
		,3.753027192e-016
		,3.634013304e-016
		,3.478685448e-016
		,3.129416168e-016
		,2.888147881e-016
		,2.900846746e-016
		,2.857148386e-016
		,2.753594062e-016
		,2.632976186e-016
		,2.500431307e-016
		,2.365680591e-016
		,2.222592067e-016
		,2.070785148e-016
		,1.927377029e-016
		,1.804005835e-016
		,1.714485037e-016
		,1.663125577e-016
		,1.640098141e-016
		,1.631405731e-016
		,1.628425955e-016
		,1.627494096e-016
		,1.627287169e-016
		,1.627360807e-016
		,1.627575672e-016
		,1.627896145e-016
		,1.628324275e-016
		,1.628877205e-016
		,1.629579363e-016
		,1.630459146e-016
		,1.631546630e-016
		,1.632871113e-016
		,1.634458291e-016
		,1.636327450e-016
		,1.638489737e-016
		,1.640950147e-016
		,4.688029869e-016
		,4.703081866e-016
		,4.715069462e-016
		,4.716581024e-016
		,4.598990236e-016
		,4.188282287e-016
		,3.958662505e-016
		,3.835003153e-016
		,3.718782076e-016
		,3.573845221e-016
		,3.200787602e-016
		,2.955351160e-016
		,2.948663238e-016
		,2.901002581e-016
		,2.877697512e-016
		,2.769869346e-016
		,2.647922336e-016
		,2.513975014e-016
		,2.372203806e-016
		,2.236205746e-016
		,2.083976451e-016
		,1.939085704e-016
		,1.813598175e-016
		,1.720649252e-016
		,1.666199954e-016
		,1.641279142e-016
		,1.631743664e-016
		,1.628432446e-016
		,1.627361305e-016
		,1.627076630e-016
		,1.627084030e-016
		,1.627226473e-016
		,1.627459822e-016
		,1.627780859e-016
		,1.628202708e-016
		,1.628746631e-016
		,1.629439084e-016
		,1.630310119e-016
		,1.631391758e-016
		,1.632715803e-016
		,1.634311135e-016
		,4.786570868e-016
		,4.815647742e-016
		,4.795297913e-016
		,4.810134178e-016
		,4.811440296e-016
		,4.596128742e-016
		,4.108947982e-016
		,4.023483848e-016
		,3.913424043e-016
		,3.797971489e-016
		,3.657278348e-016
		,3.277171301e-016
		,3.017879390e-016
		,3.024987192e-016
		,2.981382654e-016
		,2.915966956e-016
		,2.868140548e-016
		,2.783835265e-016
		,2.660975952e-016
		,2.526735109e-016
		,2.384151963e-016
		,2.244562552e-016
		,2.097236583e-016
		,1.951426760e-016
		,1.823493960e-016
		,1.727238144e-016
		,1.669546965e-016
		,1.642603749e-016
		,1.632158598e-016
		,1.628490561e-016
		,1.627276243e-016
		,1.626918946e-016
		,1.626871896e-016
		,1.626957127e-016
		,1.627122315e-016
		,1.627358955e-016
		,1.627675947e-016
		,1.628090730e-016
		,1.628626422e-016
		,1.629310749e-016
		,1.630175181e-016
		,4.851124764e-016
		,4.882847541e-016
		,4.917173627e-016
		,4.949749877e-016
		,4.973393480e-016
		,4.868117032e-016
		,4.456527545e-016
		,4.209479418e-016
		,4.084995462e-016
		,3.990352417e-016
		,3.874862684e-016
		,3.737415298e-016
		,3.357298737e-016
		,3.070822395e-016
		,3.092534981e-016
		,3.060864841e-016
		,3.003554186e-016
		,2.928434150e-016
		,2.853056349e-016
		,2.798015504e-016
		,2.672985909e-016
		,2.539212478e-016
		,2.396666359e-016
		,2.251467675e-016
		,2.110735165e-016
		,1.963678878e-016
		,1.833661144e-016
		,1.734183961e-016
		,1.673134420e-016
		,1.644085590e-016
		,1.632648105e-016
		,1.628593465e-016
		,1.627228539e-016
		,1.626801342e-016
		,1.626708244e-016
		,1.626748065e-016
		,1.626860317e-016
		,1.627031332e-016
		,1.627265962e-016
		,1.627577763e-016
		,1.627985991e-016
		,4.884091470e-016
		,4.897907117e-016
		,4.927173197e-016
		,4.960582415e-016
		,4.995197051e-016
		,5.028061803e-016
		,4.943689631e-016
		,4.406533079e-016
		,4.358949939e-016
		,4.149357129e-016
		,4.066861891e-016
		,3.951285031e-016
		,3.816045803e-016
		,3.443570765e-016
		,3.118778720e-016
		,3.154272603e-016
		,3.131816341e-016
		,3.082331588e-016
		,3.017044293e-016
		,2.940588110e-016
		,2.853704271e-016
		,2.792145788e-016
		,2.686277995e-016
		,2.550682324e-016
		,2.409283184e-016
		,2.261582195e-016
		,2.121095976e-016
		,1.975860251e-016
		,1.844235740e-016
		,1.741333581e-016
		,1.677062198e-016
		,1.645720383e-016
		,1.633218619e-016
		,1.628736601e-016
		,1.627210682e-016
		,1.626714486e-016
		,1.626580193e-016
		,1.626584034e-016
		,1.626655221e-016
		,1.626775640e-016
		,1.626946414e-016
		,1.666685023e-016
		,1.668314883e-016
		,1.670318064e-016
		,1.672695985e-016
		,1.675458577e-016
		,1.678681398e-016
		,1.682585631e-016
		,1.687711703e-016
		,1.695554532e-016
		,1.710767856e-016
		,1.748379610e-016
		,1.851451267e-016
		,2.094888883e-016
		,2.482614001e-016
		,2.887051836e-016
		,3.221048023e-016
		,3.474905687e-016
		,3.659252729e-016
		,3.790989305e-016
		,3.886649783e-016
		,3.958429078e-016
		,4.014439594e-016
		,4.060219161e-016
		,4.100137880e-016
		,4.138539783e-016
		,4.180263742e-016
		,4.229280058e-016
		,4.285126031e-016
		,4.341877808e-016
		,4.393056558e-016
		,4.435894499e-016
		,4.470790286e-016
		,4.499277684e-016
		,4.522888868e-016
		,4.542831698e-016
		,4.559989392e-016
		,4.574995640e-016
		,4.588307015e-016
		,4.600257122e-016
		,4.611094088e-016
		,4.621005947e-016
		,1.659124291e-016
		,1.660764608e-016
		,1.662640564e-016
		,1.664718434e-016
		,1.666964238e-016
		,1.669385229e-016
		,1.672022519e-016
		,1.674956179e-016
		,1.678341280e-016
		,1.682530925e-016
		,1.688496933e-016
		,1.699321942e-016
		,1.725389549e-016
		,1.799435710e-016
		,1.993754730e-016
		,2.351555760e-016
		,2.769328577e-016
		,3.131000992e-016
		,3.408764582e-016
		,3.610739054e-016
		,3.754899106e-016
		,3.859151750e-016
		,3.936848507e-016
		,3.996978332e-016
		,4.045686831e-016
		,4.087744551e-016
		,4.127753255e-016
		,4.170722161e-016
		,4.220750570e-016
		,4.277479707e-016
		,4.335038277e-016
		,4.386947320e-016
		,4.430429439e-016
		,4.465885919e-016
		,4.494860570e-016
		,4.518896374e-016
		,4.539210459e-016
		,4.556693652e-016
		,4.571985942e-016
		,4.585549221e-016
		,4.597721643e-016
		,1.651948102e-016
		,1.653644278e-016
		,1.655527172e-016
		,1.657537186e-016
		,1.659638318e-016
		,1.661824498e-016
		,1.664105746e-016
		,1.666503528e-016
		,1.669052443e-016
		,1.671809120e-016
		,1.674878266e-016
		,1.678494640e-016
		,1.683305189e-016
		,1.691390502e-016
		,1.709960584e-016
		,1.763249781e-016
		,1.914321530e-016
		,2.231331467e-016
		,2.649086132e-016
		,3.033980139e-016
		,3.335241571e-016
		,3.555411901e-016
		,3.713038195e-016
		,3.827168642e-016
		,3.911977131e-016
		,3.977155082e-016
		,4.029443723e-016
		,4.074063205e-016
		,4.115929411e-016
		,4.160271309e-016
		,4.211361021e-016
		,4.268982687e-016
		,4.327344911e-016
		,4.379981805e-016
		,4.424112484e-016
		,4.460144653e-016
		,4.489633571e-016
		,4.514132025e-016
		,4.534863858e-016
		,4.552724385e-016
		,4.568356935e-016
		,1.645137930e-016
		,1.646726146e-016
		,1.648556871e-016
		,1.650522271e-016
		,1.652572371e-016
		,1.654687928e-016
		,1.656863740e-016
		,1.659102649e-016
		,1.661413775e-016
		,1.663812772e-016
		,1.666324028e-016
		,1.668986783e-016
		,1.671872545e-016
		,1.675140390e-016
		,1.679229741e-016
		,1.685569463e-016
		,1.699213152e-016
		,1.737916744e-016
		,1.853587885e-016
		,2.125401509e-016
		,2.530472674e-016
		,2.932598307e-016
		,3.256210212e-016
		,3.494558147e-016
		,3.665780137e-016
		,3.790373575e-016
		,3.883253991e-016
		,3.954469677e-016
		,4.011156826e-016
		,4.058945264e-016
		,4.103090613e-016
		,4.149079302e-016
		,4.201392264e-016
		,4.259989432e-016
		,4.319183916e-016
		,4.372538020e-016
		,4.417280433e-016
		,4.453839588e-016
		,4.483795369e-016
		,4.508719913e-016
		,4.529848948e-016
		,1.640272955e-016
		,1.640706700e-016
		,1.642036893e-016
		,1.643741108e-016
		,1.645636342e-016
		,1.647650563e-016
		,1.649750605e-016
		,1.651919406e-016
		,1.654148704e-016
		,1.656436588e-016
		,1.658786712e-016
		,1.661208387e-016
		,1.663717818e-016
		,1.666341976e-016
		,1.669130215e-016
		,1.672192122e-016
		,1.675831411e-016
		,1.681044966e-016
		,1.691413436e-016
		,1.719920711e-016
		,1.807850570e-016
		,2.034992006e-016
		,2.416767748e-016
		,2.829076490e-016
		,3.173128856e-016
		,3.429624562e-016
		,3.614299586e-016
		,3.749121162e-016
		,3.850358203e-016
		,3.928348787e-016
		,3.990267908e-016
		,4.041944960e-016
		,4.088923973e-016
		,4.136965073e-016
		,4.190790741e-016
		,4.250568153e-016
		,4.310734991e-016
		,4.364889043e-016
		,4.410272945e-016
		,4.447343897e-016
		,4.477718005e-016
		,1.648937678e-016
		,1.639833031e-016
		,1.637805200e-016
		,1.638153478e-016
		,1.639393324e-016
		,1.641028448e-016
		,1.642881775e-016
		,1.644880895e-016
		,1.646988910e-016
		,1.649183371e-016
		,1.651449905e-016
		,1.653780330e-016
		,1.656172099e-016
		,1.658628226e-016
		,1.661157902e-016
		,1.663778836e-016
		,1.666524990e-016
		,1.669472756e-016
		,1.672835252e-016
		,1.677318035e-016
		,1.685486313e-016
		,1.706858273e-016
		,1.773614332e-016
		,1.959739094e-016
		,2.310413133e-016
		,2.725364998e-016
		,3.087137762e-016
		,3.361500958e-016
		,3.559891199e-016
		,3.704557941e-016
		,3.813657721e-016
		,3.898514667e-016
		,3.966248200e-016
		,4.022525976e-016
		,4.072970118e-016
		,4.123559786e-016
		,4.179273880e-016
		,4.240519822e-016
		,4.301885336e-016
		,4.357013964e-016
		,4.403165218e-016
		,1.749309029e-016
		,1.674723411e-016
		,1.647404515e-016
		,1.638224944e-016
		,1.635858189e-016
		,1.635971223e-016
		,1.637034213e-016
		,1.638534288e-016
		,1.640288110e-016
		,1.642220815e-016
		,1.644293074e-016
		,1.646478371e-016
		,1.648756791e-016
		,1.651113794e-016
		,1.653540220e-016
		,1.656032491e-016
		,1.658593025e-016
		,1.661231689e-016
		,1.663970932e-016
		,1.666864032e-016
		,1.670062285e-016
		,1.674071502e-016
		,1.680749233e-016
		,1.697107014e-016
		,1.747948964e-016
		,1.898289174e-016
		,2.213067408e-016
		,2.623116033e-016
		,2.999359682e-016
		,3.290673634e-016
		,3.503172766e-016
		,3.657944489e-016
		,3.774290852e-016
		,3.865346701e-016
		,3.938863856e-016
		,4.000216666e-016
		,4.054743970e-016
		,4.108438964e-016
		,4.166484748e-016
		,4.229544885e-016
		,4.292384615e-016
		,2.138648657e-016
		,1.867076015e-016
		,1.737227245e-016
		,1.674271763e-016
		,1.646960445e-016
		,1.637116419e-016
		,1.634300197e-016
		,1.634119897e-016
		,1.634966901e-016
		,1.636288072e-016
		,1.637892747e-016
		,1.639707317e-016
		,1.641694046e-016
		,1.643825853e-016
		,1.646079705e-016
		,1.648435932e-016
		,1.650879055e-016
		,1.653398680e-016
		,1.655990235e-016
		,1.658656106e-016
		,1.661409167e-016
		,1.664285627e-016
		,1.667393386e-016
		,1.671098928e-016
		,1.676760894e-016
		,1.689575367e-016
		,1.728554553e-016
		,1.848795386e-016
		,2.125679124e-016
		,2.523691512e-016
		,2.910827248e-016
		,3.217757807e-016
		,3.444189084e-016
		,3.609799690e-016
		,3.733532857e-016
		,3.829973067e-016
		,3.908494483e-016
		,3.974815776e-016
		,4.033824336e-016
		,4.091170547e-016
		,4.152046804e-016
		,2.718349333e-016
		,2.321930361e-016
		,2.024655691e-016
		,1.843916111e-016
		,1.736546218e-016
		,1.675882373e-016
		,1.647321417e-016
		,1.636416551e-016
		,1.633077720e-016
		,1.632591767e-016
		,1.633204556e-016
		,1.634318872e-016
		,1.635735972e-016
		,1.637385803e-016
		,1.639236291e-016
		,1.641264276e-016
		,1.643447613e-016
		,1.645764427e-016
		,1.648194576e-016
		,1.650721441e-016
		,1.653333415e-016
		,1.656025323e-016
		,1.658801195e-016
		,1.661683559e-016
		,1.664748630e-016
		,1.668263781e-016
		,1.673231595e-016
		,1.683527451e-016
		,1.713695417e-016
		,1.809278900e-016
		,2.048575842e-016
		,2.428235561e-016
		,2.822327630e-016
		,3.143549347e-016
		,3.383105390e-016
		,3.559890877e-016
		,3.691907354e-016
		,3.793699671e-016
		,3.876250539e-016
		,3.946692169e-016
		,4.010029825e-016
		,3.220803553e-016
		,2.874009050e-016
		,2.491516510e-016
		,2.187150684e-016
		,1.986330610e-016
		,1.840151553e-016
		,1.741957197e-016
		,1.678992024e-016
		,1.648075331e-016
		,1.636032678e-016
		,1.632159446e-016
		,1.631367165e-016
		,1.631743857e-016
		,1.632640608e-016
		,1.633847656e-016
		,1.635298403e-016
		,1.636968653e-016
		,1.638843123e-016
		,1.640905194e-016
		,1.643135151e-016
		,1.645511569e-016
		,1.648013688e-016
		,1.650623793e-016
		,1.653329360e-016
		,1.656125845e-016
		,1.659023860e-016
		,1.662075248e-016
		,1.665475170e-016
		,1.669968728e-016
		,1.678464467e-016
		,1.702091755e-016
		,1.777856667e-016
		,1.981578339e-016
		,2.337700973e-016
		,2.734470790e-016
		,3.068686129e-016
		,3.320526226e-016
		,3.507961277e-016
		,3.649047925e-016
		,3.757111182e-016
		,3.843469219e-016
		,3.612795219e-016
		,3.372740908e-016
		,3.020849205e-016
		,2.603495563e-016
		,2.365731895e-016
		,2.129871411e-016
		,1.981322267e-016
		,1.851988993e-016
		,1.748999090e-016
		,1.682457833e-016
		,1.649161580e-016
		,1.635925217e-016
		,1.631505728e-016
		,1.630413572e-016
		,1.630564326e-016
		,1.631248532e-016
		,1.632240495e-016
		,1.633474606e-016
		,1.634934300e-016
		,1.636614037e-016
		,1.638506422e-016
		,1.640598574e-016
		,1.642872445e-016
		,1.645306951e-016
		,1.647880812e-016
		,1.650575495e-016
		,1.653378516e-016
		,1.656289676e-016
		,1.659341016e-016
		,1.662673526e-016
		,1.666843376e-016
		,1.674046002e-016
		,1.692812015e-016
		,1.752861151e-016
		,1.924127311e-016
		,2.252834061e-016
		,2.647835812e-016
		,2.993484701e-016
		,3.257188495e-016
		,3.454294548e-016
		,3.604365079e-016
		,3.887336999e-016
		,3.755877789e-016
		,3.461010996e-016
		,3.052092254e-016
		,2.778963305e-016
		,2.526136637e-016
		,2.271482310e-016
		,2.139940078e-016
		,1.996560079e-016
		,1.863021302e-016
		,1.756334585e-016
		,1.686307655e-016
		,1.650550466e-016
		,1.636055709e-016
		,1.631075119e-016
		,1.629691781e-016
		,1.629633654e-016
		,1.630121609e-016
		,1.630908461e-016
		,1.631925713e-016
		,1.633161918e-016
		,1.634620588e-016
		,1.636304946e-016
		,1.638212304e-016
		,1.640332618e-016
		,1.642649381e-016
		,1.645141993e-016
		,1.647788952e-016
		,1.650571702e-016
		,1.653480656e-016
		,1.656531273e-016
		,1.659822662e-016
		,1.663770109e-016
		,1.670038622e-016
		,1.685182584e-016
		,1.732884885e-016
		,1.875404332e-016
		,2.174175888e-016
		,2.562996918e-016
		,2.918113618e-016
		,3.193514317e-016
		,4.086392247e-016
		,4.014689397e-016
		,3.832953952e-016
		,3.532793866e-016
		,3.124013580e-016
		,2.920736749e-016
		,2.648454958e-016
		,2.423968325e-016
		,2.299974647e-016
		,2.156903015e-016
		,2.010099153e-016
		,1.874025024e-016
		,1.764030700e-016
		,1.690531617e-016
		,1.652219916e-016
		,1.636393277e-016
		,1.630827965e-016
		,1.629161747e-016
		,1.628913975e-016
		,1.629227989e-016
		,1.629829921e-016
		,1.630644225e-016
		,1.631660960e-016
		,1.632889941e-016
		,1.634343807e-016
		,1.636030929e-016
		,1.637952230e-016
		,1.640100290e-016
		,1.642460274e-016
		,1.645012374e-016
		,1.647735572e-016
		,1.650613548e-016
		,1.653648323e-016
		,1.656906053e-016
		,1.660695289e-016
		,1.666282899e-016
		,1.678718228e-016
		,1.716779304e-016
		,1.834439755e-016
		,2.102082763e-016
		,2.480461694e-016
		,4.218783486e-016
		,4.177226675e-016
		,4.133857002e-016
		,3.911240183e-016
		,3.494211082e-016
		,3.259164030e-016
		,3.067955542e-016
		,2.743472234e-016
		,2.552309366e-016
		,2.457012612e-016
		,2.319070296e-016
		,2.171708976e-016
		,2.023283465e-016
		,1.885240591e-016
		,1.772117305e-016
		,1.695137047e-016
		,1.654151972e-016
		,1.636911646e-016
		,1.630730792e-016
		,1.628786750e-016
		,1.628367122e-016
		,1.628531077e-016
		,1.628973279e-016
		,1.629607601e-016
		,1.630422039e-016
		,1.631429126e-016
		,1.632647884e-016
		,1.634096036e-016
		,1.635785781e-016
		,1.637721310e-016
		,1.639897881e-016
		,1.642302608e-016
		,1.644917098e-016
		,1.647722647e-016
		,1.650711959e-016
		,1.653925748e-016
		,1.657590903e-016
		,1.662672818e-016
		,1.673071286e-016
		,1.703630020e-016
		,1.800205326e-016
		,4.348905326e-016
		,4.330644598e-016
		,4.293021329e-016
		,4.154664418e-016
		,3.897434513e-016
		,3.451904243e-016
		,3.385202624e-016
		,3.205565133e-016
		,2.839981260e-016
		,2.677799398e-016
		,2.584376070e-016
		,2.472076917e-016
		,2.335134029e-016
		,2.185767974e-016
		,2.036353530e-016
		,1.896602816e-016
		,1.780576603e-016
		,1.700091380e-016
		,1.656334579e-016
		,1.637589177e-016
		,1.630759022e-016
		,1.628534177e-016
		,1.627958348e-016
		,1.627994449e-016
		,1.628302854e-016
		,1.628784121e-016
		,1.629421350e-016
		,1.630226487e-016
		,1.631221321e-016
		,1.632429613e-016
		,1.633872660e-016
		,1.635566010e-016
		,1.637517070e-016
		,1.639723971e-016
		,1.642176284e-016
		,1.644858527e-016
		,1.647759650e-016
		,1.650902459e-016
		,1.654451818e-016
		,1.659143439e-016
		,1.667995948e-016
		,4.452817704e-016
		,4.449807345e-016
		,4.436309035e-016
		,4.401575268e-016
		,4.204917654e-016
		,3.798780873e-016
		,3.548749010e-016
		,3.420624064e-016
		,3.276474294e-016
		,2.932887377e-016
		,2.793549300e-016
		,2.717272069e-016
		,2.606656765e-016
		,2.480246243e-016
		,2.350228967e-016
		,2.199483537e-016
		,2.049211792e-016
		,1.908142869e-016
		,1.789333020e-016
		,1.705390265e-016
		,1.658760240e-016
		,1.638417450e-016
		,1.630892041e-016
		,1.628378876e-016
		,1.627657818e-016
		,1.627584989e-016
		,1.627783539e-016
		,1.628138669e-016
		,1.628626759e-016
		,1.629256726e-016
		,1.630049971e-016
		,1.631032646e-016
		,1.632231582e-016
		,1.633671069e-016
		,1.635369859e-016
		,1.637338663e-016
		,1.639578863e-016
		,1.642083684e-016
		,1.644844766e-016
		,1.647875210e-016
		,1.651294604e-016
		,4.540468356e-016
		,4.546104714e-016
		,4.547174986e-016
		,4.536659212e-016
		,4.457698898e-016
		,4.210350032e-016
		,3.762243375e-016
		,3.639470592e-016
		,3.513357531e-016
		,3.358685373e-016
		,2.936153142e-016
		,2.879209060e-016
		,2.837140389e-016
		,2.741179482e-016
		,2.623640506e-016
		,2.491556675e-016
		,2.360775226e-016
		,2.213127270e-016
		,2.062280277e-016
		,1.919872082e-016
		,1.798461065e-016
		,1.711038237e-016
		,1.661441841e-016
		,1.639384310e-016
		,1.631116531e-016
		,1.628301264e-016
		,1.627440649e-016
		,1.627274490e-016
		,1.627383632e-016
		,1.627637119e-016
		,1.628003468e-016
		,1.628487140e-016
		,1.629106958e-016
		,1.629888440e-016
		,1.630860282e-016
		,1.632051742e-016
		,1.633489900e-016
		,1.635196720e-016
		,1.637186469e-016
		,1.639464699e-016
		,1.642031602e-016
		,4.627393559e-016
		,4.634383781e-016
		,4.642529124e-016
		,4.643804283e-016
		,4.634080377e-016
		,4.487157746e-016
		,4.107225391e-016
		,3.830821920e-016
		,3.723690774e-016
		,3.599364086e-016
		,3.450136921e-016
		,2.990689283e-016
		,2.911442203e-016
		,2.898493948e-016
		,2.864817714e-016
		,2.759543612e-016
		,2.638405770e-016
		,2.505354216e-016
		,2.366829424e-016
		,2.227152365e-016
		,2.075332896e-016
		,1.931757480e-016
		,1.807834715e-016
		,1.717051842e-016
		,1.664357598e-016
		,1.640497020e-016
		,1.631419503e-016
		,1.628287168e-016
		,1.627287631e-016
		,1.627039912e-016
		,1.627076218e-016
		,1.627248913e-016
		,1.627518103e-016
		,1.627883099e-016
		,1.628358960e-016
		,1.628968567e-016
		,1.629739578e-016
		,1.630702552e-016
		,1.631888952e-016
		,1.633328610e-016
		,1.635046868e-016
		,4.727585785e-016
		,4.734003260e-016
		,4.761018372e-016
		,4.768032073e-016
		,4.746769508e-016
		,4.732337087e-016
		,4.489918335e-016
		,4.024461571e-016
		,3.892228245e-016
		,3.803481931e-016
		,3.680457166e-016
		,3.536059724e-016
		,3.046212186e-016
		,2.980190541e-016
		,2.960744536e-016
		,2.904321761e-016
		,2.874617518e-016
		,2.775564478e-016
		,2.653024867e-016
		,2.518443402e-016
		,2.375802754e-016
		,2.238515887e-016
		,2.088549491e-016
		,1.943630458e-016
		,1.817555774e-016
		,1.723331819e-016
		,1.667566223e-016
		,1.641743136e-016
		,1.631801015e-016
		,1.628324438e-016
		,1.627184965e-016
		,1.626862609e-016
		,1.626839319e-016
		,1.626948217e-016
		,1.627141052e-016
		,1.627411847e-016
		,1.627771453e-016
		,1.628239105e-016
		,1.628839587e-016
		,1.629601975e-016
		,1.630558462e-016
		,4.787406208e-016
		,4.784550901e-016
		,4.809258996e-016
		,4.835523197e-016
		,4.862080133e-016
		,4.883675546e-016
		,4.820137203e-016
		,4.398443952e-016
		,4.112372677e-016
		,3.971666057e-016
		,3.880990737e-016
		,3.758549192e-016
		,3.618037281e-016
		,3.103872241e-016
		,3.042452277e-016
		,3.034473008e-016
		,2.987770771e-016
		,2.920100656e-016
		,2.860714681e-016
		,2.789722543e-016
		,2.665803810e-016
		,2.531871566e-016
		,2.388047933e-016
		,2.246063414e-016
		,2.101859153e-016
		,1.955992151e-016
		,1.827370395e-016
		,1.730120357e-016
		,1.671006263e-016
		,1.643148616e-016
		,1.632251063e-016
		,1.628407526e-016
		,1.627121384e-016
		,1.626728439e-016
		,1.626655586e-016
		,1.626714004e-016
		,1.626847409e-016
		,1.627044581e-016
		,1.627312214e-016
		,1.627665621e-016
		,1.628125848e-016
		,4.838315622e-016
		,4.847033148e-016
		,4.859114067e-016
		,4.886218064e-016
		,4.917304404e-016
		,4.948772953e-016
		,4.969112094e-016
		,4.846037640e-016
		,4.322639317e-016
		,4.237267830e-016
		,4.076597043e-016
		,3.963863513e-016
		,3.836141222e-016
		,3.697855665e-016
		,3.165086117e-016
		,3.099740205e-016
		,3.102434955e-016
		,3.064306058e-016
		,3.004824631e-016
		,2.931514109e-016
		,2.847039948e-016
		,2.799520850e-016
		,2.678126912e-016
		,2.543421581e-016
		,2.401142061e-016
		,2.253092208e-016
		,2.115518283e-016
		,1.967896204e-016
		,1.837876880e-016
		,1.737113186e-016
		,1.674760269e-016
		,1.644693280e-016
		,1.632780469e-016
		,1.628529391e-016
		,1.627089125e-016
		,1.626627165e-016
		,1.626511263e-016
		,1.626529661e-016
		,1.626616977e-016
		,1.626757197e-016
		,1.626953147e-016
		,1.665592504e-016
		,1.667758605e-016
		,1.670145740e-016
		,1.672819607e-016
		,1.675861093e-016
		,1.679422635e-016
		,1.683807082e-016
		,1.689723199e-016
		,1.699117310e-016
		,1.717960607e-016
		,1.764913457e-016
		,1.889562258e-016
		,2.163089992e-016
		,2.561930433e-016
		,2.953788714e-016
		,3.270670597e-016
		,3.510837779e-016
		,3.685456659e-016
		,3.810567005e-016
		,3.901755953e-016
		,3.970476063e-016
		,4.024334312e-016
		,4.068545156e-016
		,4.107277820e-016
		,4.144753025e-016
		,4.185731863e-016
		,4.234128688e-016
		,4.289437353e-016
		,4.345711101e-016
		,4.396468065e-016
		,4.438940562e-016
		,4.473522493e-016
		,4.501740312e-016
		,4.525119052e-016
		,4.544860511e-016
		,4.561842946e-016
		,4.576695995e-016
		,4.589872903e-016
		,4.601704513e-016
		,4.612436647e-016
		,4.622255408e-016
		,1.658449975e-016
		,1.660439337e-016
		,1.662546037e-016
		,1.664771788e-016
		,1.667142334e-016
		,1.669694970e-016
		,1.672489117e-016
		,1.675627180e-016
		,1.679305416e-016
		,1.683972983e-016
		,1.690868471e-016
		,1.703893432e-016
		,1.735933369e-016
		,1.825689594e-016
		,2.048586609e-016
		,2.426726738e-016
		,2.839445318e-016
		,3.185967007e-016
		,3.449902672e-016
		,3.641352927e-016
		,3.777884798e-016
		,3.876753328e-016
		,3.950701743e-016
		,4.008215254e-016
		,4.055067845e-016
		,4.095775969e-016
		,4.134773720e-016
		,4.176958507e-016
		,4.226347908e-016
		,4.282521081e-016
		,4.339574646e-016
		,4.391025991e-016
		,4.434100409e-016
		,4.469197003e-016
		,4.497854404e-016
		,4.521610255e-016
		,4.541677061e-016
		,4.558941715e-016
		,4.574040790e-016
		,4.587433153e-016
		,4.599454254e-016
		,1.651602080e-016
		,1.653557005e-016
		,1.655585193e-016
		,1.657685061e-016
		,1.659856529e-016
		,1.662109349e-016
		,1.664460948e-016
		,1.666939286e-016
		,1.669587193e-016
		,1.672474243e-016
		,1.675729985e-016
		,1.679647633e-016
		,1.685038559e-016
		,1.694502894e-016
		,1.716938221e-016
		,1.781304755e-016
		,1.956753799e-016
		,2.299186942e-016
		,2.719677539e-016
		,3.092433571e-016
		,3.380428738e-016
		,3.590009701e-016
		,3.739560777e-016
		,3.847584225e-016
		,3.927900570e-016
		,3.989855913e-016
		,4.039853113e-016
		,4.082836571e-016
		,4.123521693e-016
		,4.166995002e-016
		,4.217419036e-016
		,4.274490495e-016
		,4.332366687e-016
		,4.384566669e-016
		,4.428305426e-016
		,4.463984197e-016
		,4.493151289e-016
		,4.517354625e-016
		,4.537815361e-016
		,4.555427422e-016
		,4.570833239e-016
		,1.645000116e-016
		,1.646802398e-016
		,1.648750479e-016
		,1.650790912e-016
		,1.652897330e-016
		,1.655060066e-016
		,1.657278682e-016
		,1.659559681e-016
		,1.661915661e-016
		,1.664366212e-016
		,1.666940966e-016
		,1.669687443e-016
		,1.672692924e-016
		,1.676153465e-016
		,1.680613158e-016
		,1.687837853e-016
		,1.704020081e-016
		,1.750445000e-016
		,1.885666993e-016
		,2.184384677e-016
		,2.599231922e-016
		,2.992980957e-016
		,3.304241952e-016
		,3.532204121e-016
		,3.695491048e-016
		,3.813781139e-016
		,3.901636069e-016
		,3.969009469e-016
		,4.022867470e-016
		,4.068610464e-016
		,4.111284529e-016
		,4.156211785e-016
		,4.207742028e-016
		,4.265728493e-016
		,4.324418286e-016
		,4.377348492e-016
		,4.421733951e-016
		,4.457985797e-016
		,4.487666672e-016
		,4.512335918e-016
		,4.533221782e-016
		,1.640142665e-016
		,1.640795646e-016
		,1.642262114e-016
		,1.644064572e-016
		,1.646035128e-016
		,1.648108321e-016
		,1.650255125e-016
		,1.652461873e-016
		,1.654723387e-016
		,1.657040664e-016
		,1.659420238e-016
		,1.661874522e-016
		,1.664423567e-016
		,1.667100032e-016
		,1.669963702e-016
		,1.673148259e-016
		,1.677025758e-016
		,1.682816118e-016
		,1.694874921e-016
		,1.728755308e-016
		,1.831796348e-016
		,2.084754704e-016
		,2.481938961e-016
		,2.890096511e-016
		,3.223134587e-016
		,3.469383197e-016
		,3.646331447e-016
		,3.775180202e-016
		,3.871362311e-016
		,3.945107774e-016
		,4.003674643e-016
		,4.052832441e-016
		,4.097966341e-016
		,4.144667596e-016
		,4.197508158e-016
		,4.256529325e-016
		,4.316090501e-016
		,4.369759579e-016
		,4.414762751e-016
		,4.451535436e-016
		,4.481669634e-016
		,1.649061469e-016
		,1.639808327e-016
		,1.637878421e-016
		,1.638376640e-016
		,1.639740070e-016
		,1.641474153e-016
		,1.643407475e-016
		,1.645470184e-016
		,1.647627734e-016
		,1.649860224e-016
		,1.652156043e-016
		,1.654509864e-016
		,1.656921989e-016
		,1.659398346e-016
		,1.661951369e-016
		,1.664603062e-016
		,1.667394643e-016
		,1.670418674e-016
		,1.673933894e-016
		,1.678796196e-016
		,1.688103805e-016
		,1.713227315e-016
		,1.791408897e-016
		,2.000748851e-016
		,2.370748609e-016
		,2.785917455e-016
		,3.138437859e-016
		,3.402866366e-016
		,3.593408472e-016
		,3.732419552e-016
		,3.836937177e-016
		,3.917626163e-016
		,3.981694388e-016
		,4.035004580e-016
		,4.083186537e-016
		,4.132101598e-016
		,4.186574083e-016
		,4.246865971e-016
		,4.307470259e-016
		,4.361992764e-016
		,4.407673645e-016
		,1.766827323e-016
		,1.677204522e-016
		,1.647231974e-016
		,1.638108053e-016
		,1.635965334e-016
		,1.636240175e-016
		,1.637433075e-016
		,1.639041171e-016
		,1.640885502e-016
		,1.642892432e-016
		,1.645023413e-016
		,1.647253351e-016
		,1.649564487e-016
		,1.651944929e-016
		,1.654388395e-016
		,1.656894265e-016
		,1.659468056e-016
		,1.662123273e-016
		,1.664887810e-016
		,1.667826219e-016
		,1.671120954e-016
		,1.675380907e-016
		,1.682834613e-016
		,1.701827189e-016
		,1.761201535e-016
		,1.931486447e-016
		,2.267773682e-016
		,2.682298561e-016
		,3.051282821e-016
		,3.333366013e-016
		,3.537857566e-016
		,3.686794371e-016
		,3.799002839e-016
		,3.886461770e-016
		,3.956456478e-016
		,4.014590173e-016
		,4.066464172e-016
		,4.118114788e-016
		,4.174619138e-016
		,4.236490703e-016
		,4.298383340e-016
		,2.285642834e-016
		,1.913324821e-016
		,1.743027999e-016
		,1.673817927e-016
		,1.646428624e-016
		,1.636952393e-016
		,1.634397335e-016
		,1.634390740e-016
		,1.635370449e-016
		,1.636805920e-016
		,1.638511389e-016
		,1.640412767e-016
		,1.642471285e-016
		,1.644659626e-016
		,1.646955649e-016
		,1.649341582e-016
		,1.651804519e-016
		,1.654336990e-016
		,1.656937538e-016
		,1.659611971e-016
		,1.662377667e-016
		,1.665279147e-016
		,1.668446186e-016
		,1.672317181e-016
		,1.678512140e-016
		,1.693190054e-016
		,1.738502380e-016
		,1.875325461e-016
		,2.174361027e-016
		,2.580779740e-016
		,2.962787239e-016
		,3.261378677e-016
		,3.480055675e-016
		,3.639394541e-016
		,3.758848832e-016
		,3.852255731e-016
		,3.927890163e-016
		,3.991173756e-016
		,4.047319616e-016
		,4.102273541e-016
		,4.161275057e-016
		,2.926558582e-016
		,2.506061630e-016
		,2.080592644e-016
		,1.857498724e-016
		,1.736235015e-016
		,1.674469136e-016
		,1.646505522e-016
		,1.636209231e-016
		,1.633153267e-016
		,1.632834912e-016
		,1.633577330e-016
		,1.634807529e-016
		,1.636331976e-016
		,1.638079692e-016
		,1.640016011e-016
		,1.642115649e-016
		,1.644355530e-016
		,1.646714217e-016
		,1.649173203e-016
		,1.651718338e-016
		,1.654340996e-016
		,1.657039347e-016
		,1.659821499e-016
		,1.662716572e-016
		,1.665816708e-016
		,1.669440417e-016
		,1.674776719e-016
		,1.686400038e-016
		,1.721259417e-016
		,1.830306963e-016
		,2.091176148e-016
		,2.482630998e-016
		,2.873904121e-016
		,3.187609259e-016
		,3.420023500e-016
		,3.590444826e-016
		,3.717585410e-016
		,3.816294056e-016
		,3.896624624e-016
		,3.964703616e-016
		,4.025380830e-016
		,3.440372277e-016
		,3.061829525e-016
		,2.633194726e-016
		,2.274424370e-016
		,2.005288196e-016
		,1.844022331e-016
		,1.737561191e-016
		,1.676926856e-016
		,1.647238740e-016
		,1.635789461e-016
		,1.632196841e-016
		,1.631564824e-016
		,1.632063586e-016
		,1.633072076e-016
		,1.634387548e-016
		,1.635942815e-016
		,1.637710558e-016
		,1.639671912e-016
		,1.641807414e-016
		,1.644095830e-016
		,1.646515716e-016
		,1.649047647e-016
		,1.651676263e-016
		,1.654392114e-016
		,1.657194461e-016
		,1.660099528e-016
		,1.663171296e-016
		,1.666642109e-016
		,1.671391796e-016
		,1.680839868e-016
		,1.707944634e-016
		,1.794458023e-016
		,2.018306393e-016
		,2.388918034e-016
		,2.785340375e-016
		,3.112834366e-016
		,3.358080693e-016
		,3.539621217e-016
		,3.675408806e-016
		,3.779734579e-016
		,3.863936791e-016
		,3.751375676e-016
		,3.462317516e-016
		,3.173012235e-016
		,2.792298848e-016
		,2.431284008e-016
		,2.176061908e-016
		,1.979503005e-016
		,1.845535403e-016
		,1.745091083e-016
		,1.680346091e-016
		,1.648256321e-016
		,1.635635386e-016
		,1.631497696e-016
		,1.630558101e-016
		,1.630820522e-016
		,1.631607688e-016
		,1.632703305e-016
		,1.634042572e-016
		,1.635606245e-016
		,1.637384776e-016
		,1.639366612e-016
		,1.641535462e-016
		,1.643871204e-016
		,1.646352262e-016
		,1.648958370e-016
		,1.651673247e-016
		,1.654487723e-016
		,1.657406499e-016
		,1.660471292e-016
		,1.663850831e-016
		,1.668200010e-016
		,1.676090651e-016
		,1.697440268e-016
		,1.765968666e-016
		,1.955384741e-016
		,2.300508431e-016
		,2.697683004e-016
		,3.037574463e-016
		,3.294929934e-016
		,3.486821825e-016
		,3.631790397e-016
		,3.963288075e-016
		,3.736157503e-016
		,3.580597605e-016
		,3.297589405e-016
		,2.917830580e-016
		,2.581430022e-016
		,2.342364620e-016
		,2.125514110e-016
		,1.988771103e-016
		,1.857386796e-016
		,1.752411139e-016
		,1.684077063e-016
		,1.649560951e-016
		,1.635712124e-016
		,1.631019888e-016
		,1.629782599e-016
		,1.629824893e-016
		,1.630404205e-016
		,1.631285347e-016
		,1.632402435e-016
		,1.633742651e-016
		,1.635306120e-016
		,1.637091682e-016
		,1.639092107e-016
		,1.641293447e-016
		,1.643676583e-016
		,1.646219936e-016
		,1.648902700e-016
		,1.651708558e-016
		,1.654631929e-016
		,1.657696122e-016
		,1.661021457e-016
		,1.665096628e-016
		,1.671866220e-016
		,1.688936370e-016
		,1.743274383e-016
		,1.901716996e-016
		,2.218059477e-016
		,2.611511956e-016
		,2.962064750e-016
		,3.231231297e-016
		,4.067895807e-016
		,3.971691595e-016
		,3.881685335e-016
		,3.688040142e-016
		,3.405550569e-016
		,2.949910578e-016
		,2.756907410e-016
		,2.475850693e-016
		,2.283797432e-016
		,2.148360437e-016
		,2.003524395e-016
		,1.868497543e-016
		,1.759970764e-016
		,1.688154825e-016
		,1.651132284e-016
		,1.635991549e-016
		,1.630727552e-016
		,1.629202432e-016
		,1.629044586e-016
		,1.629437482e-016
		,1.630121661e-016
		,1.631025971e-016
		,1.632140720e-016
		,1.633473699e-016
		,1.635033987e-016
		,1.636825415e-016
		,1.638844073e-016
		,1.641078196e-016
		,1.643509812e-016
		,1.646117661e-016
		,1.648881156e-016
		,1.651786525e-016
		,1.654841852e-016
		,1.658129678e-016
		,1.662013874e-016
		,1.667970779e-016
		,1.681848893e-016
		,1.725076927e-016
		,1.856398569e-016
		,2.142029488e-016
		,2.527381247e-016
		,4.176441066e-016
		,4.142520964e-016
		,4.094268384e-016
		,4.010615201e-016
		,3.771265954e-016
		,3.390796087e-016
		,3.100038612e-016
		,2.896311914e-016
		,2.580900535e-016
		,2.437389176e-016
		,2.308991855e-016
		,2.164505605e-016
		,2.016874568e-016
		,1.879575776e-016
		,1.767856717e-016
		,1.692577647e-016
		,1.652958171e-016
		,1.636450108e-016
		,1.630587348e-016
		,1.628782718e-016
		,1.628444331e-016
		,1.628675323e-016
		,1.629186925e-016
		,1.629898932e-016
		,1.630801047e-016
		,1.631905331e-016
		,1.633228698e-016
		,1.634785353e-016
		,1.636582907e-016
		,1.638620492e-016
		,1.640888623e-016
		,1.643370779e-016
		,1.646046690e-016
		,1.648898057e-016
		,1.651921455e-016
		,1.655169907e-016
		,1.658912271e-016
		,1.664272137e-016
		,1.675758419e-016
		,1.710330039e-016
		,1.818416767e-016
		,4.290932134e-016
		,4.263225310e-016
		,4.236525216e-016
		,4.187150015e-016
		,4.045536329e-016
		,3.854327924e-016
		,3.384669916e-016
		,3.235884840e-016
		,3.043907822e-016
		,2.669704329e-016
		,2.563016107e-016
		,2.465163853e-016
		,2.326888620e-016
		,2.178828040e-016
		,2.029839403e-016
		,1.890766798e-016
		,1.776098377e-016
		,1.697358322e-016
		,1.655030160e-016
		,1.637067296e-016
		,1.630574383e-016
		,1.628491978e-016
		,1.627990168e-016
		,1.628082992e-016
		,1.628448630e-016
		,1.628994637e-016
		,1.629706954e-016
		,1.630598381e-016
		,1.631690131e-016
		,1.633003992e-016
		,1.634557876e-016
		,1.636362759e-016
		,1.638420816e-016
		,1.640725075e-016
		,1.643261043e-016
		,1.646011119e-016
		,1.648965398e-016
		,1.652155040e-016
		,1.655776422e-016
		,1.660685329e-016
		,1.670366308e-016
		,4.402683108e-016
		,4.378757041e-016
		,4.369321980e-016
		,4.346610889e-016
		,4.299462159e-016
		,4.094380924e-016
		,3.727975800e-016
		,3.433710575e-016
		,3.341499934e-016
		,3.182626304e-016
		,2.756389741e-016
		,2.692519542e-016
		,2.593561362e-016
		,2.475958399e-016
		,2.342586114e-016
		,2.192670711e-016
		,2.042699688e-016
		,1.902183667e-016
		,1.784660509e-016
		,1.702480310e-016
		,1.657335932e-016
		,1.637830807e-016
		,1.630668516e-016
		,1.628303139e-016
		,1.627651753e-016
		,1.627627419e-016
		,1.627872470e-016
		,1.628280141e-016
		,1.628830321e-016
		,1.629533700e-016
		,1.630412348e-016
		,1.631491971e-016
		,1.632797637e-016
		,1.634350436e-016
		,1.636164606e-016
		,1.638245496e-016
		,1.640589096e-016
		,1.643184292e-016
		,1.646020965e-016
		,1.649116508e-016
		,1.652613242e-016
		,4.499721029e-016
		,4.475777044e-016
		,4.476654416e-016
		,4.471101641e-016
		,4.451291853e-016
		,4.360164843e-016
		,4.154044656e-016
		,3.642784903e-016
		,3.528974082e-016
		,3.395274447e-016
		,3.235347012e-016
		,2.838280796e-016
		,2.810295313e-016
		,2.727183714e-016
		,2.614355712e-016
		,2.483706275e-016
		,2.357353590e-016
		,2.206056877e-016
		,2.055533297e-016
		,1.913601381e-016
		,1.793545820e-016
		,1.707914708e-016
		,1.659885471e-016
		,1.638731646e-016
		,1.630855562e-016
		,1.628195892e-016
		,1.627403919e-016
		,1.627279308e-016
		,1.627426123e-016
		,1.627721433e-016
		,1.628137736e-016
		,1.628681762e-016
		,1.629373805e-016
		,1.630240110e-016
		,1.631309133e-016
		,1.632608620e-016
		,1.634162658e-016
		,1.635988783e-016
		,1.638095837e-016
		,1.640483825e-016
		,1.643148800e-016
		,4.598034025e-016
		,4.585300032e-016
		,4.568161960e-016
		,4.573157969e-016
		,4.570675451e-016
		,4.551734977e-016
		,4.390699613e-016
		,4.056969501e-016
		,3.712961171e-016
		,3.617267508e-016
		,3.485526900e-016
		,3.315937026e-016
		,2.842431577e-016
		,2.884674389e-016
		,2.848302340e-016
		,2.749522903e-016
		,2.630928993e-016
		,2.498446110e-016
		,2.363993048e-016
		,2.219915342e-016
		,2.068267881e-016
		,1.925354498e-016
		,1.802707630e-016
		,1.713731885e-016
		,1.662675941e-016
		,1.639773176e-016
		,1.631122787e-016
		,1.628155781e-016
		,1.627225001e-016
		,1.627014313e-016
		,1.627081276e-016
		,1.627286885e-016
		,1.627595431e-016
		,1.628008720e-016
		,1.628543674e-016
		,1.629224620e-016
		,1.630080092e-016
		,1.631140642e-016
		,1.632436478e-016
		,1.633994664e-016
		,1.635836247e-016
		,4.663027917e-016
		,4.669633069e-016
		,4.665915905e-016
		,4.681363823e-016
		,4.695684172e-016
		,4.704279220e-016
		,4.645487975e-016
		,4.439838760e-016
		,3.919102178e-016
		,3.793325617e-016
		,3.700200072e-016
		,3.570409041e-016
		,3.387637882e-016
		,2.905727054e-016
		,2.929011422e-016
		,2.894759632e-016
		,2.872700168e-016
		,2.766869548e-016
		,2.645616284e-016
		,2.511978225e-016
		,2.370262512e-016
		,2.233635598e-016
		,2.081478869e-016
		,1.937114660e-016
		,1.812244873e-016
		,1.719862069e-016
		,1.665730910e-016
		,1.640948922e-016
		,1.631465685e-016
		,1.628169201e-016
		,1.627100299e-016
		,1.626812655e-016
		,1.626814378e-016
		,1.626949036e-016
		,1.627172406e-016
		,1.627481031e-016
		,1.627887733e-016
		,1.628413509e-016
		,1.629084668e-016
		,1.629931339e-016
		,1.630985944e-016
		,4.725837906e-016
		,4.739445578e-016
		,4.735688144e-016
		,4.751452194e-016
		,4.771119126e-016
		,4.788407632e-016
		,4.795908793e-016
		,4.701012927e-016
		,4.365954256e-016
		,4.015427022e-016
		,3.876315469e-016
		,3.779766194e-016
		,3.651386543e-016
		,3.461949655e-016
		,2.961761780e-016
		,2.999440027e-016
		,2.970047957e-016
		,2.910015350e-016
		,2.867965174e-016
		,2.781808845e-016
		,2.659278658e-016
		,2.524428591e-016
		,2.381764896e-016
		,2.242069414e-016
		,2.094525985e-016
		,1.949131456e-016
		,1.821987943e-016
		,1.726368788e-016
		,1.669040522e-016
		,1.642266091e-016
		,1.631878890e-016
		,1.628229196e-016
		,1.627017894e-016
		,1.626658367e-016
		,1.626606489e-016
		,1.626685131e-016
		,1.626841967e-016
		,1.627068283e-016
		,1.627372675e-016
		,1.627772255e-016
		,1.628289854e-016
		,4.782096731e-016
		,4.797559265e-016
		,4.805303877e-016
		,4.813804634e-016
		,4.840121985e-016
		,4.866575152e-016
		,4.882949516e-016
		,4.891498445e-016
		,4.738942519e-016
		,4.251918055e-016
		,4.102431475e-016
		,3.989988407e-016
		,3.875581206e-016
		,3.729832966e-016
		,3.540380313e-016
		,3.012227836e-016
		,3.063995791e-016
		,3.044483917e-016
		,2.993413423e-016
		,2.924121277e-016
		,2.852789815e-016
		,2.795408893e-016
		,2.671139924e-016
		,2.537303543e-016
		,2.393834550e-016
		,2.248976325e-016
		,2.107807473e-016
		,1.961241934e-016
		,1.832037399e-016
		,1.733223373e-016
		,1.672605668e-016
		,1.643732931e-016
		,1.632363452e-016
		,1.628329250e-016
		,1.626968814e-016
		,1.626539991e-016
		,1.626442792e-016
		,1.626476930e-016
		,1.626582109e-016
		,1.626744481e-016
		,1.626968635e-016
		,1.665549734e-016
		,1.667921635e-016
		,1.670518110e-016
		,1.673417545e-016
		,1.676738499e-016
		,1.680687750e-016
		,1.685668695e-016
		,1.692626131e-016
		,1.704142410e-016
		,1.727969557e-016
		,1.787252493e-016
		,1.937583660e-016
		,2.240127108e-016
		,2.642890189e-016
		,3.017905152e-016
		,3.316804873e-016
		,3.543627509e-016
		,3.709194587e-016
		,3.828320781e-016
		,3.915517927e-016
		,3.981492982e-016
		,4.033389797e-016
		,4.076143984e-016
		,4.113757977e-016
		,4.150351685e-016
		,4.190621686e-016
		,4.238433705e-016
		,4.293242911e-016
		,4.349080570e-016
		,4.399459057e-016
		,4.441608098e-016
		,4.475915338e-016
		,4.503899295e-016
		,4.527077728e-016
		,4.546646466e-016
		,4.563478985e-016
		,4.578201103e-016
		,4.591263002e-016
		,4.602993049e-016
		,4.613635044e-016
		,4.623373429e-016
		,1.658527862e-016
		,1.660635419e-016
		,1.662841541e-016
		,1.665164438e-016
		,1.667640010e-016
		,1.670318131e-016
		,1.673276480e-016
		,1.676645169e-016
		,1.680674623e-016
		,1.685944545e-016
		,1.694056925e-016
		,1.710007533e-016
		,1.749863063e-016
		,1.858918538e-016
		,2.112293626e-016
		,2.506085458e-016
		,2.908940253e-016
		,3.238613479e-016
		,3.488398895e-016
		,3.669542381e-016
		,3.798930505e-016
		,3.892931986e-016
		,3.963549325e-016
		,4.018733312e-016
		,4.063905135e-016
		,4.103356957e-016
		,4.141382919e-016
		,4.182791390e-016
		,4.231536196e-016
		,4.287147554e-016
		,4.343697073e-016
		,4.394700073e-016
		,4.437383392e-016
		,4.472142219e-016
		,4.500508169e-016
		,4.524011784e-016
		,4.543859456e-016
		,4.560933024e-016
		,4.575864881e-016
		,4.589110412e-016
		,4.601002149e-016
		,1.651829221e-016
		,1.653865120e-016
		,1.655957990e-016
		,1.658110350e-016
		,1.660330787e-016
		,1.662635543e-016
		,1.665048308e-016
		,1.667603805e-016
		,1.670354298e-016
		,1.673385355e-016
		,1.676858592e-016
		,1.681144376e-016
		,1.687272127e-016
		,1.698523990e-016
		,1.725948788e-016
		,1.804061071e-016
		,2.006871221e-016
		,2.372578365e-016
		,2.791206924e-016
		,3.149673456e-016
		,3.423751893e-016
		,3.622515944e-016
		,3.764070329e-016
		,3.866337369e-016
		,3.942595743e-016
		,4.001707695e-016
		,4.049694827e-016
		,4.091230362e-016
		,4.130846401e-016
		,4.173504819e-016
		,4.223275386e-016
		,4.279783273e-016
		,4.337147643e-016
		,4.388881749e-016
		,4.432202866e-016
		,4.467510018e-016
		,4.496346546e-016
		,4.520255502e-016
		,4.540454009e-016
		,4.557832628e-016
		,4.573030829e-016
		,1.645321532e-016
		,1.647209091e-016
		,1.649220355e-016
		,1.651305964e-016
		,1.653447097e-016
		,1.655639716e-016
		,1.657887329e-016
		,1.660199681e-016
		,1.662592776e-016
		,1.665090463e-016
		,1.667728499e-016
		,1.670564571e-016
		,1.673705967e-016
		,1.677396509e-016
		,1.682316194e-016
		,1.690665993e-016
		,1.710081955e-016
		,1.766098602e-016
		,1.923901292e-016
		,2.249367779e-016
		,2.670091467e-016
		,3.053014714e-016
		,3.351140916e-016
		,3.568410609e-016
		,3.723484627e-016
		,3.835437430e-016
		,3.918521907e-016
		,3.982419935e-016
		,4.033789774e-016
		,4.077755517e-016
		,4.119152730e-016
		,4.163150780e-016
		,4.213980621e-016
		,4.271399541e-016
		,4.329596932e-016
		,4.382090979e-016
		,4.426089320e-016
		,4.461993553e-016
		,4.491356855e-016
		,4.515732216e-016
		,4.536344721e-016
		,1.640367057e-016
		,1.641185547e-016
		,1.642752697e-016
		,1.644625513e-016
		,1.646647923e-016
		,1.648759900e-016
		,1.650936082e-016
		,1.653165919e-016
		,1.655447122e-016
		,1.657783493e-016
		,1.660184454e-016
		,1.662665736e-016
		,1.665251756e-016
		,1.667981991e-016
		,1.670929192e-016
		,1.674257597e-016
		,1.678426503e-016
		,1.684939694e-016
		,1.699126863e-016
		,1.739662471e-016
		,1.860445560e-016
		,2.140371724e-016
		,2.550037648e-016
		,2.951459453e-016
		,3.272489016e-016
		,3.508274935e-016
		,3.677262713e-016
		,3.799784270e-016
		,3.890799206e-016
		,3.960487289e-016
		,4.016014436e-016
		,4.062955740e-016
		,4.106490469e-016
		,4.152038549e-016
		,4.204032122e-016
		,4.262398045e-016
		,4.321424866e-016
		,4.374653479e-016
		,4.419294941e-016
		,4.455765007e-016
		,4.485635215e-016
		,1.648690460e-016
		,1.640000015e-016
		,1.638232004e-016
		,1.638845942e-016
		,1.640304689e-016
		,1.642116189e-016
		,1.644109427e-016
		,1.646217164e-016
		,1.648407483e-016
		,1.650663249e-016
		,1.652975705e-016
		,1.655342377e-016
		,1.657766416e-016
		,1.660256726e-016
		,1.662829232e-016
		,1.665510851e-016
		,1.668351561e-016
		,1.671464040e-016
		,1.675164407e-016
		,1.680497483e-016
		,1.691225684e-016
		,1.720974242e-016
		,1.812693641e-016
		,2.047092957e-016
		,2.434550257e-016
		,2.847384563e-016
		,3.189464888e-016
		,3.443626666e-016
		,3.626339918e-016
		,3.759436607e-016
		,3.858951052e-016
		,3.935309598e-016
		,3.995853991e-016
		,4.046466580e-016
		,4.092654759e-016
		,4.140116366e-016
		,4.193518855e-016
		,4.252989745e-016
		,4.312937762e-016
		,4.366936759e-016
		,4.412210054e-016
		,1.776416910e-016
		,1.680460324e-016
		,1.647968323e-016
		,1.638359303e-016
		,1.636296219e-016
		,1.636710617e-016
		,1.638015302e-016
		,1.639713769e-016
		,1.641630851e-016
		,1.643694575e-016
		,1.645867853e-016
		,1.648127567e-016
		,1.650458462e-016
		,1.652851452e-016
		,1.655303169e-016
		,1.657815952e-016
		,1.660398483e-016
		,1.663068197e-016
		,1.665859280e-016
		,1.668849982e-016
		,1.672261366e-016
		,1.676830392e-016
		,1.685243924e-016
		,1.707467546e-016
		,1.776997765e-016
		,1.969310766e-016
		,2.326240523e-016
		,2.742842105e-016
		,3.103310174e-016
		,3.375604647e-016
		,3.572096012e-016
		,3.715306594e-016
		,3.823059851e-016
		,3.906450836e-016
		,3.972730751e-016
		,4.027755710e-016
		,4.077213931e-016
		,4.127060043e-016
		,4.182221970e-016
		,4.243061375e-016
		,4.304130342e-016
		,2.420505314e-016
		,1.991603001e-016
		,1.763591102e-016
		,1.675839237e-016
		,1.646240750e-016
		,1.637014095e-016
		,1.634678752e-016
		,1.634826699e-016
		,1.635927471e-016
		,1.637464200e-016
		,1.639255912e-016
		,1.641228803e-016
		,1.643343839e-016
		,1.645574206e-016
		,1.647899282e-016
		,1.650303606e-016
		,1.652777048e-016
		,1.655315126e-016
		,1.657919512e-016
		,1.660599542e-016
		,1.663377540e-016
		,1.666307807e-016
		,1.669546764e-016
		,1.673621177e-016
		,1.680471295e-016
		,1.697422137e-016
		,1.750284798e-016
		,1.905723505e-016
		,2.226890631e-016
		,2.639576759e-016
		,3.015161476e-016
		,3.304796372e-016
		,3.515440395e-016
		,3.668738833e-016
		,3.784032599e-016
		,3.874021799e-016
		,3.946263825e-016
		,4.006301589e-016
		,4.059674623e-016
		,4.112449488e-016
		,4.169794118e-016
		,3.101276563e-016
		,2.716617221e-016
		,2.238364243e-016
		,1.891648098e-016
		,1.738691512e-016
		,1.673772351e-016
		,1.646048337e-016
		,1.636144140e-016
		,1.633369208e-016
		,1.633212485e-016
		,1.634077350e-016
		,1.635414717e-016
		,1.637036265e-016
		,1.638869974e-016
		,1.640879158e-016
		,1.643037157e-016
		,1.645320758e-016
		,1.647709652e-016
		,1.650187445e-016
		,1.652742730e-016
		,1.655369969e-016
		,1.658070747e-016
		,1.660857469e-016
		,1.663766721e-016
		,1.666909640e-016
		,1.670666848e-016
		,1.676453976e-016
		,1.689688276e-016
		,1.730139411e-016
		,1.854478828e-016
		,2.137540611e-016
		,2.539017232e-016
		,2.926101214e-016
		,3.231756385e-016
		,3.456561640e-016
		,3.620573376e-016
		,3.743215136e-016
		,3.838919637e-016
		,3.916581318e-016
		,3.981770694e-016
		,4.039572968e-016
		,3.530535769e-016
		,3.238606070e-016
		,2.842470718e-016
		,2.411508230e-016
		,2.046349771e-016
		,1.851875796e-016
		,1.737149950e-016
		,1.675060903e-016
		,1.646503643e-016
		,1.635662384e-016
		,1.632345199e-016
		,1.631869296e-016
		,1.632486670e-016
		,1.633602743e-016
		,1.635020876e-016
		,1.636672999e-016
		,1.638528678e-016
		,1.640565934e-016
		,1.642763190e-016
		,1.645098518e-016
		,1.647551215e-016
		,1.650103756e-016
		,1.652743488e-016
		,1.655464219e-016
		,1.658269195e-016
		,1.661180782e-016
		,1.664277087e-016
		,1.667835033e-016
		,1.672896901e-016
		,1.683495313e-016
		,1.714739243e-016
		,1.813560479e-016
		,2.058585500e-016
		,2.442345900e-016
		,2.836990046e-016
		,3.157251345e-016
		,3.395535386e-016
		,3.570781626e-016
		,3.701464484e-016
		,3.802499965e-016
		,3.884561082e-016
		,3.793424206e-016
		,3.634106672e-016
		,3.391970073e-016
		,2.936590223e-016
		,2.554904659e-016
		,2.237154120e-016
		,1.996002092e-016
		,1.843254817e-016
		,1.740789228e-016
		,1.678293699e-016
		,1.647454410e-016
		,1.635437533e-016
		,1.631575399e-016
		,1.630785603e-016
		,1.631158952e-016
		,1.632048429e-016
		,1.633246054e-016
		,1.634687084e-016
		,1.636349222e-016
		,1.638218889e-016
		,1.640280763e-016
		,1.642515840e-016
		,1.644902774e-016
		,1.647420322e-016
		,1.650049891e-016
		,1.652777901e-016
		,1.655598801e-016
		,1.658522615e-016
		,1.661602070e-016
		,1.665038683e-016
		,1.669605403e-016
		,1.678323407e-016
		,1.702741886e-016
		,1.781034047e-016
		,1.989891453e-016
		,2.350546188e-016
		,2.748473024e-016
		,3.081991391e-016
		,3.332838864e-016
		,3.519042075e-016
		,3.658674149e-016
		,4.043854883e-016
		,3.883888654e-016
		,3.700945491e-016
		,3.394205959e-016
		,3.090147820e-016
		,2.737621013e-016
		,2.379806895e-016
		,2.164914941e-016
		,1.977000855e-016
		,1.851044177e-016
		,1.748475006e-016
		,1.681948441e-016
		,1.648664330e-016
		,1.635443076e-016
		,1.631030033e-016
		,1.629936643e-016
		,1.630080090e-016
		,1.630752426e-016
		,1.631729252e-016
		,1.632946432e-016
		,1.634389105e-016
		,1.636053573e-016
		,1.637934189e-016
		,1.640019476e-016
		,1.642292241e-016
		,1.644731613e-016
		,1.647315926e-016
		,1.650025824e-016
		,1.652847806e-016
		,1.655780814e-016
		,1.658857039e-016
		,1.662221546e-016
		,1.666450074e-016
		,1.673819258e-016
		,1.693171548e-016
		,1.755178171e-016
		,1.930924870e-016
		,2.264396180e-016
		,2.661127802e-016
		,3.006378765e-016
		,3.269212006e-016
		,4.156951270e-016
		,4.088502359e-016
		,3.884999625e-016
		,3.729120173e-016
		,3.533455694e-016
		,3.220768721e-016
		,2.829241750e-016
		,2.562291836e-016
		,2.309235267e-016
		,2.135737915e-016
		,1.996087969e-016
		,1.862919749e-016
		,1.756031058e-016
		,1.685900401e-016
		,1.650135312e-016
		,1.635651815e-016
		,1.630676425e-016
		,1.629290485e-016
		,1.629223789e-016
		,1.629698402e-016
		,1.630468045e-016
		,1.631465188e-016
		,1.632679643e-016
		,1.634116502e-016
		,1.635780776e-016
		,1.637671562e-016
		,1.639780322e-016
		,1.642091543e-016
		,1.644584982e-016
		,1.647238871e-016
		,1.650033926e-016
		,1.652959691e-016
		,1.656031313e-016
		,1.659350361e-016
		,1.663345823e-016
		,1.669741533e-016
		,1.685323763e-016
		,1.734535576e-016
		,1.880877269e-016
		,2.184464724e-016
		,2.575529014e-016
		,4.287828062e-016
		,4.208766332e-016
		,4.036128666e-016
		,3.977630096e-016
		,3.875394797e-016
		,3.624352750e-016
		,3.280270517e-016
		,2.929691056e-016
		,2.732483434e-016
		,2.433331797e-016
		,2.295479123e-016
		,2.156895829e-016
		,2.010717435e-016
		,1.874218509e-016
		,1.763828301e-016
		,1.690180892e-016
		,1.651854959e-016
		,1.636041117e-016
		,1.630482123e-016
		,1.628813589e-016
		,1.628557585e-016
		,1.628858705e-016
		,1.629443735e-016
		,1.630237672e-016
		,1.631231317e-016
		,1.632435580e-016
		,1.633864573e-016
		,1.635528408e-016
		,1.637429817e-016
		,1.639562980e-016
		,1.641914195e-016
		,1.644464166e-016
		,1.647191754e-016
		,1.650080089e-016
		,1.653130766e-016
		,1.656411342e-016
		,1.660239906e-016
		,1.665926090e-016
		,1.678692009e-016
		,1.717914920e-016
		,1.838776885e-016
		,4.386521335e-016
		,4.229552006e-016
		,4.172536340e-016
		,4.155199931e-016
		,4.101131918e-016
		,3.965910821e-016
		,3.743294018e-016
		,3.264071883e-016
		,3.079936162e-016
		,2.872554749e-016
		,2.529119556e-016
		,2.450931835e-016
		,2.318708291e-016
		,2.172766596e-016
		,2.024133220e-016
		,1.885470151e-016
		,1.771922827e-016
		,1.694800000e-016
		,1.653812376e-016
		,1.636592116e-016
		,1.630419931e-016
		,1.628474683e-016
		,1.628047983e-016
		,1.628200440e-016
		,1.628627340e-016
		,1.629242805e-016
		,1.630035143e-016
		,1.631017468e-016
		,1.632209768e-016
		,1.633631140e-016
		,1.635295477e-016
		,1.637208795e-016
		,1.639368037e-016
		,1.641761587e-016
		,1.644371729e-016
		,1.647179843e-016
		,1.650178479e-016
		,1.653409235e-016
		,1.657105668e-016
		,1.662264366e-016
		,1.672914143e-016
		,4.396031990e-016
		,4.331911226e-016
		,4.296396828e-016
		,4.281089330e-016
		,4.249432383e-016
		,4.190131506e-016
		,3.980843295e-016
		,3.673770249e-016
		,3.372234665e-016
		,3.217116280e-016
		,2.982414034e-016
		,2.651762826e-016
		,2.576977294e-016
		,2.471818400e-016
		,2.336089307e-016
		,2.187033127e-016
		,2.037145340e-016
		,1.896758812e-016
		,1.780351057e-016
		,1.699747764e-016
		,1.656008249e-016
		,1.637288977e-016
		,1.630469904e-016
		,1.628245596e-016
		,1.627664009e-016
		,1.627690373e-016
		,1.627985585e-016
		,1.628450340e-016
		,1.629067760e-016
		,1.629849962e-016
		,1.630819196e-016
		,1.632000085e-016
		,1.633415206e-016
		,1.635081751e-016
		,1.637008962e-016
		,1.639196728e-016
		,1.641636030e-016
		,1.644312261e-016
		,1.647214819e-016
		,1.650367395e-016
		,1.653939715e-016
		,4.423252719e-016
		,4.430849807e-016
		,4.409558289e-016
		,4.399980229e-016
		,4.387683607e-016
		,4.358555606e-016
		,4.262280658e-016
		,4.074228830e-016
		,3.546817399e-016
		,3.414407330e-016
		,3.298110091e-016
		,3.086059911e-016
		,2.763423925e-016
		,2.707482203e-016
		,2.604388681e-016
		,2.481746679e-016
		,2.351755218e-016
		,2.200848133e-016
		,2.049922209e-016
		,1.908263671e-016
		,1.789076898e-016
		,1.705041090e-016
		,1.658434584e-016
		,1.638124449e-016
		,1.630614734e-016
		,1.628104126e-016
		,1.627378899e-016
		,1.627298050e-016
		,1.627485554e-016
		,1.627826705e-016
		,1.628297772e-016
		,1.628907577e-016
		,1.629677599e-016
		,1.630634362e-016
		,1.631805457e-016
		,1.633216373e-016
		,1.634887453e-016
		,1.636831242e-016
		,1.639050955e-016
		,1.641541377e-016
		,1.644295338e-016
		,4.518994746e-016
		,4.529466922e-016
		,4.524984556e-016
		,4.516199330e-016
		,4.518888132e-016
		,4.494782879e-016
		,4.461321266e-016
		,4.291673247e-016
		,4.000769147e-016
		,3.603673833e-016
		,3.507831249e-016
		,3.369744752e-016
		,3.104486268e-016
		,2.848042201e-016
		,2.825058771e-016
		,2.737437990e-016
		,2.623381894e-016
		,2.492632874e-016
		,2.362873326e-016
		,2.214234901e-016
		,2.062832810e-016
		,1.919793907e-016
		,1.798120440e-016
		,1.710651442e-016
		,1.661101954e-016
		,1.639091319e-016
		,1.630843716e-016
		,1.628033429e-016
		,1.627170104e-016
		,1.626997434e-016
		,1.627097439e-016
		,1.627339299e-016
		,1.627691381e-016
		,1.628157917e-016
		,1.628757571e-016
		,1.629515871e-016
		,1.630461805e-016
		,1.631625311e-016
		,1.633034584e-016
		,1.634713128e-016
		,1.636677045e-016
		,4.594264403e-016
		,4.605297219e-016
		,4.614125070e-016
		,4.601235531e-016
		,4.611428991e-016
		,4.617921983e-016
		,4.613954422e-016
		,4.576778053e-016
		,4.370864703e-016
		,3.855811272e-016
		,3.693844703e-016
		,3.593754696e-016
		,3.458512979e-016
		,3.163746242e-016
		,2.874562003e-016
		,2.886850024e-016
		,2.858261714e-016
		,2.757910038e-016
		,2.639063569e-016
		,2.506637864e-016
		,2.368801282e-016
		,2.228018817e-016
		,2.075506930e-016
		,1.931544895e-016
		,1.807410332e-016
		,1.716611605e-016
		,1.663999572e-016
		,1.640197340e-016
		,1.631146613e-016
		,1.628020800e-016
		,1.627020087e-016
		,1.626767115e-016
		,1.626795902e-016
		,1.626958973e-016
		,1.627216332e-016
		,1.627567036e-016
		,1.628025866e-016
		,1.628615498e-016
		,1.629363551e-016
		,1.630300813e-016
		,1.631459345e-016
		,4.660372927e-016
		,4.673633889e-016
		,4.687627030e-016
		,4.682586276e-016
		,4.691269422e-016
		,4.706104876e-016
		,4.716712335e-016
		,4.715108955e-016
		,4.606579675e-016
		,4.322067468e-016
		,3.908119915e-016
		,3.800457558e-016
		,3.677138799e-016
		,3.542218872e-016
		,3.222270910e-016
		,2.940249212e-016
		,2.943473560e-016
		,2.896605018e-016
		,2.874259554e-016
		,2.774179214e-016
		,2.653094243e-016
		,2.519285463e-016
		,2.376683996e-016
		,2.239439511e-016
		,2.088506818e-016
		,1.943278808e-016
		,1.817010112e-016
		,1.722845654e-016
		,1.667177643e-016
		,1.641432636e-016
		,1.631522093e-016
		,1.628055668e-016
		,1.626916170e-016
		,1.626589821e-016
		,1.626560218e-016
		,1.626661092e-016
		,1.626844106e-016
		,1.627103048e-016
		,1.627448465e-016
		,1.627899293e-016
		,1.628480082e-016
		,4.723828433e-016
		,4.734531394e-016
		,4.748300000e-016
		,4.756226711e-016
		,4.760721345e-016
		,4.780189249e-016
		,4.799670559e-016
		,4.813994850e-016
		,4.813815144e-016
		,4.645600803e-016
		,4.209882474e-016
		,3.985514272e-016
		,3.886825069e-016
		,3.777846014e-016
		,3.642763857e-016
		,3.284018583e-016
		,2.999756303e-016
		,3.014775454e-016
		,2.977927857e-016
		,2.915287817e-016
		,2.861593037e-016
		,2.788421441e-016
		,2.665678870e-016
		,2.531776751e-016
		,2.388276359e-016
		,2.246379370e-016
		,2.101388214e-016
		,1.955205242e-016
		,1.826686218e-016
		,1.729537351e-016
		,1.670579672e-016
		,1.642818815e-016
		,1.631963739e-016
		,1.628132842e-016
		,1.626848287e-016
		,1.626452210e-016
		,1.626373990e-016
		,1.626425606e-016
		,1.626550756e-016
		,1.626738036e-016
		,1.626993864e-016
		,1.665961749e-016
		,1.668477558e-016
		,1.671249146e-016
		,1.674371650e-016
		,1.678000075e-016
		,1.682416483e-016
		,1.688199334e-016
		,1.696621877e-016
		,1.711197393e-016
		,1.742029996e-016
		,1.817477214e-016
		,1.997153612e-016
		,2.324526687e-016
		,2.722791406e-016
		,3.077548376e-016
		,3.358504090e-016
		,3.572913081e-016
		,3.730347313e-016
		,3.844157562e-016
		,3.927822466e-016
		,3.991345998e-016
		,4.041470830e-016
		,4.082897644e-016
		,4.119488005e-016
		,4.155274118e-016
		,4.194893361e-016
		,4.242164739e-016
		,4.296516490e-016
		,4.351969417e-016
		,4.402022732e-016
		,4.443897245e-016
		,4.477972047e-016
		,4.505757648e-016
		,4.528765522e-016
		,4.548186962e-016
		,4.564891740e-016
		,4.579502372e-016
		,4.592466285e-016
		,4.604109648e-016
		,4.614674512e-016
		,4.624343900e-016
		,1.658938972e-016
		,1.661113092e-016
		,1.663387309e-016
		,1.665791207e-016
		,1.668368483e-016
		,1.671182031e-016
		,1.674330436e-016
		,1.677979275e-016
		,1.682454384e-016
		,1.688519272e-016
		,1.698283449e-016
		,1.718224873e-016
		,1.768420521e-016
		,1.900899898e-016
		,2.185176320e-016
		,2.588174040e-016
		,2.976444083e-016
		,3.288019047e-016
		,3.523772858e-016
		,3.695186896e-016
		,3.818073059e-016
		,3.907727721e-016
		,3.975368555e-016
		,4.028441178e-016
		,4.072056447e-016
		,4.110319227e-016
		,4.147410628e-016
		,4.188067516e-016
		,4.236190733e-016
		,4.291268112e-016
		,4.347347600e-016
		,4.397940107e-016
		,4.440271240e-016
		,4.474730313e-016
		,4.502840785e-016
		,4.526125489e-016
		,4.545784387e-016
		,4.562694155e-016
		,4.577483061e-016
		,4.590603170e-016
		,4.602384309e-016
		,1.652332023e-016
		,1.654404486e-016
		,1.656531237e-016
		,1.658717620e-016
		,1.660976182e-016
		,1.663327366e-016
		,1.665800389e-016
		,1.668437563e-016
		,1.671302916e-016
		,1.674502775e-016
		,1.678241476e-016
		,1.682993709e-016
		,1.690083613e-016
		,1.703700566e-016
		,1.737642804e-016
		,1.832778352e-016
		,2.065530768e-016
		,2.450818575e-016
		,2.862670762e-016
		,3.204903929e-016
		,3.464583505e-016
		,3.652591101e-016
		,3.786540013e-016
		,3.883557444e-016
		,3.956208017e-016
		,4.012805977e-016
		,4.058995875e-016
		,4.099204556e-016
		,4.137807203e-016
		,4.179664296e-016
		,4.228772680e-016
		,4.284701921e-016
		,4.341543169e-016
		,4.392808016e-016
		,4.435716659e-016
		,4.470665134e-016
		,4.499190263e-016
		,4.522828300e-016
		,4.542790443e-016
		,4.559962292e-016
		,4.574979153e-016
		,1.645887182e-016
		,1.647822167e-016
		,1.649867781e-016
		,1.651978727e-016
		,1.654140661e-016
		,1.656352568e-016
		,1.658621080e-016
		,1.660959157e-016
		,1.663386537e-016
		,1.665932041e-016
		,1.668638900e-016
		,1.671577624e-016
		,1.674881376e-016
		,1.678856676e-016
		,1.684362533e-016
		,1.694168218e-016
		,1.717749898e-016
		,1.785708802e-016
		,1.969240881e-016
		,2.320195506e-016
		,2.742350007e-016
		,3.112114762e-016
		,3.396385694e-016
		,3.602664254e-016
		,3.749467698e-016
		,3.855336862e-016
		,3.934062342e-016
		,3.994883196e-016
		,4.044078218e-016
		,4.086487653e-016
		,4.126749850e-016
		,4.169897539e-016
		,4.220058230e-016
		,4.276908024e-016
		,4.334591357e-016
		,4.386617395e-016
		,4.430194626e-016
		,4.465721567e-016
		,4.494746127e-016
		,4.518816684e-016
		,4.539154893e-016
		,1.640821518e-016
		,1.641771656e-016
		,1.643415568e-016
		,1.645339002e-016
		,1.647396219e-016
		,1.649532268e-016
		,1.651725335e-016
		,1.653967913e-016
		,1.656260553e-016
		,1.658609868e-016
		,1.661028316e-016
		,1.663535300e-016
		,1.666160353e-016
		,1.668951298e-016
		,1.671997245e-016
		,1.675501673e-016
		,1.680036520e-016
		,1.687470397e-016
		,1.704365462e-016
		,1.753178634e-016
		,1.894645693e-016
		,2.202029880e-016
		,2.620603469e-016
		,3.012718293e-016
		,3.320866720e-016
		,3.545909270e-016
		,3.706623624e-016
		,3.822655487e-016
		,3.908660835e-016
		,3.974628953e-016
		,4.027466149e-016
		,4.072480153e-016
		,4.114632916e-016
		,4.159182204e-016
		,4.210432573e-016
		,4.268207042e-016
		,4.326730674e-016
		,4.379522080e-016
		,4.423782149e-016
		,4.459913650e-016
		,4.489475402e-016
		,1.647997973e-016
		,1.640186139e-016
		,1.638731286e-016
		,1.639472898e-016
		,1.641012750e-016
		,1.642883921e-016
		,1.644920716e-016
		,1.647058926e-016
		,1.649269347e-016
		,1.651537741e-016
		,1.653858238e-016
		,1.656231204e-016
		,1.658662641e-016
		,1.661164559e-016
		,1.663756736e-016
		,1.666471855e-016
		,1.669370655e-016
		,1.672591153e-016
		,1.676522351e-016
		,1.682448542e-016
		,1.694965129e-016
		,1.730443867e-016
		,1.838152134e-016
		,2.099151218e-016
		,2.501551431e-016
		,2.909421204e-016
		,3.239962013e-016
		,3.483618352e-016
		,3.658350449e-016
		,3.785155116e-016
		,3.879429069e-016
		,3.951550005e-016
		,4.008851742e-016
		,4.057073145e-016
		,4.101527772e-016
		,4.147737748e-016
		,4.200222402e-016
		,4.258986887e-016
		,4.318364117e-016
		,4.371899409e-016
		,4.416800261e-016
		,1.764664026e-016
		,1.678901754e-016
		,1.648214823e-016
		,1.638785890e-016
		,1.636815509e-016
		,1.637322439e-016
		,1.638719164e-016
		,1.640492707e-016
		,1.642467700e-016
		,1.644574153e-016
		,1.646776947e-016
		,1.649055368e-016
		,1.651396883e-016
		,1.653795281e-016
		,1.656250094e-016
		,1.658766627e-016
		,1.661356857e-016
		,1.664042577e-016
		,1.666865431e-016
		,1.669920556e-016
		,1.673477331e-016
		,1.678433072e-016
		,1.688044377e-016
		,1.714250763e-016
		,1.795858998e-016
		,2.012224828e-016
		,2.388354942e-016
		,2.804497608e-016
		,3.155200193e-016
		,3.417280155e-016
		,3.605822134e-016
		,3.743160226e-016
		,3.846013702e-016
		,3.925051172e-016
		,3.987666948e-016
		,4.039822645e-016
		,4.087135323e-016
		,4.135409242e-016
		,4.189411539e-016
		,4.249361039e-016
		,4.309719106e-016
		,2.420622540e-016
		,2.024247327e-016
		,1.780506542e-016
		,1.679974173e-016
		,1.647230642e-016
		,1.637311357e-016
		,1.635090685e-016
		,1.635378995e-016
		,1.636588522e-016
		,1.638215214e-016
		,1.640080808e-016
		,1.642112458e-016
		,1.644271607e-016
		,1.646532626e-016
		,1.648876912e-016
		,1.651291597e-016
		,1.653769438e-016
		,1.656308955e-016
		,1.658914973e-016
		,1.661600537e-016
		,1.664393556e-016
		,1.667360058e-016
		,1.670689293e-016
		,1.675017416e-016
		,1.682679367e-016
		,1.702416749e-016
		,1.764286614e-016
		,1.940460620e-016
		,2.283278120e-016
		,2.699901625e-016
		,3.067771065e-016
		,3.347835390e-016
		,3.550363868e-016
		,3.697814118e-016
		,3.808755876e-016
		,3.894826446e-016
		,3.963362087e-016
		,4.020178182e-016
		,4.070987409e-016
		,4.121824734e-016
		,4.177721542e-016
		,3.212157003e-016
		,2.865584038e-016
		,2.386432277e-016
		,1.977110544e-016
		,1.757876442e-016
		,1.674816370e-016
		,1.645756211e-016
		,1.636240346e-016
		,1.633686502e-016
		,1.633684971e-016
		,1.634666929e-016
		,1.636104403e-016
		,1.637814132e-016
		,1.639723481e-016
		,1.641794393e-016
		,1.643999616e-016
		,1.646316545e-016
		,1.648726580e-016
		,1.651215804e-016
		,1.653775720e-016
		,1.656403938e-016
		,1.659105535e-016
		,1.661897542e-016
		,1.664825179e-016
		,1.668022548e-016
		,1.671946286e-016
		,1.678289024e-016
		,1.693487863e-016
		,1.740614165e-016
		,1.882229753e-016
		,2.187775050e-016
		,2.597258144e-016
		,2.978811238e-016
		,3.275811454e-016
		,3.492630670e-016
		,3.650400677e-016
		,3.768788556e-016
		,3.861231131e-016
		,3.935679655e-016
		,3.997651033e-016
		,4.052586607e-016
		,3.588328659e-016
		,3.365350992e-016
		,3.080344639e-016
		,2.652231351e-016
		,2.182289344e-016
		,1.873534092e-016
		,1.737414524e-016
		,1.674052487e-016
		,1.645931278e-016
		,1.635608411e-016
		,1.632572869e-016
		,1.632252067e-016
		,1.632986279e-016
		,1.634206852e-016
		,1.635722708e-016
		,1.637464706e-016
		,1.639399562e-016
		,1.641502806e-016
		,1.643751552e-016
		,1.646123988e-016
		,1.648600811e-016
		,1.651166847e-016
		,1.653812393e-016
		,1.656534646e-016
		,1.659341031e-016
		,1.662260762e-016
		,1.665388627e-016
		,1.669055437e-016
		,1.674500440e-016
		,1.686494700e-016
		,1.722675594e-016
		,1.835542063e-016
		,2.102589439e-016
		,2.497890346e-016
		,2.889338595e-016
		,3.201843456e-016
		,3.432699087e-016
		,3.601467385e-016
		,3.727405482e-016
		,3.825386003e-016
		,3.904976937e-016
		,3.801856815e-016
		,3.686004346e-016
		,3.511701795e-016
		,3.159444529e-016
		,2.765547787e-016
		,2.318498745e-016
		,2.025172312e-016
		,1.847133627e-016
		,1.738574460e-016
		,1.676091793e-016
		,1.646703352e-016
		,1.635304062e-016
		,1.631716360e-016
		,1.631076262e-016
		,1.631561337e-016
		,1.632553465e-016
		,1.633851964e-016
		,1.635391554e-016
		,1.637146701e-016
		,1.639099985e-016
		,1.641232886e-016
		,1.643524495e-016
		,1.645953100e-016
		,1.648498537e-016
		,1.651144429e-016
		,1.653880233e-016
		,1.656704263e-016
		,1.659632346e-016
		,1.662729900e-016
		,1.666237528e-016
		,1.671070145e-016
		,1.680787437e-016
		,1.708859830e-016
		,1.798371960e-016
		,2.027863934e-016
		,2.402895643e-016
		,2.800123204e-016
		,3.126716723e-016
		,3.370759173e-016
		,3.550804103e-016
		,3.685154363e-016
		,3.980958123e-016
		,3.900294120e-016
		,3.787647558e-016
		,3.602343276e-016
		,3.283710300e-016
		,2.837534621e-016
		,2.491876135e-016
		,2.200159653e-016
		,1.992964969e-016
		,1.843090274e-016
		,1.744127410e-016
		,1.679828442e-016
		,1.647826614e-016
		,1.635227433e-016
		,1.631089784e-016
		,1.630140403e-016
		,1.630387313e-016
		,1.631155320e-016
		,1.632229707e-016
		,1.633547298e-016
		,1.635090602e-016
		,1.636851832e-016
		,1.638820968e-016
		,1.640982792e-016
		,1.643317652e-016
		,1.645803826e-016
		,1.648420388e-016
		,1.651150077e-016
		,1.653982669e-016
		,1.656922118e-016
		,1.660010684e-016
		,1.663422523e-016
		,1.667837169e-016
		,1.675927122e-016
		,1.697990250e-016
		,1.768850360e-016
		,1.963265902e-016
		,2.313171375e-016
		,2.711769445e-016
		,3.051041364e-016
		,3.307420836e-016
		,4.157907731e-016
		,4.118851808e-016
		,4.044703859e-016
		,3.856134099e-016
		,3.590261645e-016
		,3.359976146e-016
		,2.999271374e-016
		,2.660518319e-016
		,2.364376899e-016
		,2.146142518e-016
		,1.985126563e-016
		,1.856550346e-016
		,1.751988284e-016
		,1.683692013e-016
		,1.649194578e-016
		,1.635356774e-016
		,1.630663428e-016
		,1.629416795e-016
		,1.629444075e-016
		,1.630004216e-016
		,1.630863142e-016
		,1.631956108e-016
		,1.633271708e-016
		,1.634811728e-016
		,1.636576766e-016
		,1.638561197e-016
		,1.640752278e-016
		,1.643131513e-016
		,1.645677312e-016
		,1.648368310e-016
		,1.651187291e-016
		,1.654127789e-016
		,1.657213046e-016
		,1.660566796e-016
		,1.664695037e-016
		,1.671615116e-016
		,1.689215824e-016
		,1.745356010e-016
		,1.908117857e-016
		,2.229404691e-016
		,2.624852086e-016
		,4.270632821e-016
		,4.208749714e-016
		,4.168079671e-016
		,4.052750687e-016
		,3.838887189e-016
		,3.717797774e-016
		,3.459307273e-016
		,3.146669441e-016
		,2.762791708e-016
		,2.546232005e-016
		,2.281076511e-016
		,2.145398717e-016
		,2.003406436e-016
		,1.868568486e-016
		,1.759786726e-016
		,1.687844600e-016
		,1.650805841e-016
		,1.635670676e-016
		,1.630406419e-016
		,1.628873412e-016
		,1.628702248e-016
		,1.629077631e-016
		,1.629740785e-016
		,1.630621246e-016
		,1.631710236e-016
		,1.633016816e-016
		,1.634551649e-016
		,1.636320318e-016
		,1.638320585e-016
		,1.640542016e-016
		,1.642967413e-016
		,1.645575652e-016
		,1.648345720e-016
		,1.651263126e-016
		,1.654335596e-016
		,1.657647699e-016
		,1.661575415e-016
		,1.667647911e-016
		,1.681924110e-016
		,1.726540710e-016
		,1.861518147e-016
		,4.336440653e-016
		,4.323840719e-016
		,4.305737731e-016
		,4.125622767e-016
		,4.049307018e-016
		,3.982263113e-016
		,3.842484791e-016
		,3.573043398e-016
		,3.164006337e-016
		,2.910769795e-016
		,2.685799229e-016
		,2.422081085e-016
		,2.306625499e-016
		,2.165462813e-016
		,2.018028700e-016
		,1.880071910e-016
		,1.767812470e-016
		,1.692311661e-016
		,1.652654490e-016
		,1.636149941e-016
		,1.630289029e-016
		,1.628478485e-016
		,1.628129091e-016
		,1.628344960e-016
		,1.628837907e-016
		,1.629528050e-016
		,1.630405550e-016
		,1.631483235e-016
		,1.632779169e-016
		,1.634309074e-016
		,1.636082300e-016
		,1.638099709e-016
		,1.640353259e-016
		,1.642827355e-016
		,1.645502030e-016
		,1.648358762e-016
		,1.651393847e-016
		,1.654661529e-016
		,1.658439125e-016
		,1.663888723e-016
		,1.675676262e-016
		,4.422182823e-016
		,4.416330692e-016
		,4.342598490e-016
		,4.211811966e-016
		,4.184378248e-016
		,4.144804539e-016
		,4.096901147e-016
		,3.907445240e-016
		,3.630511647e-016
		,3.229685316e-016
		,3.061628354e-016
		,2.789296973e-016
		,2.546854922e-016
		,2.463575608e-016
		,2.328487398e-016
		,2.181172307e-016
		,2.031527243e-016
		,1.891488017e-016
		,1.776107773e-016
		,1.697109509e-016
		,1.654732950e-016
		,1.636778119e-016
		,1.630289162e-016
		,1.628203504e-016
		,1.627692852e-016
		,1.627773108e-016
		,1.628122852e-016
		,1.628649800e-016
		,1.629340003e-016
		,1.630206576e-016
		,1.631271383e-016
		,1.632557264e-016
		,1.634083579e-016
		,1.635863025e-016
		,1.637899547e-016
		,1.640187726e-016
		,1.642714147e-016
		,1.645461724e-016
		,1.648420725e-016
		,1.651623258e-016
		,1.655271735e-016
		,4.511003946e-016
		,4.491855011e-016
		,4.360138738e-016
		,4.345785971e-016
		,4.320067005e-016
		,4.296754536e-016
		,4.259027056e-016
		,4.164622300e-016
		,3.947984659e-016
		,3.493220453e-016
		,3.349437562e-016
		,3.198716582e-016
		,2.889831804e-016
		,2.674615605e-016
		,2.590176698e-016
		,2.478533572e-016
		,2.345587362e-016
		,2.195466181e-016
		,2.044560495e-016
		,1.902914340e-016
		,1.784698765e-016
		,1.702228828e-016
		,1.657041319e-016
		,1.637544760e-016
		,1.630389921e-016
		,1.628023222e-016
		,1.627365106e-016
		,1.627330536e-016
		,1.627562393e-016
		,1.627953974e-016
		,1.628485095e-016
		,1.629166443e-016
		,1.630020309e-016
		,1.631072953e-016
		,1.632350409e-016
		,1.633875144e-016
		,1.635663091e-016
		,1.637721404e-016
		,1.640047728e-016
		,1.642632205e-016
		,1.645465578e-016
		,4.587174809e-016
		,4.462400560e-016
		,4.457592134e-016
		,4.457914435e-016
		,4.437078219e-016
		,4.432634266e-016
		,4.416668597e-016
		,4.379226434e-016
		,4.202277881e-016
		,3.942438751e-016
		,3.496656739e-016
		,3.395490423e-016
		,3.258573778e-016
		,2.983276370e-016
		,2.787740968e-016
		,2.721184157e-016
		,2.614825075e-016
		,2.487536702e-016
		,2.361257347e-016
		,2.209207059e-016
		,2.057431658e-016
		,1.914422958e-016
		,1.793598414e-016
		,1.707669510e-016
		,1.659582138e-016
		,1.638443112e-016
		,1.630577499e-016
		,1.627918971e-016
		,1.627122249e-016
		,1.626989379e-016
		,1.627125355e-016
		,1.627407316e-016
		,1.627807606e-016
		,1.628332778e-016
		,1.629003052e-016
		,1.629844822e-016
		,1.630887018e-016
		,1.632158271e-016
		,1.633683974e-016
		,1.635483332e-016
		,1.637567020e-016
		,4.556194041e-016
		,4.530763404e-016
		,4.542204159e-016
		,4.553391244e-016
		,4.534963345e-016
		,4.538530695e-016
		,4.538464168e-016
		,4.525689310e-016
		,4.484923735e-016
		,4.256971929e-016
		,3.824930199e-016
		,3.601354355e-016
		,3.485376970e-016
		,3.344918092e-016
		,2.982679744e-016
		,2.862222097e-016
		,2.839280277e-016
		,2.748035705e-016
		,2.632820963e-016
		,2.501675867e-016
		,2.368338664e-016
		,2.222658599e-016
		,2.070133862e-016
		,1.926072128e-016
		,1.802717642e-016
		,1.713440248e-016
		,1.662355001e-016
		,1.639475733e-016
		,1.630841090e-016
		,1.627877587e-016
		,1.626943782e-016
		,1.626726442e-016
		,1.626784516e-016
		,1.626979095e-016
		,1.627274341e-016
		,1.627671818e-016
		,1.628188214e-016
		,1.628847736e-016
		,1.629679011e-016
		,1.630712995e-016
		,1.631980704e-016
		,4.594251746e-016
		,4.606981129e-016
		,4.617947158e-016
		,4.630143710e-016
		,4.626805000e-016
		,4.626695881e-016
		,4.636721868e-016
		,4.640993717e-016
		,4.630548778e-016
		,4.513045693e-016
		,4.282670962e-016
		,3.790992628e-016
		,3.694849000e-016
		,3.582508897e-016
		,3.441880575e-016
		,3.032019788e-016
		,2.899474820e-016
		,2.887256803e-016
		,2.868294103e-016
		,2.766810604e-016
		,2.647880107e-016
		,2.515298778e-016
		,2.373873523e-016
		,2.236145987e-016
		,2.082905195e-016
		,1.937692351e-016
		,1.812128378e-016
		,1.719525980e-016
		,1.665383333e-016
		,1.640637968e-016
		,1.631176715e-016
		,1.627886335e-016
		,1.626815807e-016
		,1.626522963e-016
		,1.626517253e-016
		,1.626642728e-016
		,1.626855042e-016
		,1.627150497e-016
		,1.627541621e-016
		,1.628049158e-016
		,1.628699263e-016
		,4.664167555e-016
		,4.673521781e-016
		,4.683942632e-016
		,4.698200477e-016
		,4.708728541e-016
		,4.703288429e-016
		,4.719169546e-016
		,4.733632822e-016
		,4.741132413e-016
		,4.731858954e-016
		,4.551673298e-016
		,4.171096615e-016
		,3.868992416e-016
		,3.785026219e-016
		,3.670455202e-016
		,3.531011995e-016
		,3.091983798e-016
		,2.972114453e-016
		,2.957775859e-016
		,2.903809812e-016
		,2.869734289e-016
		,2.782043977e-016
		,2.661118064e-016
		,2.527040374e-016
		,2.384367424e-016
		,2.244414908e-016
		,2.095575822e-016
		,1.949413239e-016
		,1.821743054e-016
		,1.725959941e-016
		,1.668657091e-016
		,1.641938619e-016
		,1.631579461e-016
		,1.627938782e-016
		,1.626727315e-016
		,1.626363567e-016
		,1.626305377e-016
		,1.626376232e-016
		,1.626523763e-016
		,1.626739044e-016
		,1.627030392e-016
		,1.666643857e-016
		,1.669300718e-016
		,1.672259234e-016
		,1.675635760e-016
		,1.679630008e-016
		,1.684591250e-016
		,1.691240257e-016
		,1.701451183e-016
		,1.720084651e-016
		,1.759779281e-016
		,1.854089394e-016
		,2.063452232e-016
		,2.409000091e-016
		,2.795692304e-016
		,3.128757500e-016
		,3.393923763e-016
		,3.598346892e-016
		,3.749280572e-016
		,3.858547749e-016
		,3.939363807e-016
		,4.000831142e-016
		,4.049395798e-016
		,4.089610644e-016
		,4.125225050e-016
		,4.160185665e-016
		,4.199059869e-016
		,4.245606270e-016
		,4.299315558e-016
		,4.354353329e-016
		,4.404138008e-016
		,4.445809116e-016
		,4.479709050e-016
		,4.507333493e-016
		,4.530190529e-016
		,4.549475979e-016
		,4.566064517e-016
		,4.580577867e-016
		,4.593459672e-016
		,4.605032629e-016
		,4.615536250e-016
		,4.625151738e-016
		,1.659544839e-016
		,1.661768798e-016
		,1.664104790e-016
		,1.666590155e-016
		,1.669278264e-016
		,1.672245896e-016
		,1.675622004e-016
		,1.679624577e-016
		,1.684700225e-016
		,1.691867821e-016
		,1.703968090e-016
		,1.729502217e-016
		,1.793453670e-016
		,1.953647385e-016
		,2.266726954e-016
		,2.670825730e-016
		,3.040330809e-016
		,3.333307861e-016
		,3.555694480e-016
		,3.718217306e-016
		,3.835283393e-016
		,3.921067987e-016
		,3.986035512e-016
		,4.037185499e-016
		,4.079365778e-016
		,4.116524558e-016
		,4.152747091e-016
		,4.192706905e-016
		,4.240255812e-016
		,4.294848111e-016
		,4.350510678e-016
		,4.400745101e-016
		,4.442772113e-016
		,4.476973756e-016
		,4.504865436e-016
		,4.527963072e-016
		,4.547460975e-016
		,4.564231154e-016
		,4.578898137e-016
		,4.591911037e-016
		,4.603597337e-016
		,1.652989395e-016
		,1.655083436e-016
		,1.657232630e-016
		,1.659445221e-016
		,1.661737815e-016
		,1.664135421e-016
		,1.666673576e-016
		,1.669404207e-016
		,1.672406318e-016
		,1.675814192e-016
		,1.679891017e-016
		,1.685256506e-016
		,1.693642379e-016
		,1.710463243e-016
		,1.753026127e-016
		,1.869114792e-016
		,2.133423093e-016
		,2.532821239e-016
		,2.932864196e-016
		,3.257252307e-016
		,3.502405890e-016
		,3.680088719e-016
		,3.807037466e-016
		,3.899350703e-016
		,3.968788355e-016
		,4.023123907e-016
		,4.067660715e-016
		,4.106616376e-016
		,4.144238947e-016
		,4.185308946e-016
		,4.233764984e-016
		,4.289130228e-016
		,4.345470946e-016
		,4.396295659e-016
		,4.438824814e-016
		,4.473449169e-016
		,4.501697367e-016
		,4.525097689e-016
		,4.544854624e-016
		,4.561848347e-016
		,4.576709791e-016
		,1.646595390e-016
		,1.648559903e-016
		,1.650624587e-016
		,1.652749271e-016
		,1.654923039e-016
		,1.657147784e-016
		,1.659433169e-016
		,1.661795522e-016
		,1.664258840e-016
		,1.666857931e-016
		,1.669645376e-016
		,1.672708217e-016
		,1.676213764e-016
		,1.680552490e-016
		,1.686823349e-016
		,1.698547859e-016
		,1.727560023e-016
		,1.810397702e-016
		,2.022687101e-016
		,2.396463518e-016
		,2.815153230e-016
		,3.169581887e-016
		,3.439373259e-016
		,3.634561733e-016
		,3.773355133e-016
		,3.873604652e-016
		,3.948436419e-016
		,4.006545621e-016
		,4.053816143e-016
		,4.094821790e-016
		,4.134027259e-016
		,4.176350859e-016
		,4.225836795e-016
		,4.282097550e-016
		,4.339245282e-016
		,4.390787006e-016
		,4.433935130e-016
		,4.469085984e-016
		,4.497781540e-016
		,4.521563888e-016
		,4.541649182e-016
		,1.641428841e-016
		,1.642485424e-016
		,1.644187685e-016
		,1.646146511e-016
		,1.648225657e-016
		,1.650375069e-016
		,1.652576414e-016
		,1.654825171e-016
		,1.657124705e-016
		,1.659484515e-016
		,1.661920332e-016
		,1.664455759e-016
		,1.667126473e-016
		,1.669990710e-016
		,1.673158568e-016
		,1.676884675e-016
		,1.681888391e-016
		,1.690512590e-016
		,1.710889432e-016
		,1.770033915e-016
		,1.935370227e-016
		,2.269775833e-016
		,2.693059664e-016
		,3.073363998e-016
		,3.367830196e-016
		,3.581790491e-016
		,3.734046864e-016
		,3.843717770e-016
		,3.925074454e-016
		,3.987724357e-016
		,4.038209420e-016
		,4.081546116e-016
		,4.122487056e-016
		,4.166142256e-016
		,4.216702742e-016
		,4.273900919e-016
		,4.331909799e-016
		,4.384235022e-016
		,4.428075900e-016
		,4.463830266e-016
		,4.493050571e-016
		,1.647505979e-016
		,1.640495311e-016
		,1.639327384e-016
		,1.640197380e-016
		,1.641810376e-016
		,1.643728186e-016
		,1.645796004e-016
		,1.647953645e-016
		,1.650175060e-016
		,1.652448953e-016
		,1.654772313e-016
		,1.657148321e-016
		,1.659585889e-016
		,1.662100346e-016
		,1.664715864e-016
		,1.667472060e-016
		,1.670443127e-016
		,1.673799430e-016
		,1.678023596e-016
		,1.684706432e-016
		,1.699495339e-016
		,1.742106316e-016
		,1.868602868e-016
		,2.157241633e-016
		,2.571395911e-016
		,2.971633698e-016
		,3.289652051e-016
		,3.522538531e-016
		,3.688983647e-016
		,3.809219552e-016
		,3.898290410e-016
		,3.966458826e-016
		,4.020864424e-016
		,4.066999229e-016
		,4.109956893e-016
		,4.155088966e-016
		,4.206778657e-016
		,4.264919694e-016
		,4.323776279e-016
		,4.376868730e-016
		,4.421391920e-016
		,1.750955328e-016
		,1.675313801e-016
		,1.647632919e-016
		,1.639116954e-016
		,1.637403399e-016
		,1.638026841e-016
		,1.639504381e-016
		,1.641338984e-016
		,1.643359471e-016
		,1.645497398e-016
		,1.647719958e-016
		,1.650009085e-016
		,1.652355090e-016
		,1.654754645e-016
		,1.657210166e-016
		,1.659729971e-016
		,1.662329564e-016
		,1.665035731e-016
		,1.667899147e-016
		,1.671036079e-016
		,1.674776992e-016
		,1.680221718e-016
		,1.691339815e-016
		,1.722480027e-016
		,1.818423797e-016
		,2.060682787e-016
		,2.453935151e-016
		,2.866969628e-016
		,3.206708187e-016
		,3.458274783e-016
		,3.638795255e-016
		,3.769909184e-016
		,3.867515484e-016
		,3.942177301e-016
		,4.001359336e-016
		,4.050946452e-016
		,4.096384520e-016
		,4.143301474e-016
		,4.196308658e-016
		,4.255494303e-016
		,4.315238646e-016
		,2.370306727e-016
		,1.994075676e-016
		,1.773777582e-016
		,1.680989315e-016
		,1.647852079e-016
		,1.637794072e-016
		,1.635640145e-016
		,1.636016448e-016
		,1.637323250e-016
		,1.639029004e-016
		,1.640957673e-016
		,1.643037247e-016
		,1.645230306e-016
		,1.647513001e-016
		,1.649869122e-016
		,1.652288579e-016
		,1.654767058e-016
		,1.657306087e-016
		,1.659913709e-016
		,1.662606977e-016
		,1.665420283e-016
		,1.668433972e-016
		,1.671878162e-016
		,1.676525502e-016
		,1.685200432e-016
		,1.708370876e-016
		,1.780985088e-016
		,1.980032176e-016
		,2.343479612e-016
		,2.761544141e-016
		,3.120398069e-016
		,3.390370630e-016
		,3.584819012e-016
		,3.726397642e-016
		,3.832571512e-016
		,3.914328188e-016
		,3.979098455e-016
		,4.032884621e-016
		,4.081394423e-016
		,4.130535452e-016
		,4.185177936e-016
		,3.186691952e-016
		,2.866673124e-016
		,2.450535816e-016
		,2.035396898e-016
		,1.778727242e-016
		,1.679645919e-016
		,1.646594463e-016
		,1.636480010e-016
		,1.634092987e-016
		,1.634230820e-016
		,1.635323807e-016
		,1.636855025e-016
		,1.638644644e-016
		,1.640620145e-016
		,1.642742860e-016
		,1.644985709e-016
		,1.647327367e-016
		,1.649751404e-016
		,1.652246633e-016
		,1.654807563e-016
		,1.657434989e-016
		,1.660137605e-016
		,1.662937547e-016
		,1.665890236e-016
		,1.669157871e-016
		,1.673290852e-016
		,1.680322400e-016
		,1.697928136e-016
		,1.753031605e-016
		,1.914036119e-016
		,2.241945030e-016
		,2.657198771e-016
		,3.031888531e-016
		,3.319588645e-016
		,3.528228279e-016
		,3.679985102e-016
		,3.794074868e-016
		,3.882777101e-016
		,3.953587675e-016
		,4.012260699e-016
		,4.064494309e-016
		,3.616865906e-016
		,3.452437032e-016
		,3.209048242e-016
		,2.820980709e-016
		,2.344524905e-016
		,1.959104250e-016
		,1.751998517e-016
		,1.674172673e-016
		,1.645600041e-016
		,1.635653035e-016
		,1.632861070e-016
		,1.632697932e-016
		,1.633547952e-016
		,1.634870012e-016
		,1.636478665e-016
		,1.638303554e-016
		,1.640309065e-016
		,1.642468981e-016
		,1.644759929e-016
		,1.647160957e-016
		,1.649654717e-016
		,1.652228716e-016
		,1.654876359e-016
		,1.657598332e-016
		,1.660406503e-016
		,1.663337864e-016
		,1.666507187e-016
		,1.670310957e-016
		,1.676228596e-016
		,1.689923958e-016
		,1.732003888e-016
		,1.860827567e-016
		,2.150465851e-016
		,2.555436933e-016
		,2.942296388e-016
		,3.246458242e-016
		,3.469437752e-016
		,3.631791229e-016
		,3.753316050e-016
		,3.848140583e-016
		,3.924729048e-016
		,3.846001854e-016
		,3.728094431e-016
		,3.550076673e-016
		,3.347423373e-016
		,3.038433640e-016
		,2.577036748e-016
		,2.126407108e-016
		,1.859573118e-016
		,1.738234856e-016
		,1.674717233e-016
		,1.645971640e-016
		,1.635217951e-016
		,1.631909797e-016
		,1.631420832e-016
		,1.632019036e-016
		,1.633114221e-016
		,1.634512114e-016
		,1.636146591e-016
		,1.637988801e-016
		,1.640017919e-016
		,1.642212944e-016
		,1.644551917e-016
		,1.647013575e-016
		,1.649579476e-016
		,1.652235875e-016
		,1.654975509e-016
		,1.657800784e-016
		,1.660733915e-016
		,1.663855150e-016
		,1.667452103e-016
		,1.672611361e-016
		,1.683540481e-016
		,1.715972865e-016
		,1.818342543e-016
		,2.069505222e-016
		,2.457483789e-016
		,2.852554791e-016
		,3.171691025e-016
		,3.408496734e-016
		,3.582070620e-016
		,3.711430292e-016
		,3.968740485e-016
		,3.907769030e-016
		,3.821661263e-016
		,3.693815928e-016
		,3.461217845e-016
		,3.095446395e-016
		,2.659684540e-016
		,2.250363219e-016
		,2.013982137e-016
		,1.844549542e-016
		,1.739975779e-016
		,1.677580400e-016
		,1.647021226e-016
		,1.635053638e-016
		,1.631192353e-016
		,1.630388679e-016
		,1.630742024e-016
		,1.631608521e-016
		,1.632782114e-016
		,1.634199821e-016
		,1.635841113e-016
		,1.637694027e-016
		,1.639744502e-016
		,1.641974259e-016
		,1.644362058e-016
		,1.646886204e-016
		,1.649527241e-016
		,1.652270523e-016
		,1.655109474e-016
		,1.658053540e-016
		,1.661156505e-016
		,1.664627018e-016
		,1.669269062e-016
		,1.678228937e-016
		,1.703519922e-016
		,1.784585593e-016
		,1.998975117e-016
		,2.364352266e-016
		,2.763356533e-016
		,3.096043382e-016
		,3.345741664e-016
		,4.137963864e-016
		,4.063803693e-016
		,3.967269455e-016
		,3.901901011e-016
		,3.766347182e-016
		,3.569380212e-016
		,3.149880067e-016
		,2.750689076e-016
		,2.457271984e-016
		,2.166738648e-016
		,1.986874789e-016
		,1.847770643e-016
		,1.747526832e-016
		,1.681465217e-016
		,1.648291856e-016
		,1.635098363e-016
		,1.630684622e-016
		,1.629578735e-016
		,1.629703517e-016
		,1.630353398e-016
		,1.631305403e-016
		,1.632496759e-016
		,1.633914153e-016
		,1.635555586e-016
		,1.637417068e-016
		,1.639488495e-016
		,1.641753543e-016
		,1.644191596e-016
		,1.646780657e-016
		,1.649500586e-016
		,1.652336887e-016
		,1.655287682e-016
		,1.658385436e-016
		,1.661779838e-016
		,1.666068459e-016
		,1.673618065e-016
		,1.693615898e-016
		,1.757773162e-016
		,1.938367903e-016
		,2.276850602e-016
		,2.675283817e-016
		,4.226919047e-016
		,4.207361491e-016
		,4.179964188e-016
		,4.137610232e-016
		,4.014707545e-016
		,3.807247106e-016
		,3.512445171e-016
		,3.270550482e-016
		,2.950218789e-016
		,2.586778036e-016
		,2.351732366e-016
		,2.130297943e-016
		,1.992755585e-016
		,1.861996499e-016
		,1.755560092e-016
		,1.685518686e-016
		,1.649796981e-016
		,1.635332122e-016
		,1.630356955e-016
		,1.628960876e-016
		,1.628877977e-016
		,1.629332258e-016
		,1.630078443e-016
		,1.631049895e-016
		,1.632237537e-016
		,1.633647885e-016
		,1.635287605e-016
		,1.637157486e-016
		,1.639250461e-016
		,1.641552032e-016
		,1.644042364e-016
		,1.646699489e-016
		,1.649503457e-016
		,1.652443007e-016
		,1.655533096e-016
		,1.658878154e-016
		,1.662922515e-016
		,1.669455325e-016
		,1.685519359e-016
		,1.736391239e-016
		,1.886884971e-016
		,4.344298847e-016
		,4.334980221e-016
		,4.262260280e-016
		,4.225859127e-016
		,4.167506873e-016
		,3.970099483e-016
		,3.839072404e-016
		,3.697619825e-016
		,3.376459384e-016
		,3.035119317e-016
		,2.741102512e-016
		,2.505731164e-016
		,2.283203256e-016
		,2.154320414e-016
		,2.010470016e-016
		,1.874166801e-016
		,1.763589168e-016
		,1.689857853e-016
		,1.651535090e-016
		,1.635736303e-016
		,1.630179406e-016
		,1.628503278e-016
		,1.628233925e-016
		,1.628517556e-016
		,1.629081716e-016
		,1.629851894e-016
		,1.630819528e-016
		,1.631996490e-016
		,1.633398215e-016
		,1.635036432e-016
		,1.636915586e-016
		,1.639031420e-016
		,1.641371380e-016
		,1.643916734e-016
		,1.646646299e-016
		,1.649542747e-016
		,1.652607366e-016
		,1.655909442e-016
		,1.659777803e-016
		,1.665569672e-016
		,1.678698389e-016
		,4.369870971e-016
		,4.363611733e-016
		,4.357535384e-016
		,4.345304005e-016
		,4.263586695e-016
		,4.100791030e-016
		,4.059986668e-016
		,3.982767966e-016
		,3.774810501e-016
		,3.522691100e-016
		,3.069555543e-016
		,2.892593836e-016
		,2.617171325e-016
		,2.439256628e-016
		,2.316952988e-016
		,2.173651219e-016
		,2.025134890e-016
		,1.885865975e-016
		,1.771823903e-016
		,1.694508924e-016
		,1.653501322e-016
		,1.636294107e-016
		,1.630126441e-016
		,1.628176260e-016
		,1.627738999e-016
		,1.627876933e-016
		,1.628286005e-016
		,1.628880583e-016
		,1.629649229e-016
		,1.630605547e-016
		,1.631770370e-016
		,1.633164036e-016
		,1.634802007e-016
		,1.636692028e-016
		,1.638832679e-016
		,1.641213620e-016
		,1.643817864e-016
		,1.646626966e-016
		,1.649633442e-016
		,1.652880055e-016
		,1.656607947e-016
		,4.455365296e-016
		,4.451906584e-016
		,4.448645457e-016
		,4.444203702e-016
		,4.275764382e-016
		,4.230035631e-016
		,4.206563598e-016
		,4.160099234e-016
		,4.069572566e-016
		,3.846575718e-016
		,3.480428161e-016
		,3.215903204e-016
		,3.043806802e-016
		,2.715581486e-016
		,2.564978931e-016
		,2.471393564e-016
		,2.337902963e-016
		,2.189346407e-016
		,2.038764164e-016
		,1.897419411e-016
		,1.780335629e-016
		,1.699465787e-016
		,1.655696613e-016
		,1.636991109e-016
		,1.630179588e-016
		,1.627953125e-016
		,1.627363416e-016
		,1.627377977e-016
		,1.627658335e-016
		,1.628105326e-016
		,1.628702088e-016
		,1.629460859e-016
		,1.630404276e-016
		,1.631557712e-016
		,1.632944904e-016
		,1.634584568e-016
		,1.636487673e-016
		,1.638655812e-016
		,1.641081375e-016
		,1.643750675e-016
		,1.646653662e-016
		,4.531737157e-016
		,4.531862078e-016
		,4.533010812e-016
		,4.433361841e-016
		,4.386318693e-016
		,4.354790187e-016
		,4.346176714e-016
		,4.323654631e-016
		,4.277122915e-016
		,4.105128049e-016
		,3.895023627e-016
		,3.389004491e-016
		,3.315527449e-016
		,3.180703164e-016
		,2.806622647e-016
		,2.693938692e-016
		,2.602242970e-016
		,2.484717940e-016
		,2.354880447e-016
		,2.203730562e-016
		,2.051817734e-016
		,1.909019981e-016
		,1.789056075e-016
		,1.704756601e-016
		,1.658114092e-016
		,1.637821766e-016
		,1.630322893e-016
		,1.627812704e-016
		,1.627081501e-016
		,1.626991153e-016
		,1.627166417e-016
		,1.627492739e-016
		,1.627946283e-016
		,1.628535766e-016
		,1.629282710e-016
		,1.630213946e-016
		,1.631357737e-016
		,1.632740652e-016
		,1.634384509e-016
		,1.636303576e-016
		,1.638502839e-016
		,4.601844990e-016
		,4.604528448e-016
		,4.543324525e-016
		,4.471625694e-016
		,4.483033294e-016
		,4.468551895e-016
		,4.460945185e-016
		,4.455108411e-016
		,4.434555058e-016
		,4.388334518e-016
		,4.152978048e-016
		,3.778830587e-016
		,3.494752044e-016
		,3.381137779e-016
		,3.233600418e-016
		,2.883379976e-016
		,2.808698639e-016
		,2.733628062e-016
		,2.624775814e-016
		,2.495944698e-016
		,2.367455476e-016
		,2.217338188e-016
		,2.064787307e-016
		,1.920499101e-016
		,1.798104643e-016
		,1.710347450e-016
		,1.660765001e-016
		,1.638778592e-016
		,1.630546549e-016
		,1.627739121e-016
		,1.626871686e-016
		,1.626691300e-016
		,1.626781212e-016
		,1.627010752e-016
		,1.627348163e-016
		,1.627797468e-016
		,1.628377164e-016
		,1.629112769e-016
		,1.630033517e-016
		,1.631169941e-016
		,1.632551251e-016
		,4.667366631e-016
		,4.628841644e-016
		,4.542354541e-016
		,4.555474674e-016
		,4.567595609e-016
		,4.567903522e-016
		,4.557705602e-016
		,4.562985485e-016
		,4.561124021e-016
		,4.542451319e-016
		,4.420689680e-016
		,4.245468487e-016
		,3.674632393e-016
		,3.592234254e-016
		,3.475035572e-016
		,3.330842520e-016
		,2.880286542e-016
		,2.873670521e-016
		,2.853447516e-016
		,2.759037707e-016
		,2.641810903e-016
		,2.510376971e-016
		,2.373383128e-016
		,2.230991276e-016
		,2.077180212e-016
		,1.932192548e-016
		,1.807345060e-016
		,1.716271787e-016
		,1.663640339e-016
		,1.639871441e-016
		,1.630841358e-016
		,1.627720235e-016
		,1.626717011e-016
		,1.626457760e-016
		,1.626478119e-016
		,1.626630877e-016
		,1.626875952e-016
		,1.627212168e-016
		,1.627654046e-016
		,1.628224069e-016
		,1.628949804e-016
		,4.693302427e-016
		,4.604324588e-016
		,4.616645788e-016
		,4.630449178e-016
		,4.642510178e-016
		,4.655019351e-016
		,4.641149983e-016
		,4.653694424e-016
		,4.663396951e-016
		,4.664527732e-016
		,4.645704583e-016
		,4.456954981e-016
		,4.133987091e-016
		,3.756142116e-016
		,3.683134868e-016
		,3.564014888e-016
		,3.423081456e-016
		,2.927548875e-016
		,2.924801905e-016
		,2.891499530e-016
		,2.879281916e-016
		,2.777083090e-016
		,2.657046786e-016
		,2.523550354e-016
		,2.379963007e-016
		,2.242812898e-016
		,2.090014116e-016
		,1.943802352e-016
		,1.816857913e-016
		,1.722468742e-016
		,1.666786956e-016
		,1.641091226e-016
		,1.631204986e-016
		,1.627746165e-016
		,1.626605399e-016
		,1.626273907e-016
		,1.626237050e-016
		,1.626329127e-016
		,1.626501728e-016
		,1.626748428e-016
		,1.627079504e-016
		,1.667525344e-016
		,1.670341601e-016
		,1.673518301e-016
		,1.677212434e-016
		,1.681679881e-016
		,1.687328752e-016
		,1.695070203e-016
		,1.707001821e-016
		,1.727244967e-016
		,1.769167059e-016
		,1.869837843e-016
		,2.088633230e-016
		,2.445611898e-016
		,2.827248318e-016
		,3.149294010e-016
		,3.409464157e-016
		,3.613619619e-016
		,3.764428622e-016
		,3.871729128e-016
		,3.952834376e-016
		,4.014539568e-016
		,4.062491844e-016
		,4.101688716e-016
		,4.136077703e-016
		,4.169518079e-016
		,4.206355825e-016
		,4.250111614e-016
		,4.301285717e-016
		,4.355403046e-016
		,4.405154669e-016
		,4.446991819e-016
		,4.480972216e-016
		,4.508522705e-016
		,4.531186129e-016
		,4.550251950e-016
		,4.566670887e-016
		,4.581077614e-016
		,4.593899101e-016
		,4.605441493e-016
		,4.615933134e-016
		,4.625547990e-016
		,1.660274641e-016
		,1.662546202e-016
		,1.664947829e-016
		,1.667525073e-016
		,1.670342018e-016
		,1.673496790e-016
		,1.677146147e-016
		,1.681561702e-016
		,1.687380135e-016
		,1.696017321e-016
		,1.711428768e-016
		,1.744549598e-016
		,1.825788952e-016
		,2.016766939e-016
		,2.353141302e-016
		,2.749603353e-016
		,3.097819808e-016
		,3.373393118e-016
		,3.584057054e-016
		,3.738875944e-016
		,3.850802116e-016
		,3.933239817e-016
		,3.995853715e-016
		,4.045271674e-016
		,4.086138009e-016
		,4.122268539e-016
		,4.157658884e-016
		,4.196914327e-016
		,4.243830246e-016
		,4.297894422e-016
		,4.353166708e-016
		,4.403100124e-016
		,4.444881002e-016
		,4.478872088e-016
		,4.506579060e-016
		,4.529515091e-016
		,4.548874255e-016
		,4.565526127e-016
		,4.580091361e-016
		,4.593015679e-016
		,4.604624036e-016
		,1.653739981e-016
		,1.655847996e-016
		,1.658014493e-016
		,1.660251295e-016
		,1.662579188e-016
		,1.665028465e-016
		,1.667642331e-016
		,1.670485074e-016
		,1.673656192e-016
		,1.677334426e-016
		,1.681861314e-016
		,1.688069427e-016
		,1.698265464e-016
		,1.719547680e-016
		,1.773649250e-016
		,1.915145752e-016
		,2.210742071e-016
		,2.616890904e-016
		,3.000324923e-016
		,3.305846757e-016
		,3.536856614e-016
		,3.704953953e-016
		,3.825588494e-016
		,3.913700319e-016
		,3.980249517e-016
		,4.032519476e-016
		,4.075521354e-016
		,4.113299070e-016
		,4.149995764e-016
		,4.190323732e-016
		,4.238169810e-016
		,4.293016974e-016
		,4.348906521e-016
		,4.399340528e-016
		,4.441536753e-016
		,4.475879305e-016
		,4.503888440e-016
		,4.527084664e-016
		,4.546665997e-016
		,4.563507480e-016
		,4.578236023e-016
		,1.647388361e-016
		,1.649370260e-016
		,1.651444778e-016
		,1.653576266e-016
		,1.655757039e-016
		,1.657992001e-016
		,1.660293990e-016
		,1.662683122e-016
		,1.665188513e-016
		,1.667852477e-016
		,1.670739388e-016
		,1.673958364e-016
		,1.677723059e-016
		,1.682539217e-016
		,1.689834501e-016
		,1.704141699e-016
		,1.740325209e-016
		,1.841659341e-016
		,2.085186906e-016
		,2.477405952e-016
		,2.887432650e-016
		,3.224588130e-016
		,3.479536154e-016
		,3.663889538e-016
		,3.795206214e-016
		,3.890386011e-016
		,3.961756435e-016
		,4.017443858e-016
		,4.062962089e-016
		,4.102652872e-016
		,4.140837981e-016
		,4.182345562e-016
		,4.231154784e-016
		,4.286826996e-016
		,4.343447993e-016
		,4.394522969e-016
		,4.437266151e-016
		,4.472069434e-016
		,4.500466856e-016
		,4.523992513e-016
		,4.543855747e-016
		,1.642135607e-016
		,1.643279071e-016
		,1.645025393e-016
		,1.647008108e-016
		,1.649099890e-016
		,1.651255426e-016
		,1.653459783e-016
		,1.655711379e-016
		,1.658016418e-016
		,1.660387443e-016
		,1.662843842e-016
		,1.665414167e-016
		,1.668141668e-016
		,1.671097864e-016
		,1.674420311e-016
		,1.678431543e-016
		,1.684047059e-016
		,1.694234432e-016
		,1.719139204e-016
		,1.791209117e-016
		,1.983686258e-016
		,2.343437421e-016
		,2.766669355e-016
		,3.132771313e-016
		,3.412812148e-016
		,3.615453915e-016
		,3.759361609e-016
		,3.863059655e-016
		,3.940228925e-016
		,3.999954237e-016
		,4.048373095e-016
		,4.090218328e-016
		,4.130053017e-016
		,4.172859668e-016
		,4.222734912e-016
		,4.279338336e-016
		,4.336805071e-016
		,4.388637007e-016
		,4.432037530e-016
		,4.467402702e-016
		,4.496279535e-016
		,1.647265911e-016
		,1.640924925e-016
		,1.640006983e-016
		,1.640989319e-016
		,1.642662818e-016
		,1.644616862e-016
		,1.646706182e-016
		,1.648875250e-016
		,1.651101463e-016
		,1.653376508e-016
		,1.655700218e-016
		,1.658078595e-016
		,1.660523592e-016
		,1.663054221e-016
		,1.665699810e-016
		,1.668508525e-016
		,1.671571681e-016
		,1.675101548e-016
		,1.679702598e-016
		,1.687362338e-016
		,1.705066584e-016
		,1.756592471e-016
		,1.904998911e-016
		,2.221566867e-016
		,2.643605461e-016
		,3.033561118e-016
		,3.338163483e-016
		,3.559930973e-016
		,3.717808123e-016
		,3.831464081e-016
		,3.915615583e-016
		,3.980220460e-016
		,4.032084540e-016
		,4.076407885e-016
		,4.118064819e-016
		,4.162248817e-016
		,4.213220125e-016
		,4.270772962e-016
		,4.329112583e-016
		,4.381742150e-016
		,4.425851861e-016
		,1.739321639e-016
		,1.672000325e-016
		,1.647089487e-016
		,1.639444530e-016
		,1.638030971e-016
		,1.638788675e-016
		,1.640341553e-016
		,1.642227535e-016
		,1.644283373e-016
		,1.646443776e-016
		,1.648678682e-016
		,1.650972844e-016
		,1.653319457e-016
		,1.655718058e-016
		,1.658173962e-016
		,1.660698623e-016
		,1.663311446e-016
		,1.666045104e-016
		,1.668961448e-016
		,1.672203541e-016
		,1.676179962e-016
		,1.682248738e-016
		,1.695278054e-016
		,1.732560119e-016
		,1.845459325e-016
		,2.115095752e-016
		,2.522707304e-016
		,2.929902556e-016
		,3.257577272e-016
		,3.498361761e-016
		,3.670601091e-016
		,3.795133103e-016
		,3.887397022e-016
		,3.957893200e-016
		,4.013971579e-016
		,4.061304526e-016
		,4.105121203e-016
		,4.150871987e-016
		,4.203023663e-016
		,4.261545453e-016
		,4.320743943e-016
		,2.303081806e-016
		,1.954008808e-016
		,1.760209209e-016
		,1.677508518e-016
		,1.647466411e-016
		,1.638234961e-016
		,1.636235720e-016
		,1.636721680e-016
		,1.638113009e-016
		,1.639887106e-016
		,1.641868956e-016
		,1.643986967e-016
		,1.646205387e-016
		,1.648502585e-016
		,1.650865013e-016
		,1.653285458e-016
		,1.655762551e-016
		,1.658300842e-016
		,1.660911736e-016
		,1.663616754e-016
		,1.666458011e-016
		,1.669533602e-016
		,1.673125083e-016
		,1.678176861e-016
		,1.688124578e-016
		,1.715545673e-016
		,1.800963576e-016
		,2.024937649e-016
		,2.407381023e-016
		,2.824245354e-016
		,3.172802316e-016
		,3.432298708e-016
		,3.618655860e-016
		,3.754083893e-016
		,3.855064817e-016
		,3.932358605e-016
		,3.993522835e-016
		,4.044563030e-016
		,4.091051187e-016
		,4.138723315e-016
		,4.192287406e-016
		,3.163716732e-016
		,2.830936766e-016
		,2.411960927e-016
		,2.017050803e-016
		,1.782474872e-016
		,1.682408454e-016
		,1.647321616e-016
		,1.636978139e-016
		,1.634604089e-016
		,1.634839433e-016
		,1.636035950e-016
		,1.637653382e-016
		,1.639514732e-016
		,1.641547372e-016
		,1.643712786e-016
		,1.645984816e-016
		,1.648343977e-016
		,1.650776357e-016
		,1.653273654e-016
		,1.655833433e-016
		,1.658459722e-016
		,1.661165036e-016
		,1.663977294e-016
		,1.666964228e-016
		,1.670322790e-016
		,1.674719989e-016
		,1.682610472e-016
		,1.703179190e-016
		,1.767820958e-016
		,1.950405709e-016
		,2.300062533e-016
		,2.718654749e-016
		,3.085138449e-016
		,3.362936812e-016
		,3.563373753e-016
		,3.709206062e-016
		,3.818662273e-016
		,3.903148925e-016
		,3.970140580e-016
		,4.025640501e-016
		,4.075421065e-016
		,3.588546712e-016
		,3.427739449e-016
		,3.206298956e-016
		,2.889625175e-016
		,2.462636976e-016
		,2.028272458e-016
		,1.772069761e-016
		,1.678845677e-016
		,1.646007343e-016
		,1.635817372e-016
		,1.633222635e-016
		,1.633199425e-016
		,1.634163538e-016
		,1.635583872e-016
		,1.637279786e-016
		,1.639180207e-016
		,1.641247827e-016
		,1.643455479e-016
		,1.645780105e-016
		,1.648202263e-016
		,1.650706989e-016
		,1.653284695e-016
		,1.655931996e-016
		,1.658653176e-016
		,1.661464897e-016
		,1.664413212e-016
		,1.667637128e-016
		,1.671613852e-016
		,1.678117408e-016
		,1.693895189e-016
		,1.743034130e-016
		,1.889885757e-016
		,2.202324809e-016
		,2.614848708e-016
		,2.995742626e-016
		,3.290909191e-016
		,3.505706992e-016
		,3.661858542e-016
		,3.779073469e-016
		,3.870340197e-016
		,3.943416713e-016
		,3.842980601e-016
		,3.751634324e-016
		,3.629785737e-016
		,3.453661448e-016
		,3.170109219e-016
		,2.751342199e-016
		,2.309730787e-016
		,1.935719016e-016
		,1.745659505e-016
		,1.674296243e-016
		,1.645551504e-016
		,1.635185470e-016
		,1.632149942e-016
		,1.631815564e-016
		,1.632528199e-016
		,1.633726167e-016
		,1.635221215e-016
		,1.636945988e-016
		,1.638868581e-016
		,1.640965349e-016
		,1.643213627e-016
		,1.645591258e-016
		,1.648078161e-016
		,1.650658132e-016
		,1.653320371e-016
		,1.656061058e-016
		,1.658886935e-016
		,1.661827367e-016
		,1.664980214e-016
		,1.668690110e-016
		,1.674252443e-016
		,1.686657321e-016
		,1.724302844e-016
		,1.841352854e-016
		,2.114995968e-016
		,2.514213907e-016
		,2.905685733e-016
		,3.216793217e-016
		,3.445880653e-016
		,3.612916845e-016
		,3.737653580e-016
		,4.014494917e-016
		,3.926742564e-016
		,3.845301866e-016
		,3.693502143e-016
		,3.549457240e-016
		,3.330043015e-016
		,2.976717077e-016
		,2.493412708e-016
		,2.080257377e-016
		,1.854701052e-016
		,1.738790228e-016
		,1.675673912e-016
		,1.646203352e-016
		,1.634916894e-016
		,1.631336037e-016
		,1.630680358e-016
		,1.631143097e-016
		,1.632110521e-016
		,1.633384184e-016
		,1.634900695e-016
		,1.636636205e-016
		,1.638574716e-016
		,1.640698663e-016
		,1.642987505e-016
		,1.645419308e-016
		,1.647973219e-016
		,1.650631863e-016
		,1.653383605e-016
		,1.656225829e-016
		,1.659174005e-016
		,1.662295289e-016
		,1.665839606e-016
		,1.670760991e-016
		,1.680775131e-016
		,1.709918796e-016
		,1.802722788e-016
		,2.038278354e-016
		,2.417884082e-016
		,2.815808752e-016
		,3.141350517e-016
		,3.383994365e-016
		,4.119176707e-016
		,4.020208134e-016
		,3.977378816e-016
		,3.916689535e-016
		,3.823927320e-016
		,3.674135233e-016
		,3.377236751e-016
		,3.046883322e-016
		,2.572962625e-016
		,2.210080279e-016
		,2.001366726e-016
		,1.846098622e-016
		,1.742054064e-016
		,1.679154565e-016
		,1.647418744e-016
		,1.634874552e-016
		,1.630739851e-016
		,1.629776543e-016
		,1.630002653e-016
		,1.630746375e-016
		,1.631794777e-016
		,1.633086250e-016
		,1.634604952e-016
		,1.636344770e-016
		,1.638297173e-016
		,1.640448032e-016
		,1.642778212e-016
		,1.645265918e-016
		,1.647889611e-016
		,1.650631111e-016
		,1.653479163e-016
		,1.656437044e-016
		,1.659547768e-016
		,1.662991672e-016
		,1.667475814e-016
		,1.675784616e-016
		,1.698636852e-016
		,1.772060966e-016
		,1.971876840e-016
		,2.326786276e-016
		,2.726746848e-016
		,4.209794281e-016
		,4.191161525e-016
		,4.160681415e-016
		,4.035486841e-016
		,3.983321728e-016
		,3.884974161e-016
		,3.734578553e-016
		,3.484771380e-016
		,3.019362256e-016
		,2.678095444e-016
		,2.406049341e-016
		,2.160969605e-016
		,1.981443839e-016
		,1.853549930e-016
		,1.750999596e-016
		,1.683182572e-016
		,1.648822006e-016
		,1.635024220e-016
		,1.630334537e-016
		,1.629076863e-016
		,1.629086077e-016
		,1.629624044e-016
		,1.630458042e-016
		,1.631524461e-016
		,1.632813195e-016
		,1.634327572e-016
		,1.636069854e-016
		,1.638035975e-016
		,1.640214410e-016
		,1.642587327e-016
		,1.645133199e-016
		,1.647830183e-016
		,1.650660223e-016
		,1.653616068e-016
		,1.656721043e-016
		,1.660102796e-016
		,1.664286961e-016
		,1.671371529e-016
		,1.689558375e-016
		,1.747683516e-016
		,1.915132630e-016
		,4.273344437e-016
		,4.264261614e-016
		,4.250198337e-016
		,4.230392740e-016
		,4.201287704e-016
		,4.143013922e-016
		,3.990282644e-016
		,3.703066950e-016
		,3.484057872e-016
		,3.167567037e-016
		,2.889101893e-016
		,2.537511866e-016
		,2.323960602e-016
		,2.133549852e-016
		,1.999972293e-016
		,1.867382792e-016
		,1.759170477e-016
		,1.687406085e-016
		,1.650450347e-016
		,1.635349309e-016
		,1.630090993e-016
		,1.628549981e-016
		,1.628363915e-016
		,1.628720057e-016
		,1.629360724e-016
		,1.630216161e-016
		,1.631278429e-016
		,1.632557737e-016
		,1.634066211e-016
		,1.635811090e-016
		,1.637791759e-016
		,1.639999101e-016
		,1.642416751e-016
		,1.645023779e-016
		,1.647798844e-016
		,1.650726872e-016
		,1.653815323e-016
		,1.657151182e-016
		,1.661124230e-016
		,1.667322633e-016
		,1.682038140e-016
		,4.378604085e-016
		,4.374123961e-016
		,4.368386966e-016
		,4.343741445e-016
		,4.271233650e-016
		,4.238951460e-016
		,4.132012349e-016
		,3.927135094e-016
		,3.835083894e-016
		,3.618296851e-016
		,3.341313848e-016
		,2.932372521e-016
		,2.718885822e-016
		,2.459447777e-016
		,2.295980225e-016
		,2.162540192e-016
		,2.017224738e-016
		,1.879655325e-016
		,1.767394811e-016
		,1.691914360e-016
		,1.652306266e-016
		,1.635832698e-016
		,1.629980653e-016
		,1.628165044e-016
		,1.627803807e-016
		,1.628003556e-016
		,1.628477064e-016
		,1.629144850e-016
		,1.629997494e-016
		,1.631048502e-016
		,1.632316978e-016
		,1.633820047e-016
		,1.635568685e-016
		,1.637565425e-016
		,1.639803658e-016
		,1.642268744e-016
		,1.644941098e-016
		,1.647802144e-016
		,1.650847944e-016
		,1.654134324e-016
		,1.657948145e-016
		,4.464560931e-016
		,4.400094177e-016
		,4.390849198e-016
		,4.384027369e-016
		,4.375118866e-016
		,4.361415713e-016
		,4.162653047e-016
		,4.118842309e-016
		,4.072789796e-016
		,3.983164200e-016
		,3.715305267e-016
		,3.382226180e-016
		,3.056565239e-016
		,2.875995355e-016
		,2.556195601e-016
		,2.454162740e-016
		,2.326478231e-016
		,2.181407358e-016
		,2.031955921e-016
		,1.891523246e-016
		,1.775816670e-016
		,1.696735567e-016
		,1.654382696e-016
		,1.636460235e-016
		,1.629982452e-016
		,1.627894557e-016
		,1.627374687e-016
		,1.627441736e-016
		,1.627775110e-016
		,1.628282789e-016
		,1.628950943e-016
		,1.629792955e-016
		,1.630831261e-016
		,1.632089657e-016
		,1.633588822e-016
		,1.635343077e-016
		,1.637358050e-016
		,1.639629861e-016
		,1.642146229e-016
		,1.644890675e-016
		,1.647853695e-016
		,4.480915848e-016
		,4.478202957e-016
		,4.476186341e-016
		,4.474255053e-016
		,4.472517899e-016
		,4.392772254e-016
		,4.273330270e-016
		,4.253565903e-016
		,4.225246367e-016
		,4.170234934e-016
		,3.999572551e-016
		,3.802081142e-016
		,3.355783054e-016
		,3.203800397e-016
		,3.028786471e-016
		,2.650658512e-016
		,2.581052872e-016
		,2.478430320e-016
		,2.346963375e-016
		,2.197211081e-016
		,2.045734426e-016
		,1.903212193e-016
		,1.784508718e-016
		,1.701861049e-016
		,1.656686466e-016
		,1.637221259e-016
		,1.630080436e-016
		,1.627713979e-016
		,1.627048955e-016
		,1.627003630e-016
		,1.627221875e-016
		,1.627597185e-016
		,1.628109336e-016
		,1.628769003e-016
		,1.629598666e-016
		,1.630625062e-016
		,1.631875106e-016
		,1.633372523e-016
		,1.635134824e-016
		,1.637170881e-016
		,1.639480055e-016
		,4.553172813e-016
		,4.552122636e-016
		,4.552743130e-016
		,4.554394678e-016
		,4.527627685e-016
		,4.404030823e-016
		,4.398017834e-016
		,4.379827942e-016
		,4.369425637e-016
		,4.341660428e-016
		,4.285225520e-016
		,4.049269152e-016
		,3.725340178e-016
		,3.383336041e-016
		,3.282110042e-016
		,3.150957464e-016
		,2.751995891e-016
		,2.711542584e-016
		,2.614131177e-016
		,2.490788417e-016
		,2.364132059e-016
		,2.211817897e-016
		,2.058907701e-016
		,1.914948497e-016
		,1.793435037e-016
		,1.707305036e-016
		,1.659214777e-016
		,1.638110171e-016
		,1.630261442e-016
		,1.627605481e-016
		,1.626803716e-016
		,1.626662060e-016
		,1.626786706e-016
		,1.627055017e-016
		,1.627439237e-016
		,1.627945759e-016
		,1.628594732e-016
		,1.629412664e-016
		,1.630428914e-016
		,1.631672899e-016
		,1.633171221e-016
		,4.619996678e-016
		,4.620148894e-016
		,4.622402649e-016
		,4.626556223e-016
		,4.484158492e-016
		,4.498045478e-016
		,4.504673022e-016
		,4.485363273e-016
		,4.487124150e-016
		,4.478896703e-016
		,4.452150094e-016
		,4.329316686e-016
		,4.169269915e-016
		,3.594662135e-016
		,3.486523062e-016
		,3.364750367e-016
		,3.175780270e-016
		,2.827920496e-016
		,2.828539973e-016
		,2.746965388e-016
		,2.635458283e-016
		,2.505487324e-016
		,2.373142060e-016
		,2.225532586e-016
		,2.071939496e-016
		,1.926633904e-016
		,1.802594109e-016
		,1.713059843e-016
		,1.661971135e-016
		,1.639129132e-016
		,1.630515517e-016
		,1.627556376e-016
		,1.626619174e-016
		,1.626394472e-016
		,1.626442996e-016
		,1.626626045e-016
		,1.626907696e-016
		,1.627289307e-016
		,1.627787346e-016
		,1.628425920e-016
		,1.629233718e-016
		,4.680418684e-016
		,4.681351733e-016
		,4.685864720e-016
		,4.567590666e-016
		,4.566706556e-016
		,4.580305274e-016
		,4.593911269e-016
		,4.580596056e-016
		,4.584691751e-016
		,4.589335866e-016
		,4.583615715e-016
		,4.556947067e-016
		,4.365256233e-016
		,4.084205313e-016
		,3.657657955e-016
		,3.580797134e-016
		,3.457539917e-016
		,3.241615064e-016
		,2.860277525e-016
		,2.881381939e-016
		,2.866934075e-016
		,2.769677274e-016
		,2.652276408e-016
		,2.520060708e-016
		,2.379008136e-016
		,2.239358432e-016
		,2.084612450e-016
		,1.938300435e-016
		,1.811991902e-016
		,1.719125929e-016
		,1.664976143e-016
		,1.640276302e-016
		,1.630838551e-016
		,1.627554747e-016
		,1.626481746e-016
		,1.626182645e-016
		,1.626168699e-016
		,1.626284251e-016
		,1.626484937e-016
		,1.626766845e-016
		,1.627142257e-016
		,1.668575465e-016
		,1.671582660e-016
		,1.675040384e-016
		,1.679154201e-016
		,1.684225895e-016
		,1.690832639e-016
		,1.700072623e-016
		,1.713822234e-016
		,1.736716241e-016
		,1.776660513e-016
		,1.852514182e-016
		,2.021969416e-016
		,2.361766512e-016
		,2.746187137e-016
		,3.080555276e-016
		,3.358931631e-016
		,3.583747819e-016
		,3.750746512e-016
		,3.868050807e-016
		,3.958557813e-016
		,4.026643497e-016
		,4.079382777e-016
		,4.121426046e-016
		,4.155766888e-016
		,4.185639172e-016
		,4.215155431e-016
		,4.248880649e-016
		,4.294555140e-016
		,4.347383355e-016
		,4.398186767e-016
		,4.441614678e-016
		,4.476613536e-016
		,4.504508832e-016
		,4.527299999e-016
		,4.546549711e-016
		,4.563199249e-016
		,4.577867703e-016
		,4.591028757e-016
		,4.603062724e-016
		,4.614158392e-016
		,4.624276574e-016
		,1.661089081e-016
		,1.663413740e-016
		,1.665891648e-016
		,1.668578699e-016
		,1.671556699e-016
		,1.674947677e-016
		,1.678940889e-016
		,1.683903357e-016
		,1.690575181e-016
		,1.700727061e-016
		,1.718998955e-016
		,1.757867489e-016
		,1.850973167e-016
		,2.065128753e-016
		,2.418007672e-016
		,2.805453769e-016
		,3.135686782e-016
		,3.401678578e-016
		,3.607285390e-016
		,3.758354911e-016
		,3.866597031e-016
		,3.947275244e-016
		,4.008303261e-016
		,4.056274934e-016
		,4.095861230e-016
		,4.130799248e-016
		,4.164963424e-016
		,4.202797892e-016
		,4.247940697e-016
		,4.300485705e-016
		,4.355082706e-016
		,4.404788556e-016
		,4.446473616e-016
		,4.480359913e-016
		,4.507914880e-016
		,4.530675125e-016
		,4.549881250e-016
		,4.566422860e-016
		,4.580913098e-016
		,4.593785379e-016
		,4.605355900e-016
		,1.654545203e-016
		,1.656664046e-016
		,1.658847356e-016
		,1.661110839e-016
		,1.663479898e-016
		,1.665991372e-016
		,1.668698972e-016
		,1.671679264e-016
		,1.675058894e-016
		,1.679078689e-016
		,1.684215320e-016
		,1.691618424e-016
		,1.704420413e-016
		,1.731974578e-016
		,1.801371511e-016
		,1.972539046e-016
		,2.295901893e-016
		,2.699828262e-016
		,3.062993337e-016
		,3.349801264e-016
		,3.567742244e-016
		,3.727227514e-016
		,3.842228847e-016
		,3.926617632e-016
		,3.990580082e-016
		,4.040975110e-016
		,4.082570757e-016
		,4.119262510e-016
		,4.155099068e-016
		,4.194725689e-016
		,4.241978844e-016
		,4.296338280e-016
		,4.351828709e-016
		,4.401929479e-016
		,4.443845181e-016
		,4.477949491e-016
		,4.505755331e-016
		,4.528778266e-016
		,4.548211393e-016
		,4.564924932e-016
		,4.579541911e-016
		,1.648228766e-016
		,1.650220312e-016
		,1.652299110e-016
		,1.654433834e-016
		,1.656620075e-016
		,1.658865859e-016
		,1.661187487e-016
		,1.663609477e-016
		,1.666167364e-016
		,1.668913134e-016
		,1.671927839e-016
		,1.675350712e-016
		,1.679460275e-016
		,1.684926043e-016
		,1.693638074e-016
		,1.711512805e-016
		,1.757299981e-016
		,1.881450417e-016
		,2.157418013e-016
		,2.561729275e-016
		,2.957851036e-016
		,3.276244409e-016
		,3.516443059e-016
		,3.690572882e-016
		,3.815084272e-016
		,3.905726913e-016
		,3.973991438e-016
		,4.027472467e-016
		,4.071361152e-016
		,4.109806277e-016
		,4.147013498e-016
		,4.187736895e-016
		,4.235900572e-016
		,4.291020541e-016
		,4.347156480e-016
		,4.397808899e-016
		,4.440190862e-016
		,4.474688022e-016
		,4.502825598e-016
		,4.526129306e-016
		,4.545801565e-016
		,1.642905887e-016
		,1.644120820e-016
		,1.645900187e-016
		,1.647898315e-016
		,1.649996328e-016
		,1.652153505e-016
		,1.654358244e-016
		,1.656611887e-016
		,1.658923584e-016
		,1.661309207e-016
		,1.663792384e-016
		,1.666407699e-016
		,1.669208006e-016
		,1.672282208e-016
		,1.675804697e-016
		,1.680190297e-016
		,1.686620799e-016
		,1.698899312e-016
		,1.729768108e-016
		,1.818017433e-016
		,2.040689861e-016
		,2.422525834e-016
		,2.840483835e-016
		,3.190162975e-016
		,3.455207157e-016
		,3.646597000e-016
		,3.782580499e-016
		,3.880840062e-016
		,3.954283591e-016
		,4.011413925e-016
		,4.057973154e-016
		,4.098439400e-016
		,4.137215794e-016
		,4.179182714e-016
		,4.228363172e-016
		,4.284359735e-016
		,4.341278816e-016
		,4.392621311e-016
		,4.435594117e-016
		,4.470589864e-016
		,4.499148095e-016
		,1.647217468e-016
		,1.641450164e-016
		,1.640748482e-016
		,1.641826214e-016
		,1.643548993e-016
		,1.645530169e-016
		,1.647633508e-016
		,1.649808277e-016
		,1.652035303e-016
		,1.654309241e-016
		,1.656632774e-016
		,1.659014817e-016
		,1.661470665e-016
		,1.664023473e-016
		,1.666708843e-016
		,1.669585748e-016
		,1.672767669e-016
		,1.676522199e-016
		,1.681614699e-016
		,1.690552897e-016
		,1.712038200e-016
		,1.774748031e-016
		,1.948418357e-016
		,2.292148915e-016
		,2.717544816e-016
		,3.094636399e-016
		,3.384978895e-016
		,3.595291749e-016
		,3.744556405e-016
		,3.851913962e-016
		,3.931581916e-016
		,3.993034907e-016
		,4.042675325e-016
		,4.085406212e-016
		,4.125897858e-016
		,4.169203551e-016
		,4.219477985e-016
		,4.276432666e-016
		,4.334228229e-016
		,4.386361296e-016
		,4.430025213e-016
		,1.730084340e-016
		,1.669422099e-016
		,1.646743514e-016
		,1.639848096e-016
		,1.638711101e-016
		,1.639591791e-016
		,1.641213117e-016
		,1.643142327e-016
		,1.645225143e-016
		,1.647400801e-016
		,1.649642368e-016
		,1.651937628e-016
		,1.654282681e-016
		,1.656679834e-016
		,1.659137416e-016
		,1.661670231e-016
		,1.664302158e-016
		,1.667073011e-016
		,1.670058742e-016
		,1.673436893e-016
		,1.677717240e-016
		,1.684590623e-016
		,1.700066674e-016
		,1.745032041e-016
		,1.877874591e-016
		,2.175790858e-016
		,2.594279718e-016
		,2.992870574e-016
		,3.307483872e-016
		,3.537145080e-016
		,3.700770156e-016
		,3.818569898e-016
		,3.905672604e-016
		,3.972361324e-016
		,4.025698985e-016
		,4.071074106e-016
		,4.113489186e-016
		,4.158227013e-016
		,4.209622534e-016
		,4.267537135e-016
		,4.326212121e-016
		,2.239299748e-016
		,1.917642714e-016
		,1.746865419e-016
		,1.673827473e-016
		,1.646890258e-016
		,1.638538253e-016
		,1.636847490e-016
		,1.637471479e-016
		,1.638942957e-016
		,1.640777337e-016
		,1.642803110e-016
		,1.644951104e-016
		,1.647187629e-016
		,1.649493570e-016
		,1.651858209e-016
		,1.654277272e-016
		,1.656752325e-016
		,1.659290998e-016
		,1.661908322e-016
		,1.664630936e-016
		,1.667510499e-016
		,1.670667252e-016
		,1.674448521e-016
		,1.680016717e-016
		,1.691576774e-016
		,1.724289221e-016
		,1.824932316e-016
		,2.075658198e-016
		,2.474780987e-016
		,2.887682135e-016
		,3.224731436e-016
		,3.473450498e-016
		,3.651528177e-016
		,3.780414437e-016
		,3.875974284e-016
		,3.948918553e-016
		,4.006775435e-016
		,4.055387663e-016
		,4.100121530e-016
		,4.146530892e-016
		,4.199170901e-016
		,3.111626014e-016
		,2.766610634e-016
		,2.347898057e-016
		,1.981344480e-016
		,1.770206797e-016
		,1.679790931e-016
		,1.647467591e-016
		,1.637446433e-016
		,1.635163269e-016
		,1.635509010e-016
		,1.636795189e-016
		,1.638490669e-016
		,1.640415203e-016
		,1.642496231e-016
		,1.644695917e-016
		,1.646989651e-016
		,1.649360244e-016
		,1.651796531e-016
		,1.654293196e-016
		,1.656850884e-016
		,1.659476922e-016
		,1.662188021e-016
		,1.665018844e-016
		,1.668052253e-016
		,1.671528763e-016
		,1.676261799e-016
		,1.685231361e-016
		,1.709467779e-016
		,1.785514635e-016
		,1.991869642e-016
		,2.362074158e-016
		,2.781395684e-016
		,3.138326836e-016
		,3.405742405e-016
		,3.597992488e-016
		,3.737728226e-016
		,3.842095083e-016
		,3.922089381e-016
		,3.985330634e-016
		,4.037911389e-016
		,4.085518633e-016
		,3.586761738e-016
		,3.420087266e-016
		,3.188767132e-016
		,2.864235063e-016
		,2.437996453e-016
		,2.037157880e-016
		,1.788734885e-016
		,1.682887903e-016
		,1.646778078e-016
		,1.636260658e-016
		,1.633662786e-016
		,1.633757514e-016
		,1.634828241e-016
		,1.636342376e-016
		,1.638119248e-016
		,1.640087373e-016
		,1.642208491e-016
		,1.644455315e-016
		,1.646805822e-016
		,1.649242618e-016
		,1.651753431e-016
		,1.654331734e-016
		,1.656977403e-016
		,1.659698543e-016
		,1.662516978e-016
		,1.665489908e-016
		,1.668785794e-016
		,1.672982543e-016
		,1.680217825e-016
		,1.698558941e-016
		,1.756156414e-016
		,1.923232406e-016
		,2.258229640e-016
		,2.675960032e-016
		,3.049505070e-016
		,3.335018488e-016
		,3.541520601e-016
		,3.691641117e-016
		,3.804333951e-016
		,3.891531476e-016
		,3.960790728e-016
		,3.809333649e-016
		,3.718856731e-016
		,3.600683553e-016
		,3.441926030e-016
		,3.216633505e-016
		,2.893265706e-016
		,2.445104761e-016
		,2.000461300e-016
		,1.768171597e-016
		,1.678239801e-016
		,1.645550189e-016
		,1.635297926e-016
		,1.632443722e-016
		,1.632258037e-016
		,1.633086454e-016
		,1.634386071e-016
		,1.635974909e-016
		,1.637784362e-016
		,1.639779904e-016
		,1.641935814e-016
		,1.644228607e-016
		,1.646636729e-016
		,1.649141911e-016
		,1.651730560e-016
		,1.654395128e-016
		,1.657135291e-016
		,1.659962432e-016
		,1.662914242e-016
		,1.666109994e-016
		,1.669964375e-016
		,1.676028174e-016
		,1.690240851e-016
		,1.734134187e-016
		,1.867867025e-016
		,2.164488646e-016
		,2.572964434e-016
		,2.959409300e-016
		,3.261844736e-016
		,3.482813596e-016
		,3.643462062e-016
		,3.763807000e-016
		,3.989459307e-016
		,3.933182707e-016
		,3.861597857e-016
		,3.767679104e-016
		,3.631338229e-016
		,3.422553491e-016
		,3.087278263e-016
		,2.703094325e-016
		,2.256684698e-016
		,1.910666883e-016
		,1.741400758e-016
		,1.675159773e-016
		,1.645598935e-016
		,1.634802229e-016
		,1.631519677e-016
		,1.631015440e-016
		,1.631590350e-016
		,1.632660378e-016
		,1.634033888e-016
		,1.635646661e-016
		,1.637471415e-016
		,1.639488483e-016
		,1.641677483e-016
		,1.644016498e-016
		,1.646483763e-016
		,1.649059973e-016
		,1.651730414e-016
		,1.654486605e-016
		,1.657330415e-016
		,1.660283771e-016
		,1.663430301e-016
		,1.667069755e-016
		,1.672338017e-016
		,1.683638539e-016
		,1.717395378e-016
		,1.823661765e-016
		,2.081392894e-016
		,2.473687235e-016
		,2.869039682e-016
		,3.186867944e-016
		,3.421982618e-016
		,4.124406387e-016
		,4.060760698e-016
		,4.008647657e-016
		,3.944828853e-016
		,3.809041189e-016
		,3.702347867e-016
		,3.547888598e-016
		,3.288433033e-016
		,2.900644632e-016
		,2.407054713e-016
		,2.035332878e-016
		,1.852644434e-016
		,1.739619689e-016
		,1.676722330e-016
		,1.646554464e-016
		,1.634684341e-016
		,1.630829896e-016
		,1.630011358e-016
		,1.630342575e-016
		,1.631183808e-016
		,1.632331164e-016
		,1.633723370e-016
		,1.635341594e-016
		,1.637175442e-016
		,1.639212125e-016
		,1.641434126e-016
		,1.643820362e-016
		,1.646348881e-016
		,1.648999292e-016
		,1.651756054e-016
		,1.654611622e-016
		,1.657575011e-016
		,1.660701878e-016
		,1.664209625e-016
		,1.668936296e-016
		,1.678168622e-016
		,1.704433816e-016
		,1.788554244e-016
		,2.008906976e-016
		,2.379177065e-016
		,2.779151774e-016
		,4.215077898e-016
		,4.163036465e-016
		,4.072668166e-016
		,4.039802266e-016
		,4.002602531e-016
		,3.938892895e-016
		,3.836315015e-016
		,3.635175437e-016
		,3.314953669e-016
		,2.957739858e-016
		,2.493515093e-016
		,2.199657083e-016
		,1.988745992e-016
		,1.846224052e-016
		,1.745643306e-016
		,1.680799142e-016
		,1.647882618e-016
		,1.634748681e-016
		,1.630340730e-016
		,1.629222921e-016
		,1.629328175e-016
		,1.629954554e-016
		,1.630880772e-016
		,1.632045400e-016
		,1.633436576e-016
		,1.635053915e-016
		,1.636895030e-016
		,1.638951170e-016
		,1.641206949e-016
		,1.643642115e-016
		,1.646234306e-016
		,1.648962944e-016
		,1.651812381e-016
		,1.654780389e-016
		,1.657900153e-016
		,1.661326903e-016
		,1.665684443e-016
		,1.673438438e-016
		,1.694159398e-016
		,1.760695929e-016
		,1.946551833e-016
		,4.299923893e-016
		,4.254484244e-016
		,4.236444680e-016
		,4.207809547e-016
		,4.104399327e-016
		,4.025056497e-016
		,3.970912162e-016
		,3.854160901e-016
		,3.695882172e-016
		,3.377943906e-016
		,2.919846066e-016
		,2.653087113e-016
		,2.360318435e-016
		,2.151470464e-016
		,1.983012622e-016
		,1.859141190e-016
		,1.754483379e-016
		,1.684963524e-016
		,1.649404712e-016
		,1.634991332e-016
		,1.630024420e-016
		,1.628619963e-016
		,1.628520754e-016
		,1.628954331e-016
		,1.629676780e-016
		,1.630622385e-016
		,1.631783110e-016
		,1.633166785e-016
		,1.634781644e-016
		,1.636630073e-016
		,1.638706567e-016
		,1.640997514e-016
		,1.643483739e-016
		,1.646143088e-016
		,1.648955130e-016
		,1.651908386e-016
		,1.655017521e-016
		,1.658389811e-016
		,1.662491635e-016
		,1.669182154e-016
		,1.685788682e-016
		,4.308592617e-016
		,4.303720717e-016
		,4.297315243e-016
		,4.288250713e-016
		,4.274927211e-016
		,4.255382876e-016
		,4.223833798e-016
		,4.142724328e-016
		,3.930486757e-016
		,3.615694393e-016
		,3.403921210e-016
		,3.100072493e-016
		,2.801704217e-016
		,2.526698774e-016
		,2.295237874e-016
		,2.144244404e-016
		,2.007064727e-016
		,1.872752843e-016
		,1.762805973e-016
		,1.689345025e-016
		,1.651145579e-016
		,1.635397175e-016
		,1.629852438e-016
		,1.628171090e-016
		,1.627888670e-016
		,1.628154731e-016
		,1.628698025e-016
		,1.629444621e-016
		,1.630386574e-016
		,1.631536621e-016
		,1.632911391e-016
		,1.634524208e-016
		,1.636381097e-016
		,1.638479312e-016
		,1.640807650e-016
		,1.643347823e-016
		,1.646078877e-016
		,1.648984093e-016
		,1.652063488e-016
		,1.655388616e-016
		,1.659301179e-016
		,4.408184119e-016
		,4.404650873e-016
		,4.401319392e-016
		,4.397647435e-016
		,4.392247176e-016
		,4.338199544e-016
		,4.290980830e-016
		,4.241356086e-016
		,4.048145204e-016
		,3.934666594e-016
		,3.826277330e-016
		,3.540615183e-016
		,3.256494953e-016
		,2.872629983e-016
		,2.698810626e-016
		,2.419374516e-016
		,2.307588246e-016
		,2.170553598e-016
		,2.023905349e-016
		,1.885101630e-016
		,1.771207131e-016
		,1.694013264e-016
		,1.653108753e-016
		,1.635951638e-016
		,1.629799753e-016
		,1.627847293e-016
		,1.627399894e-016
		,1.627523243e-016
		,1.627914493e-016
		,1.628488421e-016
		,1.629233812e-016
		,1.630164704e-016
		,1.631302698e-016
		,1.632669410e-016
		,1.634281531e-016
		,1.636148663e-016
		,1.638270868e-016
		,1.640639268e-016
		,1.643237799e-016
		,1.646049247e-016
		,1.649064908e-016
		,4.489442314e-016
		,4.488230190e-016
		,4.461578985e-016
		,4.417282215e-016
		,4.412879121e-016
		,4.407693525e-016
		,4.399790254e-016
		,4.311675998e-016
		,4.145393378e-016
		,4.115181079e-016
		,4.066131928e-016
		,3.919662249e-016
		,3.687961585e-016
		,3.261914215e-016
		,3.043002717e-016
		,2.827903713e-016
		,2.538592573e-016
		,2.464229737e-016
		,2.335791480e-016
		,2.189071643e-016
		,2.038694932e-016
		,1.897100741e-016
		,1.779826016e-016
		,1.698985066e-016
		,1.655295334e-016
		,1.636641410e-016
		,1.629848707e-016
		,1.627622774e-016
		,1.627025203e-016
		,1.627027750e-016
		,1.627293138e-016
		,1.627722445e-016
		,1.628298874e-016
		,1.629034734e-016
		,1.629953089e-016
		,1.631079963e-016
		,1.632440169e-016
		,1.634053865e-016
		,1.635933527e-016
		,1.638082546e-016
		,1.640495783e-016
		,4.505507537e-016
		,4.502017499e-016
		,4.499702638e-016
		,4.499380859e-016
		,4.498658423e-016
		,4.498761246e-016
		,4.498731418e-016
		,4.320564305e-016
		,4.290296900e-016
		,4.277109924e-016
		,4.243008204e-016
		,4.175525451e-016
		,3.935949339e-016
		,3.660228998e-016
		,3.306426706e-016
		,3.190447038e-016
		,2.938846934e-016
		,2.668600280e-016
		,2.595322052e-016
		,2.485022480e-016
		,2.355966386e-016
		,2.204999722e-016
		,2.052539009e-016
		,1.909013515e-016
		,1.788646009e-016
		,1.704285911e-016
		,1.657700641e-016
		,1.637461689e-016
		,1.629984281e-016
		,1.627476733e-016
		,1.626739530e-016
		,1.626639291e-016
		,1.626801951e-016
		,1.627113289e-016
		,1.627549368e-016
		,1.628118826e-016
		,1.628843332e-016
		,1.629749841e-016
		,1.630867434e-016
		,1.632223512e-016
		,1.633841298e-016
		,4.575171765e-016
		,4.572557236e-016
		,4.571541435e-016
		,4.572393838e-016
		,4.574507100e-016
		,4.578175269e-016
		,4.463898887e-016
		,4.432997763e-016
		,4.408886934e-016
		,4.405205063e-016
		,4.392955686e-016
		,4.358096751e-016
		,4.234337172e-016
		,4.051118288e-016
		,3.544400211e-016
		,3.374405870e-016
		,3.247812816e-016
		,3.042077008e-016
		,2.782478250e-016
		,2.727373096e-016
		,2.625209005e-016
		,2.498509375e-016
		,2.371303002e-016
		,2.219647162e-016
		,2.066014042e-016
		,1.920702187e-016
		,1.797783402e-016
		,1.709878648e-016
		,1.660337457e-016
		,1.638406007e-016
		,1.630197070e-016
		,1.627393832e-016
		,1.626522003e-016
		,1.626333224e-016
		,1.626412435e-016
		,1.626629195e-016
		,1.626951651e-016
		,1.627383761e-016
		,1.627943812e-016
		,1.628657358e-016
		,1.629553856e-016
		,4.640170684e-016
		,4.638718181e-016
		,4.640222321e-016
		,4.642020130e-016
		,4.646208428e-016
		,4.566184553e-016
		,4.510895844e-016
		,4.525741712e-016
		,4.517310430e-016
		,4.511780692e-016
		,4.512562298e-016
		,4.500899481e-016
		,4.465821900e-016
		,4.268732556e-016
		,4.032139724e-016
		,3.555021063e-016
		,3.475091481e-016
		,3.347824291e-016
		,3.050084320e-016
		,2.849231740e-016
		,2.845125367e-016
		,2.758844093e-016
		,2.645637096e-016
		,2.514801954e-016
		,2.378452202e-016
		,2.233881237e-016
		,2.078801301e-016
		,1.932633998e-016
		,1.807075022e-016
		,1.715801121e-016
		,1.663201456e-016
		,1.639482058e-016
		,1.630478374e-016
		,1.627362450e-016
		,1.626355938e-016
		,1.626089455e-016
		,1.626100498e-016
		,1.626242158e-016
		,1.626474350e-016
		,1.626795760e-016
		,1.627220633e-016
		,1.669791386e-016
		,1.673052241e-016
		,1.676880228e-016
		,1.681532166e-016
		,1.687442934e-016
		,1.695404737e-016
		,1.706621441e-016
		,1.723674547e-016
		,1.752038263e-016
		,1.795412184e-016
		,1.864642738e-016
		,1.964648191e-016
		,2.197894863e-016
		,2.581526808e-016
		,2.908012329e-016
		,3.224342878e-016
		,3.492559210e-016
		,3.694632722e-016
		,3.843451513e-016
		,3.950033788e-016
		,4.029445172e-016
		,4.090927152e-016
		,4.139615423e-016
		,4.178697648e-016
		,4.208035882e-016
		,4.228871121e-016
		,4.258029193e-016
		,4.295838396e-016
		,4.339001431e-016
		,4.384093654e-016
		,4.425922828e-016
		,4.461939794e-016
		,4.492181006e-016
		,4.517446845e-016
		,4.538728318e-016
		,4.556908094e-016
		,4.572681737e-016
		,4.586578385e-016
		,4.599000510e-016
		,4.610260663e-016
		,4.620608753e-016
		,1.661967355e-016
		,1.664355820e-016
		,1.666928856e-016
		,1.669757710e-016
		,1.672942265e-016
		,1.676640988e-016
		,1.681121678e-016
		,1.686872747e-016
		,1.694851966e-016
		,1.707236303e-016
		,1.727291735e-016
		,1.764989304e-016
		,1.843236247e-016
		,2.033527893e-016
		,2.382662427e-016
		,2.772785578e-016
		,3.106919219e-016
		,3.385491002e-016
		,3.603020749e-016
		,3.761827369e-016
		,3.873755354e-016
		,3.959512593e-016
		,4.024234781e-016
		,4.074336087e-016
		,4.113948003e-016
		,4.147399696e-016
		,4.178920373e-016
		,4.212163180e-016
		,4.250512821e-016
		,4.298725095e-016
		,4.352112464e-016
		,4.402151578e-016
		,4.444438018e-016
		,4.478549525e-016
		,4.505946387e-016
		,4.528493650e-016
		,4.547639650e-016
		,4.564282070e-016
		,4.579021399e-016
		,4.592292105e-016
		,4.604307005e-016
		,1.655381764e-016
		,1.657511988e-016
		,1.659715215e-016
		,1.662011492e-016
		,1.664432352e-016
		,1.667023672e-016
		,1.669849736e-016
		,1.673007969e-016
		,1.676665893e-016
		,1.681119119e-016
		,1.686984017e-016
		,1.695949639e-016
		,1.711947025e-016
		,1.746512011e-016
		,1.831241117e-016
		,2.032186230e-016
		,2.375933703e-016
		,2.769616305e-016
		,3.113625156e-016
		,3.386554072e-016
		,3.595314345e-016
		,3.748240735e-016
		,3.858447444e-016
		,3.939869163e-016
		,4.001611814e-016
		,4.050300046e-016
		,4.090532854e-016
		,4.126081623e-016
		,4.160888413e-016
		,4.199480948e-016
		,4.245605438e-016
		,4.299083541e-016
		,4.354095600e-016
		,4.403928574e-016
		,4.445653732e-016
		,4.479581955e-016
		,4.507214476e-016
		,4.530083542e-016
		,4.549394114e-016
		,4.566012122e-016
		,4.580552159e-016
		,1.649093553e-016
		,1.651089887e-016
		,1.653170132e-016
		,1.655307199e-016
		,1.657500013e-016
		,1.659759929e-016
		,1.662107278e-016
		,1.664572113e-016
		,1.667197700e-016
		,1.670047838e-016
		,1.673227393e-016
		,1.676926392e-016
		,1.681527026e-016
		,1.687915019e-016
		,1.698657695e-016
		,1.721586802e-016
		,1.780370163e-016
		,1.932016238e-016
		,2.239057384e-016
		,2.647100635e-016
		,3.024663874e-016
		,3.323665659e-016
		,3.549807220e-016
		,3.714574877e-016
		,3.832975711e-016
		,3.919563865e-016
		,3.985027723e-016
		,4.036493137e-016
		,4.078877457e-016
		,4.116166688e-016
		,4.152466260e-016
		,4.192460564e-016
		,4.240023832e-016
		,4.294643455e-016
		,4.350351472e-016
		,4.400637354e-016
		,4.442708549e-016
		,4.476943360e-016
		,4.504859193e-016
		,4.527974268e-016
		,4.547484518e-016
		,1.643716118e-016
		,1.644990186e-016
		,1.646794103e-016
		,1.648801520e-016
		,1.650901608e-016
		,1.653058102e-016
		,1.655262690e-016
		,1.657519709e-016
		,1.659841476e-016
		,1.662247678e-016
		,1.664767073e-016
		,1.667441895e-016
		,1.670337626e-016
		,1.673566782e-016
		,1.677354949e-016
		,1.682246414e-016
		,1.689794004e-016
		,1.704938444e-016
		,1.743780551e-016
		,1.852225336e-016
		,2.107388054e-016
		,2.506109541e-016
		,2.913287797e-016
		,3.244644605e-016
		,3.494501032e-016
		,3.675090703e-016
		,3.803782369e-016
		,3.897158616e-016
		,3.967270046e-016
		,4.022050318e-016
		,4.066887526e-016
		,4.106045343e-016
		,4.143797815e-016
		,4.184944235e-016
		,4.233447309e-016
		,4.288860116e-016
		,4.345262346e-016
		,4.396151734e-016
		,4.438735554e-016
		,4.473400676e-016
		,4.501677678e-016
		,1.647314601e-016
		,1.642046412e-016
		,1.641533648e-016
		,1.642692748e-016
		,1.644455015e-016
		,1.646455756e-016
		,1.648567453e-016
		,1.650744068e-016
		,1.652969814e-016
		,1.655242304e-016
		,1.657566871e-016
		,1.659955330e-016
		,1.662426863e-016
		,1.665010426e-016
		,1.667748960e-016
		,1.670715319e-016
		,1.674052427e-016
		,1.678102990e-016
		,1.683848191e-016
		,1.694489884e-016
		,1.720944285e-016
		,1.797730522e-016
		,2.000057292e-016
		,2.368756945e-016
		,2.792376233e-016
		,3.154132588e-016
		,3.429472981e-016
		,3.628220071e-016
		,3.769158760e-016
		,3.870710727e-016
		,3.946374242e-016
		,4.005043176e-016
		,4.052705007e-016
		,4.093986979e-016
		,4.133382365e-016
		,4.175828498e-016
		,4.225396022e-016
		,4.281732254e-016
		,4.338965485e-016
		,4.390591475e-016
		,4.433808572e-016
		,1.722725771e-016
		,1.667416897e-016
		,1.646591516e-016
		,1.640336213e-016
		,1.639439393e-016
		,1.640428786e-016
		,1.642109290e-016
		,1.644073506e-016
		,1.646176375e-016
		,1.648361657e-016
		,1.650605364e-016
		,1.652899031e-016
		,1.655240921e-016
		,1.657637662e-016
		,1.660100114e-016
		,1.662646173e-016
		,1.665305014e-016
		,1.668126526e-016
		,1.671203524e-016
		,1.674760413e-016
		,1.679438809e-016
		,1.687366129e-016
		,1.706014495e-016
		,1.760653274e-016
		,1.916767464e-016
		,2.242980132e-016
		,2.668109534e-016
		,3.055338335e-016
		,3.355954038e-016
		,3.574102565e-016
		,3.728930728e-016
		,3.840151131e-016
		,3.922481696e-016
		,3.985781119e-016
		,4.036723583e-016
		,4.080392750e-016
		,4.121573505e-016
		,4.165395882e-016
		,4.216079273e-016
		,4.273392230e-016
		,4.331523879e-016
		,2.181123362e-016
		,1.887346895e-016
		,1.736145635e-016
		,1.670771412e-016
		,1.646392588e-016
		,1.638883148e-016
		,1.637496548e-016
		,1.638254086e-016
		,1.639804409e-016
		,1.641691481e-016
		,1.643752417e-016
		,1.645922647e-016
		,1.648170301e-016
		,1.650480849e-016
		,1.652845429e-016
		,1.655261915e-016
		,1.657735671e-016
		,1.660277120e-016
		,1.662905814e-016
		,1.665654107e-016
		,1.668586922e-016
		,1.671850837e-016
		,1.675881089e-016
		,1.682120149e-016
		,1.695754013e-016
		,1.735113168e-016
		,1.853808641e-016
		,2.132664325e-016
		,2.545365360e-016
		,2.951432999e-016
		,3.275870088e-016
		,3.513481784e-016
		,3.682946077e-016
		,3.805019300e-016
		,3.895221753e-016
		,3.964125653e-016
		,4.019039380e-016
		,4.065539801e-016
		,4.108761350e-016
		,4.154083398e-016
		,4.205920535e-016
		,3.056739301e-016
		,2.698900705e-016
		,2.281904732e-016
		,1.941564551e-016
		,1.755634687e-016
		,1.676056566e-016
		,1.646845467e-016
		,1.637726384e-016
		,1.635747967e-016
		,1.636219970e-016
		,1.637594379e-016
		,1.639359643e-016
		,1.641338261e-016
		,1.643459542e-016
		,1.645686521e-016
		,1.647995123e-016
		,1.650372496e-016
		,1.652809436e-016
		,1.655304240e-016
		,1.657860173e-016
		,1.660488241e-016
		,1.663209950e-016
		,1.666069646e-016
		,1.669166701e-016
		,1.672801254e-016
		,1.677971323e-016
		,1.688325787e-016
		,1.717158094e-016
		,1.806854081e-016
		,2.039029806e-016
		,2.427845341e-016
		,2.845093217e-016
		,3.191167245e-016
		,3.447839231e-016
		,3.631795660e-016
		,3.765067300e-016
		,3.864004476e-016
		,3.939511746e-016
		,3.999257695e-016
		,4.049235002e-016
		,4.094949261e-016
		,3.557573229e-016
		,3.385101407e-016
		,3.144735799e-016
		,2.809722442e-016
		,2.392437977e-016
		,2.009239724e-016
		,1.779956456e-016
		,1.682160932e-016
		,1.647441790e-016
		,1.636688339e-016
		,1.634167805e-016
		,1.634369330e-016
		,1.635538841e-016
		,1.637140487e-016
		,1.638991341e-016
		,1.641019246e-016
		,1.643185222e-016
		,1.645463513e-016
		,1.647832973e-016
		,1.650279085e-016
		,1.652792316e-016
		,1.655369581e-016
		,1.658013521e-016
		,1.660737910e-016
		,1.663568613e-016
		,1.666580452e-016
		,1.669975617e-016
		,1.674466582e-016
		,1.682645173e-016
		,1.704189034e-016
		,1.771971817e-016
		,1.961521505e-016
		,2.318193010e-016
		,2.738525826e-016
		,3.103312927e-016
		,3.378600375e-016
		,3.576815401e-016
		,3.720862858e-016
		,3.828610852e-016
		,3.911360834e-016
		,3.976765713e-016
		,3.808375881e-016
		,3.714019701e-016
		,3.594202798e-016
		,3.433791202e-016
		,3.204504159e-016
		,2.875016767e-016
		,2.464037374e-016
		,2.052642231e-016
		,1.790942906e-016
		,1.681981272e-016
		,1.646440508e-016
		,1.635603826e-016
		,1.632804407e-016
		,1.632753128e-016
		,1.633692081e-016
		,1.635091324e-016
		,1.636769616e-016
		,1.638657308e-016
		,1.640717917e-016
		,1.642924429e-016
		,1.645253535e-016
		,1.647684769e-016
		,1.650202463e-016
		,1.652795640e-016
		,1.655461010e-016
		,1.658201728e-016
		,1.661032955e-016
		,1.664007539e-016
		,1.667268643e-016
		,1.671327220e-016
		,1.678046176e-016
		,1.694523642e-016
		,1.745960882e-016
		,1.898536240e-016
		,2.218129799e-016
		,2.633553675e-016
		,3.013506190e-016
		,3.306580763e-016
		,3.519221487e-016
		,3.673710257e-016
		,3.789619609e-016
		,3.947144307e-016
		,3.887930764e-016
		,3.814623558e-016
		,3.723954496e-016
		,3.605329085e-016
		,3.445714756e-016
		,3.219002220e-016
		,2.879629210e-016
		,2.408283287e-016
		,1.972098707e-016
		,1.764758635e-016
		,1.677503255e-016
		,1.645300121e-016
		,1.634839280e-016
		,1.631745164e-016
		,1.631394832e-016
		,1.632084455e-016
		,1.633257793e-016
		,1.634729939e-016
		,1.636435229e-016
		,1.638343327e-016
		,1.640431337e-016
		,1.642676847e-016
		,1.645057558e-016
		,1.647552571e-016
		,1.650144539e-016
		,1.652823874e-016
		,1.655582845e-016
		,1.658430581e-016
		,1.661395537e-016
		,1.664590857e-016
		,1.668376816e-016
		,1.674110115e-016
		,1.687037248e-016
		,1.726390591e-016
		,1.848040280e-016
		,2.128585551e-016
		,2.531622765e-016
		,2.922854639e-016
		,3.232338557e-016
		,3.459484857e-016
		,4.092522078e-016
		,4.055766165e-016
		,4.010805217e-016
		,3.951930260e-016
		,3.871133918e-016
		,3.756682582e-016
		,3.601721581e-016
		,3.329183261e-016
		,3.033195554e-016
		,2.651685321e-016
		,2.212414688e-016
		,1.889423085e-016
		,1.741426305e-016
		,1.675929540e-016
		,1.645768195e-016
		,1.634516783e-016
		,1.630955404e-016
		,1.630285505e-016
		,1.630725309e-016
		,1.631667431e-016
		,1.632915365e-016
		,1.634407945e-016
		,1.636122749e-016
		,1.638045288e-016
		,1.640158890e-016
		,1.642443572e-016
		,1.644877050e-016
		,1.647438927e-016
		,1.650110602e-016
		,1.652878797e-016
		,1.655743137e-016
		,1.658716833e-016
		,1.661881338e-016
		,1.665501814e-016
		,1.670569108e-016
		,1.680990094e-016
		,1.711423794e-016
		,1.807885919e-016
		,2.049892659e-016
		,2.433954706e-016
		,2.832275550e-016
		,4.195669082e-016
		,4.157176216e-016
		,4.115182401e-016
		,4.078283787e-016
		,4.029148101e-016
		,3.903759184e-016
		,3.825000012e-016
		,3.709980318e-016
		,3.519450413e-016
		,3.220173743e-016
		,2.804795980e-016
		,2.306565476e-016
		,2.025003985e-016
		,1.851216147e-016
		,1.741808944e-016
		,1.678173174e-016
		,1.646957227e-016
		,1.634502781e-016
		,1.630377846e-016
		,1.629401754e-016
		,1.629607387e-016
		,1.630326844e-016
		,1.631349371e-016
		,1.632614743e-016
		,1.634108754e-016
		,1.635826766e-016
		,1.637762001e-016
		,1.639901254e-016
		,1.642225881e-016
		,1.644715956e-016
		,1.647346506e-016
		,1.650102766e-016
		,1.652969898e-016
		,1.655954875e-016
		,1.659108178e-016
		,1.662625999e-016
		,1.667248654e-016
		,1.675889369e-016
		,1.699737708e-016
		,1.776076091e-016
		,1.981791871e-016
		,4.273302920e-016
		,4.254602637e-016
		,4.204613873e-016
		,4.131325113e-016
		,4.102777179e-016
		,4.069767642e-016
		,4.020583026e-016
		,3.952522677e-016
		,3.830834875e-016
		,3.567925956e-016
		,3.266064121e-016
		,2.830400259e-016
		,2.434503939e-016
		,2.182263758e-016
		,1.986510773e-016
		,1.847298973e-016
		,1.749367118e-016
		,1.682519855e-016
		,1.648395637e-016
		,1.634662557e-016
		,1.629983332e-016
		,1.628716306e-016
		,1.628708118e-016
		,1.629224377e-016
		,1.630034008e-016
		,1.631074481e-016
		,1.632336791e-016
		,1.633826034e-016
		,1.635545890e-016
		,1.637493626e-016
		,1.639660175e-016
		,1.642027386e-016
		,1.644574550e-016
		,1.647281301e-016
		,1.650127635e-016
		,1.653112063e-016
		,1.656258226e-016
		,1.659697450e-016
		,1.664033681e-016
		,1.671403804e-016
		,1.690381116e-016
		,4.338021530e-016
		,4.323389935e-016
		,4.293889866e-016
		,4.281001343e-016
		,4.239759554e-016
		,4.202986988e-016
		,4.090365555e-016
		,4.057363363e-016
		,3.976469121e-016
		,3.854278112e-016
		,3.653856165e-016
		,3.250773024e-016
		,2.838851590e-016
		,2.620889311e-016
		,2.323882996e-016
		,2.135392794e-016
		,1.991805972e-016
		,1.864821392e-016
		,1.758123036e-016
		,1.686815804e-016
		,1.650027044e-016
		,1.634989022e-016
		,1.629744468e-016
		,1.628197718e-016
		,1.627997553e-016
		,1.628335086e-016
		,1.628953949e-016
		,1.629785088e-016
		,1.630821656e-016
		,1.632074599e-016
		,1.633557509e-016
		,1.635279542e-016
		,1.637242415e-016
		,1.639436393e-016
		,1.641850040e-016
		,1.644459531e-016
		,1.647246715e-016
		,1.650206057e-016
		,1.653335444e-016
		,1.656719882e-016
		,1.660817950e-016
		,4.343112335e-016
		,4.332972761e-016
		,4.329994519e-016
		,4.325880453e-016
		,4.319196810e-016
		,4.308156673e-016
		,4.295350995e-016
		,4.272831767e-016
		,4.219041026e-016
		,4.130452598e-016
		,3.804770589e-016
		,3.598198120e-016
		,3.326220590e-016
		,3.069351845e-016
		,2.717161569e-016
		,2.518230084e-016
		,2.269818129e-016
		,2.153547765e-016
		,2.013828430e-016
		,1.878158479e-016
		,1.766539554e-016
		,1.691339432e-016
		,1.651874252e-016
		,1.635467647e-016
		,1.629633543e-016
		,1.627815616e-016
		,1.627443366e-016
		,1.627627503e-016
		,1.628082123e-016
		,1.628728412e-016
		,1.629557178e-016
		,1.630582678e-016
		,1.631824661e-016
		,1.633303492e-016
		,1.635029096e-016
		,1.637007642e-016
		,1.639234785e-016
		,1.641696422e-016
		,1.644375476e-016
		,1.647270813e-016
		,1.650356849e-016
		,4.432982178e-016
		,4.429526825e-016
		,4.426536658e-016
		,4.424064765e-016
		,4.422169489e-016
		,4.418828532e-016
		,4.414805847e-016
		,4.330873563e-016
		,4.304241333e-016
		,4.205974427e-016
		,4.001642324e-016
		,3.935060470e-016
		,3.764715566e-016
		,3.488915586e-016
		,3.144518434e-016
		,2.861386282e-016
		,2.638189228e-016
		,2.430398791e-016
		,2.318314119e-016
		,2.178187005e-016
		,2.030319039e-016
		,1.890514819e-016
		,1.775057838e-016
		,1.696152902e-016
		,1.653938776e-016
		,1.636086149e-016
		,1.629630384e-016
		,1.627543069e-016
		,1.627014755e-016
		,1.627068884e-016
		,1.627386284e-016
		,1.627875376e-016
		,1.628522533e-016
		,1.629340845e-016
		,1.630353977e-016
		,1.631587936e-016
		,1.633062225e-016
		,1.634795687e-016
		,1.636792450e-016
		,1.639055211e-016
		,1.641578314e-016
		,4.514042568e-016
		,4.511809431e-016
		,4.510719552e-016
		,4.510998802e-016
		,4.452191395e-016
		,4.438580524e-016
		,4.436219730e-016
		,4.433562634e-016
		,4.427440249e-016
		,4.219339160e-016
		,4.168931181e-016
		,4.129410245e-016
		,4.051335767e-016
		,3.834288253e-016
		,3.621957047e-016
		,3.170144153e-016
		,3.028857507e-016
		,2.749702798e-016
		,2.559976889e-016
		,2.472404526e-016
		,2.344733472e-016
		,2.196436144e-016
		,2.045113084e-016
		,1.902538407e-016
		,1.783812267e-016
		,1.701263581e-016
		,1.656227484e-016
		,1.636835070e-016
		,1.629719691e-016
		,1.627355997e-016
		,1.626684732e-016
		,1.626628624e-016
		,1.626833615e-016
		,1.627193142e-016
		,1.627686957e-016
		,1.628325391e-016
		,1.629133132e-016
		,1.630135343e-016
		,1.631362277e-016
		,1.632837140e-016
		,1.634578725e-016
		,4.588064279e-016
		,4.537888948e-016
		,4.524301588e-016
		,4.522154623e-016
		,4.521324780e-016
		,4.522060219e-016
		,4.523764356e-016
		,4.524960509e-016
		,4.433929880e-016
		,4.328713003e-016
		,4.316162023e-016
		,4.298416288e-016
		,4.256282828e-016
		,4.132725485e-016
		,3.914741367e-016
		,3.488313611e-016
		,3.278997871e-016
		,3.176666225e-016
		,2.850807013e-016
		,2.691733487e-016
		,2.608198554e-016
		,2.490919333e-016
		,2.364702596e-016
		,2.212492614e-016
		,2.058999131e-016
		,1.914534887e-016
		,1.792775023e-016
		,1.706700468e-016
		,1.658740540e-016
		,1.637709924e-016
		,1.629888205e-016
		,1.627237133e-016
		,1.626430745e-016
		,1.626280498e-016
		,1.626393742e-016
		,1.626648580e-016
		,1.627016877e-016
		,1.627505439e-016
		,1.628135241e-016
		,1.628931621e-016
		,1.629926686e-016
		,4.598709290e-016
		,4.596464330e-016
		,4.593798891e-016
		,4.592383003e-016
		,4.592732346e-016
		,4.595131677e-016
		,4.598968374e-016
		,4.558577749e-016
		,4.449873617e-016
		,4.451512758e-016
		,4.436250970e-016
		,4.433009798e-016
		,4.414977826e-016
		,4.370837240e-016
		,4.169776062e-016
		,3.971201034e-016
		,3.444758698e-016
		,3.363260607e-016
		,3.231626241e-016
		,2.928176600e-016
		,2.807541024e-016
		,2.741286384e-016
		,2.635564255e-016
		,2.507639184e-016
		,2.376460703e-016
		,2.227200888e-016
		,2.072577845e-016
		,1.926387377e-016
		,1.801980490e-016
		,1.712469896e-016
		,1.661480483e-016
		,1.638710738e-016
		,1.630127565e-016
		,1.627173940e-016
		,1.626233929e-016
		,1.626001915e-016
		,1.626040653e-016
		,1.626212047e-016
		,1.626479612e-016
		,1.626846760e-016
		,1.627327889e-016
		,1.671208553e-016
		,1.674803912e-016
		,1.679139106e-016
		,1.684591420e-016
		,1.691751871e-016
		,1.701536485e-016
		,1.715592247e-016
		,1.736835111e-016
		,1.769777672e-016
		,1.817210853e-016
		,1.889661153e-016
		,1.961049488e-016
		,2.103280163e-016
		,2.326778552e-016
		,2.652549348e-016
		,3.068694447e-016
		,3.401833675e-016
		,3.626467134e-016
		,3.796571848e-016
		,3.927653313e-016
		,4.022981248e-016
		,4.095399632e-016
		,4.149027726e-016
		,4.179561916e-016
		,4.194522631e-016
		,4.218049755e-016
		,4.246767584e-016
		,4.279214843e-016
		,4.317251185e-016
		,4.363320344e-016
		,4.412521345e-016
		,4.457345238e-016
		,4.494577657e-016
		,4.524289051e-016
		,4.547662731e-016
		,4.566111213e-016
		,4.581066618e-016
		,4.593769890e-016
		,4.605064463e-016
		,4.615394848e-016
		,4.624954985e-016
		,1.662903252e-016
		,1.665375326e-016
		,1.668072908e-016
		,1.671086468e-016
		,1.674550120e-016
		,1.678685913e-016
		,1.683848633e-016
		,1.690672873e-016
		,1.700442108e-016
		,1.715257668e-016
		,1.739792448e-016
		,1.781387205e-016
		,1.845752017e-016
		,1.962487333e-016
		,2.257572378e-016
		,2.636464299e-016
		,2.964800580e-016
		,3.271212117e-016
		,3.533316192e-016
		,3.729717071e-016
		,3.865756528e-016
		,3.966608609e-016
		,4.040736955e-016
		,4.097232854e-016
		,4.141783252e-016
		,4.177695405e-016
		,4.205389943e-016
		,4.223835603e-016
		,4.248900181e-016
		,4.289173047e-016
		,4.338568133e-016
		,4.388145400e-016
		,4.431223367e-016
		,4.466541960e-016
		,4.495657895e-016
		,4.520017939e-016
		,4.540694241e-016
		,4.558542030e-016
		,4.574235023e-016
		,4.588277175e-016
		,4.600979565e-016
		,1.656238123e-016
		,1.658383285e-016
		,1.660613030e-016
		,1.662953065e-016
		,1.665442225e-016
		,1.668136755e-016
		,1.671119153e-016
		,1.674520700e-016
		,1.678556260e-016
		,1.683622868e-016
		,1.690577134e-016
		,1.701607183e-016
		,1.720532120e-016
		,1.756954768e-016
		,1.835214821e-016
		,2.038286533e-016
		,2.388087307e-016
		,2.774372921e-016
		,3.116261034e-016
		,3.395208046e-016
		,3.609480170e-016
		,3.764414071e-016
		,3.874216817e-016
		,3.957268568e-016
		,4.019319155e-016
		,4.067220173e-016
		,4.106202675e-016
		,4.140162328e-016
		,4.172834276e-016
		,4.208158338e-016
		,4.249680401e-016
		,4.299980991e-016
		,4.353816901e-016
		,4.403472032e-016
		,4.445268903e-016
		,4.479155156e-016
		,4.506630843e-016
		,4.529395676e-016
		,4.548738928e-016
		,4.565519231e-016
		,4.580302806e-016
		,1.649970040e-016
		,1.651968814e-016
		,1.654050144e-016
		,1.656191153e-016
		,1.658394307e-016
		,1.660674871e-016
		,1.663058082e-016
		,1.665580746e-016
		,1.668296871e-016
		,1.671286068e-016
		,1.674685847e-016
		,1.678747262e-016
		,1.684050097e-016
		,1.691822351e-016
		,1.705537458e-016
		,1.735012532e-016
		,1.809814217e-016
		,1.991961665e-016
		,2.323834865e-016
		,2.726087448e-016
		,3.083903573e-016
		,3.365603500e-016
		,3.579820688e-016
		,3.736512897e-016
		,3.849509807e-016
		,3.932569592e-016
		,3.995531662e-016
		,4.045151995e-016
		,4.086125244e-016
		,4.122293295e-016
		,4.157659867e-016
		,4.196817411e-016
		,4.243594913e-016
		,4.297625736e-016
		,4.352928104e-016
		,4.402912585e-016
		,4.444737500e-016
		,4.478758249e-016
		,4.506490346e-016
		,4.529453342e-016
		,4.548837632e-016
		,1.644552415e-016
		,1.645875930e-016
		,1.647698264e-016
		,1.649711181e-016
		,1.651811573e-016
		,1.653967560e-016
		,1.656174188e-016
		,1.658439026e-016
		,1.660778052e-016
		,1.663215657e-016
		,1.665787284e-016
		,1.668545559e-016
		,1.671573753e-016
		,1.675018577e-016
		,1.679180960e-016
		,1.684795472e-016
		,1.693950090e-016
		,1.713165168e-016
		,1.762858458e-016
		,1.896257496e-016
		,2.184471093e-016
		,2.592602261e-016
		,2.983516463e-016
		,3.295242757e-016
		,3.530256027e-016
		,3.700813515e-016
		,3.822921763e-016
		,3.911924649e-016
		,3.979031402e-016
		,4.031662920e-016
		,4.074904439e-016
		,4.112840439e-016
		,4.149636669e-016
		,4.190022106e-016
		,4.237904517e-016
		,4.292790201e-016
		,4.348732097e-016
		,4.399222518e-016
		,4.441467035e-016
		,4.475845909e-016
		,4.503880756e-016
		,1.647525257e-016
		,1.642698479e-016
		,1.642352529e-016
		,1.643581502e-016
		,1.645375781e-016
		,1.647391070e-016
		,1.649508272e-016
		,1.651686051e-016
		,1.653912212e-016
		,1.656187435e-016
		,1.658519786e-016
		,1.660923776e-016
		,1.663416455e-016
		,1.666031193e-016
		,1.668844356e-016
		,1.671931754e-016
		,1.675484278e-016
		,1.679946620e-016
		,1.686603706e-016
		,1.699592255e-016
		,1.732720173e-016
		,1.827362168e-016
		,2.061461076e-016
		,2.450931544e-016
		,2.866986978e-016
		,3.211077398e-016
		,3.470942572e-016
		,3.658417422e-016
		,3.791602367e-016
		,3.887924507e-016
		,3.960025561e-016
		,4.016200973e-016
		,4.062054347e-016
		,4.101976711e-016
		,4.140320871e-016
		,4.181931944e-016
		,4.230804705e-016
		,4.286535915e-016
		,4.343226897e-016
		,4.394372017e-016
		,4.437172564e-016
		,1.716791052e-016
		,1.665860800e-016
		,1.646598098e-016
		,1.640897679e-016
		,1.640213517e-016
		,1.641299096e-016
		,1.643030918e-016
		,1.645024973e-016
		,1.647145119e-016
		,1.649339265e-016
		,1.651587171e-016
		,1.653878688e-016
		,1.656209066e-016
		,1.658598771e-016
		,1.661065903e-016
		,1.663640081e-016
		,1.666336554e-016
		,1.669238634e-016
		,1.672437422e-016
		,1.676260805e-016
		,1.681480163e-016
		,1.690869594e-016
		,1.713774138e-016
		,1.780887610e-016
		,1.963950997e-016
		,2.316951274e-016
		,2.743407409e-016
		,3.116429291e-016
		,3.402170990e-016
		,3.608594665e-016
		,3.754775715e-016
		,3.859857727e-016
		,3.937914087e-016
		,3.998241314e-016
		,4.047087961e-016
		,4.089248868e-016
		,4.129317415e-016
		,4.172276093e-016
		,4.222255215e-016
		,4.278951972e-016
		,4.336515580e-016
		,2.129595022e-016
		,1.862517065e-016
		,1.727572939e-016
		,1.668380253e-016
		,1.646108784e-016
		,1.639315541e-016
		,1.638199469e-016
		,1.639084287e-016
		,1.640709207e-016
		,1.642645054e-016
		,1.644737614e-016
		,1.646915547e-016
		,1.649159724e-016
		,1.651464973e-016
		,1.653817430e-016
		,1.656248721e-016
		,1.658727352e-016
		,1.661276066e-016
		,1.663923610e-016
		,1.666716572e-016
		,1.669733800e-016
		,1.673160390e-016
		,1.677562519e-016
		,1.684759789e-016
		,1.701260999e-016
		,1.749372430e-016
		,1.889548659e-016
		,2.196848392e-016
		,2.618597033e-016
		,3.014626142e-016
		,3.325474716e-016
		,3.551624277e-016
		,3.712222279e-016
		,3.827535545e-016
		,3.912729628e-016
		,3.978033898e-016
		,4.030404214e-016
		,4.075119745e-016
		,4.117052171e-016
		,4.161429022e-016
		,4.212546522e-016
		,2.997808456e-016
		,2.629712901e-016
		,2.220048612e-016
		,1.907501278e-016
		,1.743189919e-016
		,1.672477810e-016
		,1.646215322e-016
		,1.638031025e-016
		,1.636371758e-016
		,1.636992529e-016
		,1.638452579e-016
		,1.640264402e-016
		,1.642288014e-016
		,1.644425610e-016
		,1.646672205e-016
		,1.649003316e-016
		,1.651395325e-016
		,1.653826323e-016
		,1.656324615e-016
		,1.658881327e-016
		,1.661518980e-016
		,1.664262048e-016
		,1.667196846e-016
		,1.670389357e-016
		,1.674306264e-016
		,1.680149485e-016
		,1.692578931e-016
		,1.727642286e-016
		,1.833971065e-016
		,2.093328255e-016
		,2.497058686e-016
		,2.908790343e-016
		,3.242889721e-016
		,3.488517002e-016
		,3.663954000e-016
		,3.790471484e-016
		,3.883971170e-016
		,3.955290722e-016
		,4.011977676e-016
		,4.059726029e-016
		,4.103833739e-016
		,3.529881649e-016
		,3.347762594e-016
		,3.094047667e-016
		,2.744026938e-016
		,2.325619658e-016
		,1.967996646e-016
		,1.765500801e-016
		,1.678581926e-016
		,1.646898527e-016
		,1.637013705e-016
		,1.634729585e-016
		,1.635031126e-016
		,1.636301401e-016
		,1.637959256e-016
		,1.639885204e-016
		,1.641978628e-016
		,1.644186547e-016
		,1.646488979e-016
		,1.648873958e-016
		,1.651328237e-016
		,1.653846129e-016
		,1.656427885e-016
		,1.659072224e-016
		,1.661816752e-016
		,1.664692427e-016
		,1.667800384e-016
		,1.671408267e-016
		,1.676457452e-016
		,1.686199285e-016
		,1.712291335e-016
		,1.792871136e-016
		,2.006762537e-016
		,2.382152873e-016
		,2.801572524e-016
		,3.156189519e-016
		,3.420839515e-016
		,3.610830991e-016
		,3.748620552e-016
		,3.851117983e-016
		,3.929453881e-016
		,3.991273964e-016
		,3.793119823e-016
		,3.698243940e-016
		,3.574663461e-016
		,3.408115857e-016
		,3.175854690e-016
		,2.849707211e-016
		,2.433115044e-016
		,2.034356741e-016
		,1.788283221e-016
		,1.684080527e-016
		,1.647205398e-016
		,1.635944925e-016
		,1.633254375e-016
		,1.633285588e-016
		,1.634345008e-016
		,1.635846608e-016
		,1.637614097e-016
		,1.639573879e-016
		,1.641694160e-016
		,1.643945065e-016
		,1.646308787e-016
		,1.648757248e-016
		,1.651286789e-016
		,1.653886876e-016
		,1.656557432e-016
		,1.659326820e-016
		,1.662172920e-016
		,1.665272348e-016
		,1.668716778e-016
		,1.673319880e-016
		,1.681302389e-016
		,1.701168597e-016
		,1.762372090e-016
		,1.936027941e-016
		,2.276243351e-016
		,2.695122940e-016
		,3.066748688e-016
		,3.349823320e-016
		,3.554253861e-016
		,3.702866183e-016
		,3.814276833e-016
		,3.945702942e-016
		,3.887983764e-016
		,3.816682248e-016
		,3.726639973e-016
		,3.603582297e-016
		,3.431077174e-016
		,3.203329206e-016
		,2.895580818e-016
		,2.481593787e-016
		,2.054722144e-016
		,1.786605004e-016
		,1.680419353e-016
		,1.646070880e-016
		,1.634981322e-016
		,1.632048122e-016
		,1.631829708e-016
		,1.632634968e-016
		,1.633918106e-016
		,1.635485906e-016
		,1.637284474e-016
		,1.639271304e-016
		,1.641424877e-016
		,1.643720663e-016
		,1.646137914e-016
		,1.648657663e-016
		,1.651261327e-016
		,1.653971612e-016
		,1.656753910e-016
		,1.659636331e-016
		,1.662696239e-016
		,1.666140345e-016
		,1.670479679e-016
		,1.677297731e-016
		,1.692980495e-016
		,1.739929846e-016
		,1.878967569e-016
		,2.180807886e-016
		,2.591024095e-016
		,2.975741293e-016
		,3.276136532e-016
		,3.495280811e-016
		,4.042733745e-016
		,4.004605914e-016
		,3.957875959e-016
		,3.901083642e-016
		,3.830728241e-016
		,3.740533418e-016
		,3.621405163e-016
		,3.457548008e-016
		,3.214440312e-016
		,2.843733986e-016
		,2.339991874e-016
		,1.956669919e-016
		,1.760053492e-016
		,1.676537871e-016
		,1.645415746e-016
		,1.634447933e-016
		,1.631131400e-016
		,1.630614241e-016
		,1.631170819e-016
		,1.632220220e-016
		,1.633569438e-016
		,1.635164566e-016
		,1.636974209e-016
		,1.638982883e-016
		,1.641167623e-016
		,1.643511447e-016
		,1.645987290e-016
		,1.648581975e-016
		,1.651300548e-016
		,1.654093136e-016
		,1.657032386e-016
		,1.660087208e-016
		,1.663564187e-016
		,1.667766193e-016
		,1.673848799e-016
		,1.686648846e-016
		,1.723228353e-016
		,1.834038687e-016
		,2.097002090e-016
		,2.490558690e-016
		,2.884072340e-016
		,4.158950306e-016
		,4.127802362e-016
		,4.093325471e-016
		,4.056368077e-016
		,4.011386942e-016
		,3.947931159e-016
		,3.860138877e-016
		,3.750173256e-016
		,3.525764060e-016
		,3.296818131e-016
		,3.012447744e-016
		,2.599539434e-016
		,2.168259546e-016
		,1.868672010e-016
		,1.743510856e-016
		,1.676696207e-016
		,1.646006098e-016
		,1.634301252e-016
		,1.630466546e-016
		,1.629635543e-016
		,1.629950566e-016
		,1.630767410e-016
		,1.631894447e-016
		,1.633264245e-016
		,1.634864709e-016
		,1.636682508e-016
		,1.638711703e-016
		,1.640930497e-016
		,1.643318138e-016
		,1.645879364e-016
		,1.648559712e-016
		,1.651376897e-016
		,1.654325549e-016
		,1.657434742e-016
		,1.660895312e-016
		,1.665089441e-016
		,1.670739695e-016
		,1.681551474e-016
		,1.710551889e-016
		,1.798797714e-016
		,2.025370060e-016
		,4.256921403e-016
		,4.227810870e-016
		,4.187146290e-016
		,4.162294044e-016
		,4.132948886e-016
		,4.101919074e-016
		,3.969429833e-016
		,3.892465691e-016
		,3.813672620e-016
		,3.689639499e-016
		,3.477730743e-016
		,3.165686621e-016
		,2.708335275e-016
		,2.243498366e-016
		,2.022581793e-016
		,1.850607158e-016
		,1.743913129e-016
		,1.679896269e-016
		,1.647424867e-016
		,1.634386308e-016
		,1.629990129e-016
		,1.628868246e-016
		,1.628956299e-016
		,1.629565360e-016
		,1.630470193e-016
		,1.631614561e-016
		,1.632983728e-016
		,1.634583284e-016
		,1.636409981e-016
		,1.638457368e-016
		,1.640717661e-016
		,1.643179165e-016
		,1.645795025e-016
		,1.648610789e-016
		,1.651557157e-016
		,1.654722932e-016
		,1.658199059e-016
		,1.662235000e-016
		,1.667837843e-016
		,1.677285066e-016
		,1.700756142e-016
		,4.320793444e-016
		,4.306894348e-016
		,4.284730815e-016
		,4.244507086e-016
		,4.186635864e-016
		,4.156788667e-016
		,4.134205219e-016
		,4.098612621e-016
		,4.045252515e-016
		,3.959444136e-016
		,3.804100681e-016
		,3.459550515e-016
		,3.161616634e-016
		,2.715448305e-016
		,2.419365469e-016
		,2.165929645e-016
		,1.984809571e-016
		,1.854126461e-016
		,1.753019625e-016
		,1.684282475e-016
		,1.648975688e-016
		,1.634633861e-016
		,1.629686479e-016
		,1.628278713e-016
		,1.628168911e-016
		,1.628587325e-016
		,1.629292648e-016
		,1.630217952e-016
		,1.631358078e-016
		,1.632721073e-016
		,1.634320219e-016
		,1.636154387e-016
		,1.638244069e-016
		,1.640541353e-016
		,1.643076260e-016
		,1.645808699e-016
		,1.648745865e-016
		,1.651980327e-016
		,1.655469680e-016
		,1.659237233e-016
		,1.664893310e-016
		,4.369543411e-016
		,4.360998507e-016
		,4.348768941e-016
		,4.322834169e-016
		,4.314446134e-016
		,4.303101661e-016
		,4.285700148e-016
		,4.194599134e-016
		,4.118886673e-016
		,4.073633443e-016
		,3.974486658e-016
		,3.840536806e-016
		,3.537972908e-016
		,3.116326357e-016
		,2.804903449e-016
		,2.555091576e-016
		,2.323211973e-016
		,2.125180026e-016
		,2.000655238e-016
		,1.870497202e-016
		,1.761752765e-016
		,1.688721763e-016
		,1.650717923e-016
		,1.635041354e-016
		,1.629521101e-016
		,1.627841126e-016
		,1.627552063e-016
		,1.627807177e-016
		,1.628335857e-016
		,1.629063821e-016
		,1.629988574e-016
		,1.631120254e-016
		,1.632474413e-016
		,1.634082617e-016
		,1.635940863e-016
		,1.638047574e-016
		,1.640437021e-016
		,1.643052109e-016
		,1.645915843e-016
		,1.649231563e-016
		,1.652749254e-016
		,4.448674010e-016
		,4.368870030e-016
		,4.355424822e-016
		,4.353570776e-016
		,4.350816403e-016
		,4.343135953e-016
		,4.337252416e-016
		,4.328718462e-016
		,4.314823910e-016
		,4.285801795e-016
		,4.217295005e-016
		,4.117631077e-016
		,3.707478086e-016
		,3.563526435e-016
		,3.250300955e-016
		,3.006792171e-016
		,2.669666844e-016
		,2.468758131e-016
		,2.286100081e-016
		,2.163222266e-016
		,2.021026393e-016
		,1.883639531e-016
		,1.770258775e-016
		,1.693402461e-016
		,1.652672504e-016
		,1.635594327e-016
		,1.629470799e-016
		,1.627525672e-016
		,1.627075224e-016
		,1.627190504e-016
		,1.627567747e-016
		,1.628131505e-016
		,1.628860659e-016
		,1.629773152e-016
		,1.630889767e-016
		,1.632267593e-016
		,1.633870215e-016
		,1.635763923e-016
		,1.637927797e-016
		,1.640391441e-016
		,1.643172937e-016
		,4.460009214e-016
		,4.456559641e-016
		,4.453563211e-016
		,4.451052107e-016
		,4.449359852e-016
		,4.448690693e-016
		,4.447940845e-016
		,4.445700102e-016
		,4.416195352e-016
		,4.341640780e-016
		,4.294971420e-016
		,4.100014368e-016
		,4.011589375e-016
		,3.931214026e-016
		,3.690721186e-016
		,3.452858808e-016
		,3.038095953e-016
		,2.850541115e-016
		,2.577352710e-016
		,2.444722514e-016
		,2.327902986e-016
		,2.185934233e-016
		,2.037089750e-016
		,1.895953830e-016
		,1.778898292e-016
		,1.698368556e-016
		,1.654846157e-016
		,1.636281299e-016
		,1.629519581e-016
		,1.627306621e-016
		,1.626708837e-016
		,1.626703197e-016
		,1.626963501e-016
		,1.627381906e-016
		,1.627947863e-016
		,1.628665148e-016
		,1.629574534e-016
		,1.630703578e-016
		,1.632076856e-016
		,1.633723888e-016
		,1.635631201e-016
		,4.539461246e-016
		,4.536182193e-016
		,4.533893855e-016
		,4.532788165e-016
		,4.533245059e-016
		,4.515798783e-016
		,4.464195727e-016
		,4.463432113e-016
		,4.462533912e-016
		,4.460406233e-016
		,4.371111593e-016
		,4.206603844e-016
		,4.189770117e-016
		,4.140891261e-016
		,4.014361608e-016
		,3.756607560e-016
		,3.472606248e-016
		,3.164525022e-016
		,3.015744376e-016
		,2.681427111e-016
		,2.577736949e-016
		,2.479126780e-016
		,2.353042836e-016
		,2.203736628e-016
		,2.051666170e-016
		,1.907949437e-016
		,1.787785697e-016
		,1.703650118e-016
		,1.657242850e-016
		,1.637095906e-016
		,1.629655488e-016
		,1.627159938e-016
		,1.626426711e-016
		,1.626324622e-016
		,1.626482249e-016
		,1.626789492e-016
		,1.627216288e-016
		,1.627768443e-016
		,1.628499484e-016
		,1.629400337e-016
		,1.630553641e-016
		,4.610062569e-016
		,4.608127329e-016
		,4.587696658e-016
		,4.544873396e-016
		,4.542838620e-016
		,4.542179474e-016
		,4.543111055e-016
		,4.545241570e-016
		,4.548813855e-016
		,4.546692343e-016
		,4.367718677e-016
		,4.346314596e-016
		,4.343443225e-016
		,4.321288935e-016
		,4.268021199e-016
		,4.060621448e-016
		,3.884965893e-016
		,3.341334961e-016
		,3.249607193e-016
		,3.162875086e-016
		,2.773074681e-016
		,2.711028792e-016
		,2.619830758e-016
		,2.497009759e-016
		,2.372049475e-016
		,2.219666704e-016
		,2.065514934e-016
		,1.919806577e-016
		,1.796949050e-016
		,1.709243106e-016
		,1.659870072e-016
		,1.638037050e-016
		,1.629865831e-016
		,1.627071832e-016
		,1.626211535e-016
		,1.626025658e-016
		,1.626104848e-016
		,1.626318371e-016
		,1.626626286e-016
		,1.627057184e-016
		,1.627618457e-016
		,1.672915396e-016
		,1.677003748e-016
		,1.682095303e-016
		,1.688704835e-016
		,1.697623820e-016
		,1.709919551e-016
		,1.727587844e-016
		,1.753053352e-016
		,1.791374460e-016
		,1.844425499e-016
		,1.915556841e-016
		,1.976749051e-016
		,2.075807675e-016
		,2.242057164e-016
		,2.434739819e-016
		,2.834333358e-016
		,3.218537916e-016
		,3.514476760e-016
		,3.729688138e-016
		,3.891407158e-016
		,4.007871997e-016
		,4.089620615e-016
		,4.137677539e-016
		,4.155933985e-016
		,4.182981514e-016
		,4.211419413e-016
		,4.230849180e-016
		,4.242271677e-016
		,4.272111934e-016
		,4.321044850e-016
		,4.376605783e-016
		,4.429110221e-016
		,4.473816374e-016
		,4.510249866e-016
		,4.539859899e-016
		,4.564341554e-016
		,4.585068405e-016
		,4.603036649e-016
		,4.618940814e-016
		,4.633250687e-016
		,4.646258109e-016
		,1.663921664e-016
		,1.666507806e-016
		,1.669378878e-016
		,1.672656122e-016
		,1.676520659e-016
		,1.681275690e-016
		,1.687427202e-016
		,1.695886312e-016
		,1.708129807e-016
		,1.726985704e-016
		,1.758179838e-016
		,1.803450694e-016
		,1.868834911e-016
		,1.951038656e-016
		,2.126330645e-016
		,2.392376642e-016
		,2.769786253e-016
		,3.157234532e-016
		,3.452388860e-016
		,3.659878893e-016
		,3.817514809e-016
		,3.932300046e-016
		,4.023935271e-016
		,4.099723129e-016
		,4.151089615e-016
		,4.186545445e-016
		,4.204924380e-016
		,4.227699110e-016
		,4.258900089e-016
		,4.295901707e-016
		,4.337993341e-016
		,4.382701868e-016
		,4.425600498e-016
		,4.462730714e-016
		,4.493646918e-016
		,4.519364307e-016
		,4.540961733e-016
		,4.559343827e-016
		,4.575223562e-016
		,4.589142687e-016
		,4.601506239e-016
		,1.657131868e-016
		,1.659302111e-016
		,1.661572834e-016
		,1.663976882e-016
		,1.666563662e-016
		,1.669406156e-016
		,1.672612487e-016
		,1.676361026e-016
		,1.680961028e-016
		,1.686977019e-016
		,1.695622276e-016
		,1.709411417e-016
		,1.731185851e-016
		,1.771339214e-016
		,1.828604839e-016
		,1.976605563e-016
		,2.291168201e-016
		,2.664361064e-016
		,3.018353354e-016
		,3.329757345e-016
		,3.581434587e-016
		,3.758139025e-016
		,3.880349834e-016
		,3.972644711e-016
		,4.040919544e-016
		,4.092730494e-016
		,4.132517189e-016
		,4.163595068e-016
		,4.190013732e-016
		,4.214675602e-016
		,4.246955726e-016
		,4.292776880e-016
		,4.344851000e-016
		,4.394697548e-016
		,4.437027335e-016
		,4.471382375e-016
		,4.499723263e-016
		,4.523693191e-016
		,4.544233957e-016
		,4.561931519e-016
		,4.577291421e-016
		,1.650877674e-016
		,1.652882720e-016
		,1.654971808e-016
		,1.657126616e-016
		,1.659353784e-016
		,1.661673459e-016
		,1.664117562e-016
		,1.666732978e-016
		,1.669587144e-016
		,1.672787677e-016
		,1.676521630e-016
		,1.681126834e-016
		,1.687406200e-016
		,1.697187839e-016
		,1.715218180e-016
		,1.748643155e-016
		,1.828969246e-016
		,2.029117552e-016
		,2.372116558e-016
		,2.761114439e-016
		,3.113414099e-016
		,3.392466505e-016
		,3.605020333e-016
		,3.758679692e-016
		,3.868341921e-016
		,3.949551754e-016
		,4.010740419e-016
		,4.058724311e-016
		,4.098170893e-016
		,4.132819627e-016
		,4.166486004e-016
		,4.203393799e-016
		,4.247330994e-016
		,4.299458507e-016
		,4.353978059e-016
		,4.403741431e-016
		,4.445490975e-016
		,4.479402786e-016
		,4.507021424e-016
		,4.529943848e-016
		,4.549367710e-016
		,1.645437287e-016
		,1.646807839e-016
		,1.648650581e-016
		,1.650674611e-016
		,1.652784591e-016
		,1.654953432e-016
		,1.657180261e-016
		,1.659477014e-016
		,1.661865067e-016
		,1.664376171e-016
		,1.667056615e-016
		,1.669976219e-016
		,1.673247910e-016
		,1.677075173e-016
		,1.681881662e-016
		,1.688701248e-016
		,1.700422771e-016
		,1.725768133e-016
		,1.790433517e-016
		,1.953480635e-016
		,2.271373944e-016
		,2.678777485e-016
		,3.048573605e-016
		,3.340396206e-016
		,3.561585459e-016
		,3.723178788e-016
		,3.839505078e-016
		,3.924676870e-016
		,3.989141872e-016
		,4.039877695e-016
		,4.081711804e-016
		,4.118575113e-016
		,4.154538495e-016
		,4.194267638e-016
		,4.241620183e-016
		,4.296059807e-016
		,4.351614694e-016
		,4.401771301e-016
		,4.443732972e-016
		,4.477873871e-016
		,4.505707730e-016
		,1.647864962e-016
		,1.643439512e-016
		,1.643249825e-016
		,1.644548682e-016
		,1.646380819e-016
		,1.648421668e-016
		,1.650561103e-016
		,1.652763549e-016
		,1.655021731e-016
		,1.657341871e-016
		,1.659737764e-016
		,1.662224910e-016
		,1.664822281e-016
		,1.667533052e-016
		,1.670332913e-016
		,1.673450936e-016
		,1.677473273e-016
		,1.682588423e-016
		,1.690965050e-016
		,1.707643408e-016
		,1.750344981e-016
		,1.868761907e-016
		,2.137735846e-016
		,2.539723584e-016
		,2.939863691e-016
		,3.263329115e-016
		,3.507443616e-016
		,3.684575442e-016
		,3.810876488e-016
		,3.902652815e-016
		,3.971681805e-016
		,4.025688089e-016
		,4.069949954e-016
		,4.108678213e-016
		,4.146144700e-016
		,4.187150905e-016
		,4.235507043e-016
		,4.290751493e-016
		,4.346984578e-016
		,4.397710808e-016
		,4.440139791e-016
		,1.711977997e-016
		,1.664704964e-016
		,1.646797214e-016
		,1.641597630e-016
		,1.641117782e-016
		,1.642306985e-016
		,1.644106511e-016
		,1.646155224e-016
		,1.648327637e-016
		,1.650579599e-016
		,1.652891999e-016
		,1.655248743e-016
		,1.657647779e-016
		,1.659974230e-016
		,1.662223357e-016
		,1.664610967e-016
		,1.667505061e-016
		,1.670597050e-016
		,1.674103781e-016
		,1.678660280e-016
		,1.684915308e-016
		,1.697028404e-016
		,1.726763060e-016
		,1.812895492e-016
		,2.027894240e-016
		,2.400569694e-016
		,2.818432363e-016
		,3.172987014e-016
		,3.443002080e-016
		,3.638411812e-016
		,3.776639167e-016
		,3.876369936e-016
		,3.950835110e-016
		,4.008708286e-016
		,4.055834622e-016
		,4.096786020e-016
		,4.136085092e-016
		,4.178443539e-016
		,4.227864670e-016
		,4.284046289e-016
		,4.341095254e-016
		,2.084635408e-016
		,1.842318453e-016
		,1.720782596e-016
		,1.666611791e-016
		,1.646118433e-016
		,1.639968577e-016
		,1.639123419e-016
		,1.640161305e-016
		,1.641903311e-016
		,1.643944044e-016
		,1.646125139e-016
		,1.648381324e-016
		,1.650655149e-016
		,1.652712728e-016
		,1.654811068e-016
		,1.657111185e-016
		,1.659674309e-016
		,1.662388109e-016
		,1.665110174e-016
		,1.668163111e-016
		,1.671361568e-016
		,1.675507133e-016
		,1.680802316e-016
		,1.690393749e-016
		,1.712861308e-016
		,1.777092205e-016
		,1.944695606e-016
		,2.274463345e-016
		,2.692635446e-016
		,3.072242708e-016
		,3.368821019e-016
		,3.584055017e-016
		,3.736196305e-016
		,3.845529649e-016
		,3.926606527e-016
		,3.989108717e-016
		,4.039610793e-016
		,4.083256156e-016
		,4.124489448e-016
		,4.168230356e-016
		,4.218846467e-016
		,2.937863629e-016
		,2.562403764e-016
		,2.164389395e-016
		,1.879313770e-016
		,1.733371103e-016
		,1.669829440e-016
		,1.645996278e-016
		,1.638666896e-016
		,1.637374568e-016
		,1.638204733e-016
		,1.639804062e-016
		,1.641742089e-016
		,1.643649445e-016
		,1.645440166e-016
		,1.647677455e-016
		,1.649751522e-016
		,1.652293432e-016
		,1.654916484e-016
		,1.657609587e-016
		,1.660126294e-016
		,1.662841859e-016
		,1.665690589e-016
		,1.669125130e-016
		,1.672651958e-016
		,1.677858348e-016
		,1.686123818e-016
		,1.705008404e-016
		,1.754260085e-016
		,1.884162928e-016
		,2.165548965e-016
		,2.567998985e-016
		,2.964847260e-016
		,3.287126796e-016
		,3.522006768e-016
		,3.689360157e-016
		,3.809831415e-016
		,3.898847776e-016
		,3.967037259e-016
		,4.021918313e-016
		,4.068578176e-016
		,4.111685869e-016
		,3.495508895e-016
		,3.303373203e-016
		,3.036950134e-016
		,2.675864116e-016
		,2.261377693e-016
		,1.930249275e-016
		,1.751557528e-016
		,1.674920516e-016
		,1.646605306e-016
		,1.637744731e-016
		,1.635847833e-016
		,1.636267813e-016
		,1.637273415e-016
		,1.638714457e-016
		,1.640770357e-016
		,1.642629043e-016
		,1.645037984e-016
		,1.647654273e-016
		,1.650149610e-016
		,1.652616393e-016
		,1.655186140e-016
		,1.657858015e-016
		,1.660515202e-016
		,1.663432504e-016
		,1.666900600e-016
		,1.670435396e-016
		,1.675582685e-016
		,1.683410972e-016
		,1.700313168e-016
		,1.739564095e-016
		,1.841487269e-016
		,2.075662161e-016
		,2.449419736e-016
		,2.855361439e-016
		,3.199367911e-016
		,3.453424673e-016
		,3.636249056e-016
		,3.768716804e-016
		,3.867019397e-016
		,3.942639126e-016
		,4.002705049e-016
		,3.780139171e-016
		,3.680543303e-016
		,3.549617985e-016
		,3.373032524e-016
		,3.127449598e-016
		,2.788140335e-016
		,2.370671542e-016
		,1.996482271e-016
		,1.776396795e-016
		,1.681596016e-016
		,1.647469585e-016
		,1.636673786e-016
		,1.633680371e-016
		,1.633881893e-016
		,1.634819268e-016
		,1.636283298e-016
		,1.638386506e-016
		,1.640721899e-016
		,1.642921563e-016
		,1.645179480e-016
		,1.647685395e-016
		,1.650136387e-016
		,1.652776322e-016
		,1.655489946e-016
		,1.658189058e-016
		,1.661339914e-016
		,1.664396664e-016
		,1.668702262e-016
		,1.673615231e-016
		,1.682387615e-016
		,1.697730904e-016
		,1.729202715e-016
		,1.811768361e-016
		,2.004374920e-016
		,2.340820091e-016
		,2.747777387e-016
		,3.107032710e-016
		,3.379649755e-016
		,3.577702843e-016
		,3.722467021e-016
		,3.831626273e-016
		,3.935566958e-016
		,3.876282313e-016
		,3.803076859e-016
		,3.710579061e-016
		,3.590379512e-016
		,3.428755255e-016
		,3.200889896e-016
		,2.882618536e-016
		,2.465980765e-016
		,2.051301807e-016
		,1.795073064e-016
		,1.684631825e-016
		,1.646467493e-016
		,1.635376399e-016
		,1.632097153e-016
		,1.632035240e-016
		,1.633155098e-016
		,1.634878250e-016
		,1.636481448e-016
		,1.638411308e-016
		,1.640525051e-016
		,1.642766636e-016
		,1.645200986e-016
		,1.647678749e-016
		,1.650278382e-016
		,1.652936540e-016
		,1.655908990e-016
		,1.659077634e-016
		,1.662209689e-016
		,1.666747214e-016
		,1.672444719e-016
		,1.682228796e-016
		,1.696853258e-016
		,1.724748158e-016
		,1.789763472e-016
		,1.946727636e-016
		,2.245384497e-016
		,2.644399261e-016
		,3.011935721e-016
		,3.301719520e-016
		,3.515481505e-016
		,4.044229082e-016
		,4.004949017e-016
		,3.958234377e-016
		,3.898102013e-016
		,3.815658305e-016
		,3.715650525e-016
		,3.592114776e-016
		,3.436737105e-016
		,3.219893639e-016
		,2.907114009e-016
		,2.478086515e-016
		,2.037253559e-016
		,1.776868326e-016
		,1.679570098e-016
		,1.645403997e-016
		,1.634379755e-016
		,1.631396483e-016
		,1.631190005e-016
		,1.631854365e-016
		,1.633108853e-016
		,1.634532005e-016
		,1.636344546e-016
		,1.638283527e-016
		,1.640422073e-016
		,1.642696667e-016
		,1.645163592e-016
		,1.647707243e-016
		,1.650356804e-016
		,1.653597986e-016
		,1.656673756e-016
		,1.660391807e-016
		,1.664496541e-016
		,1.671780443e-016
		,1.682169526e-016
		,1.696652362e-016
		,1.722800899e-016
		,1.778104808e-016
		,1.904270131e-016
		,2.164858495e-016
		,2.543654880e-016
		,2.914977175e-016
		,4.121264747e-016
		,4.093872836e-016
		,4.061332865e-016
		,4.022286102e-016
		,3.976684277e-016
		,3.920521084e-016
		,3.849653912e-016
		,3.757767345e-016
		,3.634578929e-016
		,3.453068373e-016
		,3.184422453e-016
		,2.769328132e-016
		,2.278433719e-016
		,1.936924039e-016
		,1.754364215e-016
		,1.676079057e-016
		,1.645704446e-016
		,1.634345502e-016
		,1.630795109e-016
		,1.630176170e-016
		,1.630656259e-016
		,1.631614111e-016
		,1.632923769e-016
		,1.634405064e-016
		,1.636181837e-016
		,1.638127710e-016
		,1.640318225e-016
		,1.642648364e-016
		,1.645151716e-016
		,1.648003140e-016
		,1.651092926e-016
		,1.654308286e-016
		,1.658347871e-016
		,1.662784779e-016
		,1.670393822e-016
		,1.681954060e-016
		,1.696961809e-016
		,1.722284423e-016
		,1.770916773e-016
		,1.874945506e-016
		,2.109818913e-016
		,4.208951588e-016
		,4.189717514e-016
		,4.169873093e-016
		,4.144388970e-016
		,4.115011898e-016
		,4.068325584e-016
		,4.016938723e-016
		,3.958422577e-016
		,3.873108123e-016
		,3.676797064e-016
		,3.498545564e-016
		,3.295487395e-016
		,2.963802805e-016
		,2.533953730e-016
		,2.117851395e-016
		,1.857294232e-016
		,1.744920658e-016
		,1.677817724e-016
		,1.646744518e-016
		,1.634387010e-016
		,1.630357109e-016
		,1.629461880e-016
		,1.629625232e-016
		,1.630416308e-016
		,1.631440906e-016
		,1.632767461e-016
		,1.634278626e-016
		,1.636050743e-016
		,1.638041255e-016
		,1.640258694e-016
		,1.642664596e-016
		,1.645623314e-016
		,1.648466810e-016
		,1.652181712e-016
		,1.656128551e-016
		,1.661257042e-016
		,1.668769368e-016
		,1.680840117e-016
		,1.697789119e-016
		,1.722789921e-016
		,1.766722873e-016
		,4.304302153e-016
		,4.280910382e-016
		,4.236132434e-016
		,4.218674486e-016
		,4.182764962e-016
		,4.160117869e-016
		,4.123582927e-016
		,4.015394465e-016
		,3.983746130e-016
		,3.925983413e-016
		,3.833968810e-016
		,3.682754718e-016
		,3.446236738e-016
		,3.104427381e-016
		,2.585418661e-016
		,2.216954818e-016
		,2.016578116e-016
		,1.849736767e-016
		,1.746970565e-016
		,1.682038796e-016
		,1.648299725e-016
		,1.634645162e-016
		,1.630090414e-016
		,1.628812468e-016
		,1.628874491e-016
		,1.629419288e-016
		,1.630285549e-016
		,1.631358163e-016
		,1.632644167e-016
		,1.634188263e-016
		,1.635962340e-016
		,1.637977483e-016
		,1.640433718e-016
		,1.643096677e-016
		,1.646132185e-016
		,1.649899481e-016
		,1.654139652e-016
		,1.660064785e-016
		,1.667637428e-016
		,1.677020713e-016
		,1.698864997e-016
		,4.361915960e-016
		,4.350158534e-016
		,4.337886462e-016
		,4.311151309e-016
		,4.280541053e-016
		,4.236453874e-016
		,4.202022821e-016
		,4.184653327e-016
		,4.152376179e-016
		,4.105195752e-016
		,4.035245501e-016
		,3.911648016e-016
		,3.685061316e-016
		,3.442977457e-016
		,3.070707508e-016
		,2.671640859e-016
		,2.403111097e-016
		,2.147639881e-016
		,1.982957348e-016
		,1.860688115e-016
		,1.757035202e-016
		,1.686543745e-016
		,1.649960911e-016
		,1.635091636e-016
		,1.629912340e-016
		,1.628429585e-016
		,1.628286588e-016
		,1.628669256e-016
		,1.629332161e-016
		,1.630177492e-016
		,1.631293584e-016
		,1.632572821e-016
		,1.634132311e-016
		,1.635982581e-016
		,1.638307735e-016
		,1.640702461e-016
		,1.644047092e-016
		,1.647599022e-016
		,1.652070191e-016
		,1.659266656e-016
		,1.667338796e-016
		,4.404902234e-016
		,4.396864357e-016
		,4.388383263e-016
		,4.379048428e-016
		,4.352977523e-016
		,4.346804777e-016
		,4.338604890e-016
		,4.326891908e-016
		,4.281436778e-016
		,4.205968241e-016
		,4.171903344e-016
		,4.080636497e-016
		,3.969666884e-016
		,3.778535618e-016
		,3.387626529e-016
		,2.979814996e-016
		,2.797372035e-016
		,2.510340779e-016
		,2.302556417e-016
		,2.137711083e-016
		,2.008844516e-016
		,1.876183682e-016
		,1.765898342e-016
		,1.691141990e-016
		,1.651923279e-016
		,1.635651415e-016
		,1.629895672e-016
		,1.628169250e-016
		,1.627843401e-016
		,1.628098270e-016
		,1.628579419e-016
		,1.629302363e-016
		,1.630160967e-016
		,1.631266257e-016
		,1.632543501e-016
		,1.634369140e-016
		,1.636281789e-016
		,1.638731015e-016
		,1.641829463e-016
		,1.645503998e-016
		,1.650029912e-016
		,4.478131140e-016
		,4.471264623e-016
		,4.400674769e-016
		,4.371046076e-016
		,4.374375336e-016
		,4.373143885e-016
		,4.370967373e-016
		,4.367585936e-016
		,4.357336846e-016
		,4.349388965e-016
		,4.335573889e-016
		,4.292707556e-016
		,4.227498111e-016
		,4.005326204e-016
		,3.694051709e-016
		,3.472141206e-016
		,3.208058381e-016
		,2.897275234e-016
		,2.658857820e-016
		,2.435832855e-016
		,2.302003762e-016
		,2.172509688e-016
		,2.027959982e-016
		,1.889282572e-016
		,1.774595647e-016
		,1.696038056e-016
		,1.654083560e-016
		,1.636347049e-016
		,1.629998256e-016
		,1.628020848e-016
		,1.627578582e-016
		,1.627671838e-016
		,1.628052103e-016
		,1.628598772e-016
		,1.629344017e-016
		,1.630193057e-016
		,1.631259552e-016
		,1.632914125e-016
		,1.634625483e-016
		,1.637077701e-016
		,1.639675462e-016
		,4.504435431e-016
		,4.483918724e-016
		,4.480222805e-016
		,4.476918167e-016
		,4.474605194e-016
		,4.473075379e-016
		,4.472507628e-016
		,4.472879411e-016
		,4.472393191e-016
		,4.472146168e-016
		,4.418716849e-016
		,4.354761189e-016
		,4.277481465e-016
		,4.028798338e-016
		,3.981204778e-016
		,3.907805227e-016
		,3.612947390e-016
		,3.368854726e-016
		,2.980845791e-016
		,2.835195221e-016
		,2.524708614e-016
		,2.456713247e-016
		,2.338431073e-016
		,2.193893345e-016
		,2.043565053e-016
		,1.901736963e-016
		,1.783441775e-016
		,1.701263724e-016
		,1.656472513e-016
		,1.637234763e-016
		,1.630206746e-016
		,1.627976094e-016
		,1.627396536e-016
		,1.627380153e-016
		,1.627688604e-016
		,1.628127830e-016
		,1.628707971e-016
		,1.629305575e-016
		,1.630373241e-016
		,1.631594522e-016
		,1.633476760e-016
		,4.565563831e-016
		,4.561339399e-016
		,4.558420450e-016
		,4.556223650e-016
		,4.555166293e-016
		,4.555409272e-016
		,4.557374090e-016
		,4.509436667e-016
		,4.486645391e-016
		,4.488023898e-016
		,4.489427595e-016
		,4.488310940e-016
		,4.272891040e-016
		,4.233060647e-016
		,4.205491342e-016
		,4.141515529e-016
		,3.928662123e-016
		,3.722102296e-016
		,3.309253271e-016
		,3.154445085e-016
		,2.968753759e-016
		,2.649716552e-016
		,2.592080486e-016
		,2.485426552e-016
		,2.362079433e-016
		,2.211282564e-016
		,2.057892286e-016
		,1.913948488e-016
		,1.792524482e-016
		,1.706838492e-016
		,1.659124600e-016
		,1.638251688e-016
		,1.630531553e-016
		,1.627951100e-016
		,1.627282887e-016
		,1.627264400e-016
		,1.627439021e-016
		,1.627797659e-016
		,1.628200935e-016
		,1.628726101e-016
		,1.629671176e-016
		,1.675309004e-016
		,1.680157091e-016
		,1.686405767e-016
		,1.694722937e-016
		,1.706034484e-016
		,1.721812213e-016
		,1.743870229e-016
		,1.773799404e-016
		,1.816047352e-016
		,1.867939602e-016
		,1.935637680e-016
		,1.999082306e-016
		,2.090437674e-016
		,2.191347733e-016
		,2.357904934e-016
		,2.625415223e-016
		,3.052189210e-016
		,3.373638646e-016
		,3.647948908e-016
		,3.846075881e-016
		,3.979792333e-016
		,4.069117674e-016
		,4.099987379e-016
		,4.129405041e-016
		,4.156914472e-016
		,4.163151188e-016
		,4.167175430e-016
		,4.192580235e-016
		,4.232123615e-016
		,4.284119599e-016
		,4.347553411e-016
		,4.401893157e-016
		,4.447442714e-016
		,4.485742603e-016
		,4.518829730e-016
		,4.548314825e-016
		,4.573267334e-016
		,4.593477508e-016
		,4.610295994e-016
		,4.624831386e-016
		,4.637746367e-016
		,1.665349524e-016
		,1.668138742e-016
		,1.671301638e-016
		,1.675007125e-016
		,1.679528253e-016
		,1.685286702e-016
		,1.692974102e-016
		,1.703752608e-016
		,1.719551096e-016
		,1.742771450e-016
		,1.778827847e-016
		,1.827242276e-016
		,1.897482789e-016
		,1.965270025e-016
		,2.078418279e-016
		,2.246597950e-016
		,2.498308264e-016
		,2.928587513e-016
		,3.340810417e-016
		,3.603286934e-016
		,3.797013540e-016
		,3.938765453e-016
		,4.036154172e-016
		,4.102470826e-016
		,4.144035122e-016
		,4.158635236e-016
		,4.180347493e-016
		,4.211518563e-016
		,4.236069250e-016
		,4.259461320e-016
		,4.295336027e-016
		,4.346122189e-016
		,4.401182782e-016
		,4.451319352e-016
		,4.493107571e-016
		,4.526956998e-016
		,4.554420043e-016
		,4.576887556e-016
		,4.595262163e-016
		,4.610036411e-016
		,4.621576237e-016
		,1.658426703e-016
		,1.660685785e-016
		,1.663075137e-016
		,1.665638459e-016
		,1.668441342e-016
		,1.671582936e-016
		,1.675216405e-016
		,1.679587502e-016
		,1.685109842e-016
		,1.692603928e-016
		,1.703654271e-016
		,1.720458439e-016
		,1.747146903e-016
		,1.792016347e-016
		,1.849466636e-016
		,1.947892988e-016
		,2.163293705e-016
		,2.501829394e-016
		,2.870404338e-016
		,3.210885870e-016
		,3.494669067e-016
		,3.688419185e-016
		,3.836858006e-016
		,3.958189429e-016
		,4.049233293e-016
		,4.111860829e-016
		,4.158986240e-016
		,4.194914760e-016
		,4.216842225e-016
		,4.235482959e-016
		,4.263560900e-016
		,4.297574070e-016
		,4.338199669e-016
		,4.382273140e-016
		,4.424596959e-016
		,4.461963103e-016
		,4.493353269e-016
		,4.519360602e-016
		,4.541052943e-016
		,4.559413656e-016
		,4.575212655e-016
		,1.652240497e-016
		,1.654318214e-016
		,1.656494325e-016
		,1.658757242e-016
		,1.661120729e-016
		,1.663613591e-016
		,1.666279277e-016
		,1.669181065e-016
		,1.672413724e-016
		,1.676125465e-016
		,1.680562688e-016
		,1.686235437e-016
		,1.694216242e-016
		,1.706767782e-016
		,1.727771125e-016
		,1.762747860e-016
		,1.827053898e-016
		,1.997793528e-016
		,2.326340972e-016
		,2.696925642e-016
		,3.071082533e-016
		,3.378210956e-016
		,3.608695451e-016
		,3.768455111e-016
		,3.881831159e-016
		,3.967363109e-016
		,4.030526250e-016
		,4.078664885e-016
		,4.117142289e-016
		,4.150007736e-016
		,4.180615044e-016
		,4.211550691e-016
		,4.248787033e-016
		,4.297247113e-016
		,4.350268933e-016
		,4.399922997e-016
		,4.441928701e-016
		,4.476057183e-016
		,4.504009738e-016
		,4.527369819e-016
		,4.547207528e-016
		,1.646867327e-016
		,1.648356886e-016
		,1.650308432e-016
		,1.652449827e-016
		,1.654696119e-016
		,1.657028482e-016
		,1.659454494e-016
		,1.661995917e-016
		,1.664686405e-016
		,1.667573870e-016
		,1.670727041e-016
		,1.674248935e-016
		,1.678305833e-016
		,1.683196443e-016
		,1.689535972e-016
		,1.698790241e-016
		,1.714901562e-016
		,1.749138053e-016
		,1.831958881e-016
		,2.023102652e-016
		,2.358075928e-016
		,2.753400930e-016
		,3.100737583e-016
		,3.375222863e-016
		,3.585261769e-016
		,3.739879409e-016
		,3.851779542e-016
		,3.934041364e-016
		,3.996510568e-016
		,4.045822655e-016
		,4.086607286e-016
		,4.122677136e-016
		,4.158029589e-016
		,4.197281180e-016
		,4.244250843e-016
		,4.298369665e-016
		,4.353646949e-016
		,4.403564611e-016
		,4.445324295e-016
		,4.479295659e-016
		,4.506986635e-016
		,1.648911017e-016
		,1.644939687e-016
		,1.644999109e-016
		,1.646487712e-016
		,1.648503653e-016
		,1.650745152e-016
		,1.653115817e-016
		,1.655592104e-016
		,1.658179430e-016
		,1.660898152e-016
		,1.663778449e-016
		,1.666869793e-016
		,1.670199313e-016
		,1.673751653e-016
		,1.677585473e-016
		,1.681014230e-016
		,1.684658048e-016
		,1.691395768e-016
		,1.706659860e-016
		,1.731989075e-016
		,1.791817409e-016
		,1.948937442e-016
		,2.264053641e-016
		,2.650785545e-016
		,3.008447676e-016
		,3.300491747e-016
		,3.525927240e-016
		,3.695142909e-016
		,3.817018085e-016
		,3.905861385e-016
		,3.973384445e-016
		,4.026641379e-016
		,4.070500850e-016
		,4.109060223e-016
		,4.146759711e-016
		,4.188861997e-016
		,4.238388083e-016
		,4.294007286e-016
		,4.350161390e-016
		,4.400624986e-016
		,4.442758581e-016
		,1.708766127e-016
		,1.664687104e-016
		,1.648089421e-016
		,1.643488316e-016
		,1.643372373e-016
		,1.644867490e-016
		,1.646979537e-016
		,1.649376313e-016
		,1.651951293e-016
		,1.654677001e-016
		,1.657563668e-016
		,1.660611689e-016
		,1.663759168e-016
		,1.666904032e-016
		,1.669792477e-016
		,1.670513609e-016
		,1.670211902e-016
		,1.674073315e-016
		,1.679444275e-016
		,1.686865294e-016
		,1.699962995e-016
		,1.721999788e-016
		,1.769521702e-016
		,1.905352365e-016
		,2.165921503e-016
		,2.518398262e-016
		,2.889269260e-016
		,3.208039146e-016
		,3.457441777e-016
		,3.646858038e-016
		,3.779957610e-016
		,3.876699364e-016
		,3.949690116e-016
		,4.006916868e-016
		,4.053921976e-016
		,4.095265235e-016
		,4.136040338e-016
		,4.180785979e-016
		,4.231468692e-016
		,4.288209874e-016
		,4.345318346e-016
		,2.046841132e-016
		,1.826907558e-016
		,1.716505748e-016
		,1.666622869e-016
		,1.647846043e-016
		,1.642511402e-016
		,1.642210306e-016
		,1.643744329e-016
		,1.646013549e-016
		,1.648656248e-016
		,1.651548432e-016
		,1.654580687e-016
		,1.657572835e-016
		,1.660495953e-016
		,1.662094842e-016
		,1.661289069e-016
		,1.659618100e-016
		,1.663037491e-016
		,1.665315694e-016
		,1.671024434e-016
		,1.676105388e-016
		,1.688041563e-016
		,1.696192350e-016
		,1.721359673e-016
		,1.769526063e-016
		,1.894588490e-016
		,2.106581218e-016
		,2.410724003e-016
		,2.764044044e-016
		,3.095201158e-016
		,3.371011477e-016
		,3.583834901e-016
		,3.730744377e-016
		,3.837942442e-016
		,3.918695351e-016
		,3.981795694e-016
		,4.033427630e-016
		,4.079309390e-016
		,4.124743977e-016
		,4.171073221e-016
		,4.223186957e-016
		,2.879504825e-016
		,2.500060373e-016
		,2.117330164e-016
		,1.858182889e-016
		,1.727524890e-016
		,1.669983052e-016
		,1.648503296e-016
		,1.642325295e-016
		,1.641861213e-016
		,1.643504684e-016
		,1.645966908e-016
		,1.648658806e-016
		,1.651320417e-016
		,1.653846307e-016
		,1.653174311e-016
		,1.651250676e-016
		,1.650950484e-016
		,1.652760023e-016
		,1.658264508e-016
		,1.660561059e-016
		,1.666298541e-016
		,1.670223176e-016
		,1.676920026e-016
		,1.685446225e-016
		,1.700279669e-016
		,1.725056314e-016
		,1.782163213e-016
		,1.898751738e-016
		,2.071519943e-016
		,2.326898168e-016
		,2.645331041e-016
		,2.973114982e-016
		,3.276398532e-016
		,3.508195543e-016
		,3.671025598e-016
		,3.791189550e-016
		,3.881724845e-016
		,3.952202703e-016
		,4.010611012e-016
		,4.064315789e-016
		,4.112125485e-016
		,3.459400057e-016
		,3.257503437e-016
		,2.979615937e-016
		,2.610271691e-016
		,2.205090621e-016
		,1.901671527e-016
		,1.743568300e-016
		,1.675487060e-016
		,1.650521942e-016
		,1.643322514e-016
		,1.642505444e-016
		,1.643636916e-016
		,1.645719834e-016
		,1.646077043e-016
		,1.643018266e-016
		,1.642720404e-016
		,1.642139626e-016
		,1.643211963e-016
		,1.650719023e-016
		,1.654359486e-016
		,1.658651018e-016
		,1.661895521e-016
		,1.664758669e-016
		,1.669051590e-016
		,1.679537466e-016
		,1.684743543e-016
		,1.705248524e-016
		,1.733643297e-016
		,1.801796705e-016
		,1.905605249e-016
		,2.053461288e-016
		,2.266031052e-016
		,2.541217954e-016
		,2.852608695e-016
		,3.180233148e-016
		,3.421989322e-016
		,3.601452562e-016
		,3.736101604e-016
		,3.838312310e-016
		,3.919450383e-016
		,3.990735257e-016
		,3.761086198e-016
		,3.656580692e-016
		,3.519760714e-016
		,3.334789645e-016
		,3.077907155e-016
		,2.726166295e-016
		,2.309636891e-016
		,1.960946085e-016
		,1.766803719e-016
		,1.683779581e-016
		,1.653571835e-016
		,1.644402863e-016
		,1.641880751e-016
		,1.638270843e-016
		,1.633333204e-016
		,1.636381658e-016
		,1.633423412e-016
		,1.636016306e-016
		,1.643066472e-016
		,1.647775088e-016
		,1.651513285e-016
		,1.653364055e-016
		,1.657582817e-016
		,1.661291689e-016
		,1.664026217e-016
		,1.670487628e-016
		,1.678196256e-016
		,1.690651705e-016
		,1.709716817e-016
		,1.749112254e-016
		,1.817214507e-016
		,1.908243673e-016
		,2.045292571e-016
		,2.225185585e-016
		,2.457635682e-016
		,2.751357649e-016
		,3.082810570e-016
		,3.329165470e-016
		,3.522912915e-016
		,3.672393695e-016
		,3.790003136e-016
		,3.927895286e-016
		,3.866428184e-016
		,3.789109983e-016
		,3.692526065e-016
		,3.567602034e-016
		,3.399182331e-016
		,3.164446913e-016
		,2.836356298e-016
		,2.422490190e-016
		,2.032341701e-016
		,1.793643700e-016
		,1.691203347e-016
		,1.652953856e-016
		,1.635971749e-016
		,1.629411164e-016
		,1.630960754e-016
		,1.626059023e-016
		,1.631398939e-016
		,1.636306112e-016
		,1.641584222e-016
		,1.644210488e-016
		,1.646000247e-016
		,1.650027324e-016
		,1.652490895e-016
		,1.656016855e-016
		,1.660119366e-016
		,1.664358174e-016
		,1.672171867e-016
		,1.676019986e-016
		,1.696330487e-016
		,1.717903679e-016
		,1.770046528e-016
		,1.836930997e-016
		,1.919020451e-016
		,2.029944612e-016
		,2.186816967e-016
		,2.393268670e-016
		,2.678606098e-016
		,2.987619680e-016
		,3.233896181e-016
		,3.437684976e-016
		,4.033338365e-016
		,3.993055432e-016
		,3.945200271e-016
		,3.887342624e-016
		,3.815880990e-016
		,3.722138997e-016
		,3.604534081e-016
		,3.446824159e-016
		,3.227025720e-016
		,2.902579583e-016
		,2.484457946e-016
		,2.067022406e-016
		,1.796389567e-016
		,1.680196612e-016
		,1.645004486e-016
		,1.631170619e-016
		,1.623619122e-016
		,1.628405768e-016
		,1.631817402e-016
		,1.636829509e-016
		,1.636939416e-016
		,1.640382649e-016
		,1.642537158e-016
		,1.645453537e-016
		,1.648318628e-016
		,1.652018046e-016
		,1.654652835e-016
		,1.657584478e-016
		,1.665567869e-016
		,1.671504991e-016
		,1.680119978e-016
		,1.695710079e-016
		,1.731533718e-016
		,1.789344001e-016
		,1.853685446e-016
		,1.935923928e-016
		,2.038880116e-016
		,2.165776910e-016
		,2.329060121e-016
		,2.619730956e-016
		,2.894088330e-016
		,4.114859810e-016
		,4.086246591e-016
		,4.045557036e-016
		,3.998138941e-016
		,3.945096521e-016
		,3.889362218e-016
		,3.818936547e-016
		,3.728948111e-016
		,3.611875980e-016
		,3.452813251e-016
		,3.226752559e-016
		,2.892707645e-016
		,2.429294050e-016
		,1.990276517e-016
		,1.766407285e-016
		,1.674567527e-016
		,1.638748629e-016
		,1.632844313e-016
		,1.630820467e-016
		,1.633391213e-016
		,1.633131165e-016
		,1.634998946e-016
		,1.637282729e-016
		,1.638761025e-016
		,1.642351766e-016
		,1.644298445e-016
		,1.647257695e-016
		,1.649959642e-016
		,1.653004079e-016
		,1.657293461e-016
		,1.665091276e-016
		,1.670689549e-016
		,1.684895497e-016
		,1.698860555e-016
		,1.741184781e-016
		,1.803683126e-016
		,1.867860932e-016
		,1.948356139e-016
		,2.043450694e-016
		,2.152686304e-016
		,2.300154201e-016
		,4.186291392e-016
		,4.165440005e-016
		,4.141290138e-016
		,4.112579906e-016
		,4.080950350e-016
		,4.043338138e-016
		,3.997552297e-016
		,3.940371817e-016
		,3.862564753e-016
		,3.762899652e-016
		,3.627729159e-016
		,3.419641408e-016
		,3.108435962e-016
		,2.646301369e-016
		,2.225379250e-016
		,1.906699233e-016
		,1.744141272e-016
		,1.678335401e-016
		,1.646479837e-016
		,1.636293980e-016
		,1.632814919e-016
		,1.633131659e-016
		,1.632731389e-016
		,1.635529475e-016
		,1.636624049e-016
		,1.638816044e-016
		,1.640534317e-016
		,1.643015568e-016
		,1.645736163e-016
		,1.648450495e-016
		,1.651442308e-016
		,1.658377199e-016
		,1.663508511e-016
		,1.673064449e-016
		,1.686011277e-016
		,1.705148795e-016
		,1.743013612e-016
		,1.809577217e-016
		,1.877604358e-016
		,1.953603530e-016
		,2.040429967e-016
		,4.261662097e-016
		,4.245402917e-016
		,4.227972750e-016
		,4.207163145e-016
		,4.170825445e-016
		,4.148186724e-016
		,4.121390814e-016
		,4.084917168e-016
		,4.038744997e-016
		,3.944870811e-016
		,3.799811573e-016
		,3.661951015e-016
		,3.509914891e-016
		,3.252329071e-016
		,2.885557861e-016
		,2.445727260e-016
		,2.053732098e-016
		,1.860926351e-016
		,1.747449380e-016
		,1.681395330e-016
		,1.650049835e-016
		,1.637190405e-016
		,1.634036706e-016
		,1.632967146e-016
		,1.633994056e-016
		,1.634693996e-016
		,1.636283884e-016
		,1.637843686e-016
		,1.639642953e-016
		,1.641998667e-016
		,1.644202331e-016
		,1.647139307e-016
		,1.651386804e-016
		,1.657334552e-016
		,1.662384474e-016
		,1.675132430e-016
		,1.687590259e-016
		,1.711047162e-016
		,1.747452380e-016
		,1.788788187e-016
		,1.884106468e-016
		,4.342441244e-016
		,4.305210622e-016
		,4.274008418e-016
		,4.261820534e-016
		,4.247569857e-016
		,4.229156496e-016
		,4.208160705e-016
		,4.170557491e-016
		,4.083486323e-016
		,4.051059590e-016
		,4.003974242e-016
		,3.939310866e-016
		,3.837307768e-016
		,3.649982085e-016
		,3.388793419e-016
		,3.011282763e-016
		,2.449442468e-016
		,2.213881386e-016
		,2.004830431e-016
		,1.854064869e-016
		,1.755010195e-016
		,1.686838998e-016
		,1.652508795e-016
		,1.639305341e-016
		,1.634086777e-016
		,1.633435437e-016
		,1.633792999e-016
		,1.634691926e-016
		,1.636059209e-016
		,1.637315423e-016
		,1.639206599e-016
		,1.640617078e-016
		,1.643191439e-016
		,1.645664190e-016
		,1.651013433e-016
		,1.654442969e-016
		,1.663101066e-016
		,1.673167965e-016
		,1.688358238e-016
		,1.718560059e-016
		,1.753120747e-016
		,4.396733888e-016
		,4.386307579e-016
		,4.375567184e-016
		,4.364462642e-016
		,4.325878719e-016
		,4.304814522e-016
		,4.268996164e-016
		,4.228295001e-016
		,4.213807598e-016
		,4.196813057e-016
		,4.159063364e-016
		,4.110292824e-016
		,4.032937172e-016
		,3.894958593e-016
		,3.623827084e-016
		,3.390611347e-016
		,2.920861964e-016
		,2.651865311e-016
		,2.368837385e-016
		,2.140914683e-016
		,1.991836131e-016
		,1.871323383e-016
		,1.765011235e-016
		,1.692200269e-016
		,1.655417663e-016
		,1.639628239e-016
		,1.634816635e-016
		,1.633971959e-016
		,1.633982745e-016
		,1.635051291e-016
		,1.635809650e-016
		,1.637017471e-016
		,1.638085070e-016
		,1.639687915e-016
		,1.641142937e-016
		,1.644585549e-016
		,1.648175415e-016
		,1.652714432e-016
		,1.662593522e-016
		,1.672871391e-016
		,1.687587371e-016
		,4.447096021e-016
		,4.431652722e-016
		,4.424054237e-016
		,4.415485943e-016
		,4.407750207e-016
		,4.382048294e-016
		,4.376832450e-016
		,4.370762390e-016
		,4.360377874e-016
		,4.347533732e-016
		,4.242372223e-016
		,4.212371581e-016
		,4.139080391e-016
		,4.040391617e-016
		,3.916728603e-016
		,3.669507027e-016
		,3.338905948e-016
		,2.936225960e-016
		,2.768594902e-016
		,2.480494576e-016
		,2.277752578e-016
		,2.152281708e-016
		,2.019679594e-016
		,1.886058929e-016
		,1.773689674e-016
		,1.698114586e-016
		,1.657817617e-016
		,1.640904237e-016
		,1.635726958e-016
		,1.634295194e-016
		,1.634603637e-016
		,1.634784282e-016
		,1.635203187e-016
		,1.636107975e-016
		,1.636862972e-016
		,1.637942013e-016
		,1.639022336e-016
		,1.643888226e-016
		,1.646288408e-016
		,1.652967835e-016
		,1.660303107e-016
		,4.508763865e-016
		,4.501673060e-016
		,4.495087287e-016
		,4.440242503e-016
		,4.397610061e-016
		,4.398276399e-016
		,4.396474038e-016
		,4.392447742e-016
		,4.391171387e-016
		,4.387741005e-016
		,4.381786185e-016
		,4.369369203e-016
		,4.346493623e-016
		,4.293880458e-016
		,4.227817720e-016
		,3.850188569e-016
		,3.649238521e-016
		,3.333948544e-016
		,3.182517141e-016
		,2.813191701e-016
		,2.641411689e-016
		,2.409228785e-016
		,2.316499942e-016
		,2.182459374e-016
		,2.038092955e-016
		,1.898903896e-016
		,1.783357585e-016
		,1.704003985e-016
		,1.660520386e-016
		,1.642620087e-016
		,1.635802289e-016
		,1.634587424e-016
		,1.634102905e-016
		,1.633970525e-016
		,1.634794449e-016
		,1.635166119e-016
		,1.636347402e-016
		,1.636742820e-016
		,1.638671882e-016
		,1.641988326e-016
		,1.646729803e-016
		,4.537611873e-016
		,4.530559361e-016
		,4.508632807e-016
		,4.505425304e-016
		,4.502566862e-016
		,4.500411219e-016
		,4.499217006e-016
		,4.499171301e-016
		,4.500125147e-016
		,4.499783511e-016
		,4.501291921e-016
		,4.501900128e-016
		,4.427621950e-016
		,4.357968366e-016
		,4.163144342e-016
		,4.039032976e-016
		,3.971568719e-016
		,3.750147248e-016
		,3.570479503e-016
		,3.212939531e-016
		,2.969786007e-016
		,2.757185699e-016
		,2.544447486e-016
		,2.466574842e-016
		,2.348618889e-016
		,2.202911776e-016
		,2.053621430e-016
		,1.911600457e-016
		,1.793309818e-016
		,1.709503905e-016
		,1.663445762e-016
		,1.643256472e-016
		,1.636115064e-016
		,1.633916906e-016
		,1.633822505e-016
		,1.634176924e-016
		,1.634341663e-016
		,1.635317578e-016
		,1.636024484e-016
		,1.635926841e-016
		,1.638867995e-016
		,1.680574242e-016
		,1.686545835e-016
		,1.694326280e-016
		,1.704624686e-016
		,1.718520251e-016
		,1.737342520e-016
		,1.762023656e-016
		,1.794090377e-016
		,1.837348546e-016
		,1.889792576e-016
		,1.962330489e-016
		,2.023200191e-016
		,2.104140879e-016
		,2.205879472e-016
		,2.279008946e-016
		,2.524776968e-016
		,2.872554789e-016
		,3.269145677e-016
		,3.544860219e-016
		,3.764370523e-016
		,3.955776712e-016
		,4.042034351e-016
		,4.068098839e-016
		,4.105617248e-016
		,4.118250358e-016
		,4.119325460e-016
		,4.144399531e-016
		,4.178772742e-016
		,4.215748182e-016
		,4.257021816e-016
		,4.304598105e-016
		,4.356348465e-016
		,4.406840981e-016
		,4.454452062e-016
		,4.502745608e-016
		,4.537446267e-016
		,4.561238018e-016
		,4.580314458e-016
		,4.596552630e-016
		,4.610927242e-016
		,4.624261182e-016
		,1.669606765e-016
		,1.672858719e-016
		,1.676600842e-016
		,1.681047614e-016
		,1.686538085e-016
		,1.693598257e-016
		,1.703009831e-016
		,1.715893738e-016
		,1.734041442e-016
		,1.759899525e-016
		,1.799717744e-016
		,1.851671532e-016
		,1.923168011e-016
		,1.979605508e-016
		,2.084168071e-016
		,2.197889189e-016
		,2.360184411e-016
		,2.751162877e-016
		,3.168190891e-016
		,3.473421339e-016
		,3.724625455e-016
		,3.901817705e-016
		,4.024223862e-016
		,4.105947210e-016
		,4.141146110e-016
		,4.160922278e-016
		,4.185995135e-016
		,4.197182861e-016
		,4.195119120e-016
		,4.208354883e-016
		,4.249562068e-016
		,4.306344250e-016
		,4.363604388e-016
		,4.419418750e-016
		,4.469170778e-016
		,4.509718268e-016
		,4.541584859e-016
		,4.567193209e-016
		,4.588484697e-016
		,4.606735353e-016
		,4.622789317e-016
		,1.662784407e-016
		,1.665386490e-016
		,1.668165112e-016
		,1.671174931e-016
		,1.674497213e-016
		,1.678249895e-016
		,1.682616858e-016
		,1.687888164e-016
		,1.694556473e-016
		,1.703493936e-016
		,1.715989463e-016
		,1.734842610e-016
		,1.764736299e-016
		,1.810904716e-016
		,1.869422456e-016
		,1.954489839e-016
		,2.112078691e-016
		,2.290323873e-016
		,2.667875754e-016
		,3.121683923e-016
		,3.451555683e-016
		,3.659728842e-016
		,3.819591904e-016
		,3.939698883e-016
		,4.027734748e-016
		,4.093069898e-016
		,4.144007655e-016
		,4.181112906e-016
		,4.205182889e-016
		,4.232147994e-016
		,4.260801551e-016
		,4.292185017e-016
		,4.331375125e-016
		,4.379866229e-016
		,4.427878856e-016
		,4.467869113e-016
		,4.499232818e-016
		,4.524327886e-016
		,4.545244440e-016
		,4.563200320e-016
		,4.578888140e-016
		,1.656961029e-016
		,1.659377649e-016
		,1.661923045e-016
		,1.664591190e-016
		,1.667401331e-016
		,1.670388719e-016
		,1.673604775e-016
		,1.677123496e-016
		,1.681052561e-016
		,1.685563223e-016
		,1.690939001e-016
		,1.697695012e-016
		,1.706865002e-016
		,1.720590993e-016
		,1.741172074e-016
		,1.777932925e-016
		,1.829335254e-016
		,1.961065279e-016
		,2.240983499e-016
		,2.605631900e-016
		,2.992130587e-016
		,3.308845700e-016
		,3.559177597e-016
		,3.742364130e-016
		,3.878528354e-016
		,3.980371683e-016
		,4.051816013e-016
		,4.104823895e-016
		,4.145017419e-016
		,4.175149303e-016
		,4.197856180e-016
		,4.217619736e-016
		,4.249091667e-016
		,4.293600216e-016
		,4.344194528e-016
		,4.392765384e-016
		,4.434453569e-016
		,4.469204143e-016
		,4.498179814e-016
		,4.522413058e-016
		,4.542892824e-016
		,1.651988361e-016
		,1.653870744e-016
		,1.656222797e-016
		,1.658788112e-016
		,1.661489579e-016
		,1.664313719e-016
		,1.667272852e-016
		,1.670393758e-016
		,1.673716144e-016
		,1.677296277e-016
		,1.681216018e-016
		,1.685601356e-016
		,1.690661865e-016
		,1.696782421e-016
		,1.704758350e-016
		,1.716449686e-016
		,1.736678793e-016
		,1.778523127e-016
		,1.874704897e-016
		,2.081588232e-016
		,2.419343624e-016
		,2.800665029e-016
		,3.132055991e-016
		,3.395624649e-016
		,3.598963295e-016
		,3.749475674e-016
		,3.858797413e-016
		,3.939374318e-016
		,4.000693324e-016
		,4.049188438e-016
		,4.089373384e-016
		,4.124991704e-016
		,4.159997918e-016
		,4.198979937e-016
		,4.245734084e-016
		,4.299672301e-016
		,4.354792918e-016
		,4.404575490e-016
		,4.446220977e-016
		,4.480096588e-016
		,4.507706968e-016
		,1.654075201e-016
		,1.650797115e-016
		,1.651389567e-016
		,1.653374017e-016
		,1.655892884e-016
		,1.658661752e-016
		,1.661592941e-016
		,1.664668900e-016
		,1.667901694e-016
		,1.671321190e-016
		,1.674974130e-016
		,1.678931668e-016
		,1.683294812e-016
		,1.688313712e-016
		,1.694336672e-016
		,1.701738110e-016
		,1.711767415e-016
		,1.727822434e-016
		,1.767077243e-016
		,1.828614051e-016
		,1.932783178e-016
		,2.136849626e-016
		,2.495524728e-016
		,2.832824296e-016
		,3.106136975e-016
		,3.333781154e-016
		,3.517695336e-016
		,3.669217629e-016
		,3.790778278e-016
		,3.877286727e-016
		,3.945030789e-016
		,3.999640806e-016
		,4.045241137e-016
		,4.086040682e-016
		,4.126972858e-016
		,4.174355523e-016
		,4.232947505e-016
		,4.294663774e-016
		,4.352213043e-016
		,4.402372802e-016
		,4.444030853e-016
		,1.710904937e-016
		,1.669707122e-016
		,1.654519911e-016
		,1.650762727e-016
		,1.651306173e-016
		,1.653418216e-016
		,1.656154555e-016
		,1.659203195e-016
		,1.662471568e-016
		,1.665948711e-016
		,1.669664512e-016
		,1.673688896e-016
		,1.678133593e-016
		,1.683123543e-016
		,1.688787908e-016
		,1.694667251e-016
		,1.701149111e-016
		,1.708018474e-016
		,1.724524595e-016
		,1.750203622e-016
		,1.796353581e-016
		,1.846581715e-016
		,1.937319049e-016
		,2.158391082e-016
		,2.481593735e-016
		,2.761107689e-016
		,3.005304560e-016
		,3.226941242e-016
		,3.415074739e-016
		,3.583558938e-016
		,3.722609321e-016
		,3.817402466e-016
		,3.891948562e-016
		,3.952630419e-016
		,4.004153094e-016
		,4.051070611e-016
		,4.098871075e-016
		,4.155932150e-016
		,4.223038905e-016
		,4.287369283e-016
		,4.346526150e-016
		,2.021937679e-016
		,1.820699279e-016
		,1.719110468e-016
		,1.672867051e-016
		,1.655804338e-016
		,1.651490744e-016
		,1.651995366e-016
		,1.654292463e-016
		,1.657347589e-016
		,1.660833663e-016
		,1.664676378e-016
		,1.668915275e-016
		,1.673637197e-016
		,1.678901108e-016
		,1.684861222e-016
		,1.690503754e-016
		,1.693148033e-016
		,1.692129390e-016
		,1.694509803e-016
		,1.708698679e-016
		,1.715919782e-016
		,1.752236103e-016
		,1.776022095e-016
		,1.866232981e-016
		,1.968917166e-016
		,2.218145298e-016
		,2.494822833e-016
		,2.715951456e-016
		,2.922141355e-016
		,3.117251083e-016
		,3.294896490e-016
		,3.486013346e-016
		,3.640879699e-016
		,3.745372532e-016
		,3.829616663e-016
		,3.899534201e-016
		,3.959811957e-016
		,4.015233141e-016
		,4.073362142e-016
		,4.144472564e-016
		,4.214866047e-016
		,2.831813539e-016
		,2.452603059e-016
		,2.086782185e-016
		,1.849464082e-016
		,1.730461952e-016
		,1.677646165e-016
		,1.658288939e-016
		,1.653361829e-016
		,1.653912662e-016
		,1.656570321e-016
		,1.660228170e-016
		,1.664596499e-016
		,1.669549866e-016
		,1.675051509e-016
		,1.680850828e-016
		,1.684418000e-016
		,1.685137560e-016
		,1.678548916e-016
		,1.681459747e-016
		,1.678144756e-016
		,1.683632713e-016
		,1.685407449e-016
		,1.715015705e-016
		,1.747296176e-016
		,1.797813230e-016
		,1.892141825e-016
		,2.034775321e-016
		,2.272940377e-016
		,2.492340572e-016
		,2.673196466e-016
		,2.848324659e-016
		,3.016784717e-016
		,3.180948898e-016
		,3.397149555e-016
		,3.556253198e-016
		,3.668328397e-016
		,3.762233887e-016
		,3.842613680e-016
		,3.912869331e-016
		,3.979192968e-016
		,4.056561318e-016
		,3.428530610e-016
		,3.219338295e-016
		,2.933859694e-016
		,2.561396299e-016
		,2.168940415e-016
		,1.889367966e-016
		,1.746559129e-016
		,1.684825173e-016
		,1.662607821e-016
		,1.657115179e-016
		,1.658053748e-016
		,1.661556582e-016
		,1.666208421e-016
		,1.671688911e-016
		,1.676521625e-016
		,1.676730885e-016
		,1.672944605e-016
		,1.663958492e-016
		,1.659159405e-016
		,1.666578950e-016
		,1.666628764e-016
		,1.670539591e-016
		,1.681761278e-016
		,1.683839163e-016
		,1.731553892e-016
		,1.747717706e-016
		,1.827547787e-016
		,1.915852898e-016
		,2.094679326e-016
		,2.305925653e-016
		,2.479917605e-016
		,2.638809156e-016
		,2.789374426e-016
		,2.933004748e-016
		,3.084097741e-016
		,3.321208121e-016
		,3.472080906e-016
		,3.589297596e-016
		,3.692605409e-016
		,3.782868902e-016
		,3.864123802e-016
		,3.744024794e-016
		,3.635635343e-016
		,3.493676247e-016
		,3.301958557e-016
		,3.036904141e-016
		,2.679187721e-016
		,2.270328348e-016
		,1.944995349e-016
		,1.769947994e-016
		,1.695819739e-016
		,1.670068373e-016
		,1.664150126e-016
		,1.665491140e-016
		,1.669382440e-016
		,1.670592960e-016
		,1.665911666e-016
		,1.663480241e-016
		,1.647658704e-016
		,1.636597735e-016
		,1.651657758e-016
		,1.654007843e-016
		,1.663685918e-016
		,1.671143202e-016
		,1.677321502e-016
		,1.677109383e-016
		,1.703309898e-016
		,1.732235943e-016
		,1.771195163e-016
		,1.848680773e-016
		,1.959717871e-016
		,2.139023460e-016
		,2.304494890e-016
		,2.453371077e-016
		,2.604331084e-016
		,2.740494257e-016
		,2.864928309e-016
		,3.014678500e-016
		,3.254394929e-016
		,3.392353192e-016
		,3.512916420e-016
		,3.622498333e-016
		,3.921801970e-016
		,3.858738701e-016
		,3.780570346e-016
		,3.681435090e-016
		,3.552133010e-016
		,3.376394737e-016
		,3.133236460e-016
		,2.797988847e-016
		,2.387055023e-016
		,2.018990155e-016
		,1.803103832e-016
		,1.711518775e-016
		,1.680766334e-016
		,1.671897796e-016
		,1.664724511e-016
		,1.655044362e-016
		,1.652594693e-016
		,1.630666283e-016
		,1.624012608e-016
		,1.634757091e-016
		,1.645699030e-016
		,1.657551455e-016
		,1.662137095e-016
		,1.658905267e-016
		,1.672030883e-016
		,1.680172188e-016
		,1.687799717e-016
		,1.718435821e-016
		,1.724599957e-016
		,1.802936245e-016
		,1.867837778e-016
		,2.015121894e-016
		,2.180045239e-016
		,2.315019332e-016
		,2.441592829e-016
		,2.562632634e-016
		,2.676596139e-016
		,2.787838405e-016
		,2.963826566e-016
		,3.190522192e-016
		,3.319966046e-016
		,4.027396360e-016
		,3.986544746e-016
		,3.937976066e-016
		,3.879226775e-016
		,3.806765750e-016
		,3.715337543e-016
		,3.596723174e-016
		,3.437534501e-016
		,3.214806146e-016
		,2.901155261e-016
		,2.493318437e-016
		,2.082912450e-016
		,1.830082167e-016
		,1.719650015e-016
		,1.672472108e-016
		,1.654496588e-016
		,1.641284792e-016
		,1.613606981e-016
		,1.616347888e-016
		,1.624661054e-016
		,1.637450533e-016
		,1.655283184e-016
		,1.649075560e-016
		,1.653338754e-016
		,1.661694934e-016
		,1.668607262e-016
		,1.671032685e-016
		,1.675763775e-016
		,1.708652510e-016
		,1.726379309e-016
		,1.743043709e-016
		,1.796507503e-016
		,1.902017233e-016
		,2.059635838e-016
		,2.197962065e-016
		,2.319015623e-016
		,2.436082839e-016
		,2.544700866e-016
		,2.642541672e-016
		,2.733772529e-016
		,2.945888921e-016
		,4.111121163e-016
		,4.082268201e-016
		,4.049027338e-016
		,4.010149086e-016
		,3.963911737e-016
		,3.907926948e-016
		,3.832253863e-016
		,3.732179628e-016
		,3.604678863e-016
		,3.448750335e-016
		,3.234969131e-016
		,2.923981397e-016
		,2.494593415e-016
		,2.056597156e-016
		,1.795997804e-016
		,1.700429656e-016
		,1.645653859e-016
		,1.607544730e-016
		,1.612056844e-016
		,1.616740448e-016
		,1.639863743e-016
		,1.644033228e-016
		,1.644304430e-016
		,1.644925359e-016
		,1.657621723e-016
		,1.657178051e-016
		,1.663025482e-016
		,1.671662654e-016
		,1.676086483e-016
		,1.684429105e-016
		,1.713069841e-016
		,1.724336384e-016
		,1.766654769e-016
		,1.799847874e-016
		,1.912185389e-016
		,2.089664212e-016
		,2.206145390e-016
		,2.319034905e-016
		,2.427068742e-016
		,2.525217688e-016
		,2.610874627e-016
		,4.173037465e-016
		,4.151721994e-016
		,4.127689113e-016
		,4.100225138e-016
		,4.067346785e-016
		,4.028041602e-016
		,3.982015725e-016
		,3.925041035e-016
		,3.852729041e-016
		,3.758459857e-016
		,3.631322106e-016
		,3.450960388e-016
		,3.179871428e-016
		,2.772561520e-016
		,2.292799126e-016
		,1.949414943e-016
		,1.750346248e-016
		,1.648931701e-016
		,1.629417554e-016
		,1.616257091e-016
		,1.642309810e-016
		,1.641662464e-016
		,1.632710967e-016
		,1.648352089e-016
		,1.646446556e-016
		,1.652434634e-016
		,1.655596536e-016
		,1.663831912e-016
		,1.668637635e-016
		,1.671147227e-016
		,1.675308595e-016
		,1.697269061e-016
		,1.710564446e-016
		,1.732325721e-016
		,1.774246248e-016
		,1.818325647e-016
		,1.926523088e-016
		,2.061677256e-016
		,2.213658561e-016
		,2.319557524e-016
		,2.418604392e-016
		,4.247453919e-016
		,4.229061548e-016
		,4.208334328e-016
		,4.186671950e-016
		,4.165211614e-016
		,4.139522719e-016
		,4.107165908e-016
		,4.067846667e-016
		,4.018674870e-016
		,3.955334120e-016
		,3.871517780e-016
		,3.742873874e-016
		,3.560512710e-016
		,3.262112476e-016
		,2.942690694e-016
		,2.522055549e-016
		,2.118029761e-016
		,1.849936551e-016
		,1.739799077e-016
		,1.667030120e-016
		,1.654901808e-016
		,1.641973219e-016
		,1.639301733e-016
		,1.640530696e-016
		,1.645907368e-016
		,1.644616452e-016
		,1.654539604e-016
		,1.656436818e-016
		,1.658954208e-016
		,1.663804945e-016
		,1.666104071e-016
		,1.671168632e-016
		,1.681601782e-016
		,1.700020628e-016
		,1.707923085e-016
		,1.747520535e-016
		,1.777557662e-016
		,1.843977448e-016
		,1.952832879e-016
		,2.006560558e-016
		,2.176485482e-016
		,4.307325142e-016
		,4.293554640e-016
		,4.278797802e-016
		,4.262292307e-016
		,4.244082793e-016
		,4.224137132e-016
		,4.201725245e-016
		,4.176481507e-016
		,4.124283665e-016
		,4.075702323e-016
		,3.994418181e-016
		,3.901640539e-016
		,3.819502974e-016
		,3.683153262e-016
		,3.450130716e-016
		,3.126720714e-016
		,2.707776175e-016
		,2.274004422e-016
		,2.022095639e-016
		,1.859723877e-016
		,1.757437339e-016
		,1.685081790e-016
		,1.658919617e-016
		,1.649032349e-016
		,1.640429501e-016
		,1.647806182e-016
		,1.649414873e-016
		,1.651843727e-016
		,1.654452318e-016
		,1.656008893e-016
		,1.660347059e-016
		,1.661311040e-016
		,1.666788129e-016
		,1.671553155e-016
		,1.688822259e-016
		,1.696173316e-016
		,1.717740008e-016
		,1.749667305e-016
		,1.787292826e-016
		,1.874970963e-016
		,1.970263779e-016
		,4.352635563e-016
		,4.339102697e-016
		,4.328894856e-016
		,4.317829592e-016
		,4.306380241e-016
		,4.292204961e-016
		,4.278403735e-016
		,4.263074988e-016
		,4.204674317e-016
		,4.155485166e-016
		,4.132750081e-016
		,4.092164443e-016
		,4.031924068e-016
		,3.941360189e-016
		,3.778142818e-016
		,3.570650795e-016
		,3.256390552e-016
		,2.776567800e-016
		,2.403674977e-016
		,2.194623706e-016
		,1.996513602e-016
		,1.867859207e-016
		,1.769518146e-016
		,1.697586600e-016
		,1.665390799e-016
		,1.650747240e-016
		,1.649803763e-016
		,1.649564769e-016
		,1.650252625e-016
		,1.653575330e-016
		,1.654262398e-016
		,1.657235464e-016
		,1.659696757e-016
		,1.662537800e-016
		,1.665675956e-016
		,1.676873465e-016
		,1.686926366e-016
		,1.695148280e-016
		,1.727183786e-016
		,1.751388936e-016
		,1.793034409e-016
		,4.431660267e-016
		,4.421560719e-016
		,4.411355061e-016
		,4.401172857e-016
		,4.390318139e-016
		,4.347359271e-016
		,4.333971745e-016
		,4.302503720e-016
		,4.276697562e-016
		,4.271851541e-016
		,4.251588081e-016
		,4.225935096e-016
		,4.186459529e-016
		,4.126599027e-016
		,4.010085348e-016
		,3.810553634e-016
		,3.578918711e-016
		,3.194334779e-016
		,2.823625582e-016
		,2.610708088e-016
		,2.322398880e-016
		,2.137601549e-016
		,2.018476953e-016
		,1.887317653e-016
		,1.781335701e-016
		,1.712030572e-016
		,1.668656115e-016
		,1.653542554e-016
		,1.650672197e-016
		,1.650480515e-016
		,1.653447493e-016
		,1.653666931e-016
		,1.655351371e-016
		,1.658860418e-016
		,1.659486753e-016
		,1.661931222e-016
		,1.665191170e-016
		,1.680883301e-016
		,1.684651421e-016
		,1.702350544e-016
		,1.724659738e-016
		,4.493424585e-016
		,4.465691883e-016
		,4.458503072e-016
		,4.450951474e-016
		,4.443433670e-016
		,4.436381188e-016
		,4.410544269e-016
		,4.401044214e-016
		,4.399222465e-016
		,4.377478062e-016
		,4.365072652e-016
		,4.281982397e-016
		,4.231216496e-016
		,4.204323879e-016
		,4.110203669e-016
		,4.030859927e-016
		,3.900271984e-016
		,3.555337671e-016
		,3.208750313e-016
		,2.939911038e-016
		,2.670796227e-016
		,2.454637786e-016
		,2.290644492e-016
		,2.180457065e-016
		,2.041477955e-016
		,1.904003542e-016
		,1.795572362e-016
		,1.715254814e-016
		,1.672685022e-016
		,1.657675419e-016
		,1.650552124e-016
		,1.653769749e-016
		,1.654208581e-016
		,1.654819199e-016
		,1.658001701e-016
		,1.657697704e-016
		,1.661205826e-016
		,1.661381387e-016
		,1.668072159e-016
		,1.677736356e-016
		,1.688295528e-016
		,4.549498481e-016
		,4.542099114e-016
		,4.535229121e-016
		,4.529157489e-016
		,4.476173079e-016
		,4.426995606e-016
		,4.429127355e-016
		,4.430357336e-016
		,4.429177514e-016
		,4.427066641e-016
		,4.424960068e-016
		,4.421983058e-016
		,4.415494050e-016
		,4.394216273e-016
		,4.335939012e-016
		,4.268718003e-016
		,4.062859519e-016
		,3.697453057e-016
		,3.512762678e-016
		,3.308310769e-016
		,3.064335624e-016
		,2.789982364e-016
		,2.554138200e-016
		,2.440270366e-016
		,2.342074900e-016
		,2.204328622e-016
		,2.056582673e-016
		,1.921033843e-016
		,1.805332473e-016
		,1.721977429e-016
		,1.679328417e-016
		,1.659286130e-016
		,1.654077754e-016
		,1.653070460e-016
		,1.655579468e-016
		,1.657468430e-016
		,1.657207975e-016
		,1.660508958e-016
		,1.661994906e-016
		,1.661025778e-016
		,1.671209757e-016
		,1.688821588e-016
		,1.695582419e-016
		,1.704339288e-016
		,1.715868268e-016
		,1.731076319e-016
		,1.750934821e-016
		,1.776625408e-016
		,1.809740271e-016
		,1.852503300e-016
		,1.905642038e-016
		,1.979244302e-016
		,2.037300122e-016
		,2.111706697e-016
		,2.218359162e-016
		,2.206559601e-016
		,2.462598564e-016
		,2.749478738e-016
		,3.123857102e-016
		,3.500945319e-016
		,3.738238890e-016
		,3.898148109e-016
		,3.979959564e-016
		,4.049066553e-016
		,4.080809260e-016
		,4.073932325e-016
		,4.093523690e-016
		,4.132018594e-016
		,4.171959200e-016
		,4.209865104e-016
		,4.248333638e-016
		,4.291729383e-016
		,4.340830559e-016
		,4.391081046e-016
		,4.436558818e-016
		,4.474531116e-016
		,4.505468533e-016
		,4.531410772e-016
		,4.556745216e-016
		,4.586505014e-016
		,4.607900567e-016
		,4.621793698e-016
		,1.677091610e-016
		,1.680711026e-016
		,1.684886510e-016
		,1.689856802e-016
		,1.695978416e-016
		,1.703767194e-016
		,1.713971305e-016
		,1.727895509e-016
		,1.747127059e-016
		,1.774411494e-016
		,1.815063199e-016
		,1.865689547e-016
		,1.933478927e-016
		,1.988086481e-016
		,2.091843253e-016
		,2.168800202e-016
		,2.327280906e-016
		,2.603924423e-016
		,3.045809881e-016
		,3.387534122e-016
		,3.639799578e-016
		,3.858099739e-016
		,3.995862641e-016
		,4.079972056e-016
		,4.106590424e-016
		,4.138988685e-016
		,4.159737699e-016
		,4.157985487e-016
		,4.169947626e-016
		,4.201770799e-016
		,4.241073784e-016
		,4.286047162e-016
		,4.336415111e-016
		,4.390286862e-016
		,4.446143190e-016
		,4.489177964e-016
		,4.521195022e-016
		,4.547725474e-016
		,4.571176743e-016
		,4.592811459e-016
		,4.612198266e-016
		,1.670329964e-016
		,1.673192853e-016
		,1.676254544e-016
		,1.679575461e-016
		,1.683243606e-016
		,1.687386584e-016
		,1.692194445e-016
		,1.697967504e-016
		,1.705212756e-016
		,1.714796456e-016
		,1.727968475e-016
		,1.747348825e-016
		,1.777174882e-016
		,1.821745749e-016
		,1.881913200e-016
		,1.963864501e-016
		,2.075863214e-016
		,2.227741320e-016
		,2.493719802e-016
		,2.959958631e-016
		,3.373648513e-016
		,3.634157614e-016
		,3.821444887e-016
		,3.953199232e-016
		,4.041912844e-016
		,4.101208387e-016
		,4.139247278e-016
		,4.154736813e-016
		,4.176513492e-016
		,4.202115339e-016
		,4.226372957e-016
		,4.256105298e-016
		,4.300373343e-016
		,4.356467387e-016
		,4.413152949e-016
		,4.463126898e-016
		,4.504029237e-016
		,4.536569996e-016
		,4.562208589e-016
		,4.582152309e-016
		,4.597373351e-016
		,1.664767979e-016
		,1.667422559e-016
		,1.670216199e-016
		,1.673144990e-016
		,1.676228602e-016
		,1.679501811e-016
		,1.683015808e-016
		,1.686845572e-016
		,1.691103968e-016
		,1.695970330e-016
		,1.701742128e-016
		,1.708957554e-016
		,1.718570392e-016
		,1.732518950e-016
		,1.753453363e-016
		,1.789831306e-016
		,1.842978390e-016
		,1.949530446e-016
		,2.191620635e-016
		,2.531157051e-016
		,2.928056748e-016
		,3.255200711e-016
		,3.526243817e-016
		,3.713963595e-016
		,3.854202234e-016
		,3.960808173e-016
		,4.042979394e-016
		,4.106522433e-016
		,4.155381351e-016
		,4.190589969e-016
		,4.212390098e-016
		,4.227882655e-016
		,4.254122874e-016
		,4.292256017e-016
		,4.338690224e-016
		,4.385854037e-016
		,4.428837411e-016
		,4.465842222e-016
		,4.496618621e-016
		,4.522036846e-016
		,4.543242983e-016
		,1.660079554e-016
		,1.662219957e-016
		,1.664822426e-016
		,1.667639145e-016
		,1.670594215e-016
		,1.673672398e-016
		,1.676883642e-016
		,1.680253881e-016
		,1.683825988e-016
		,1.687666297e-016
		,1.691877049e-016
		,1.696619287e-016
		,1.702159140e-016
		,1.708973063e-016
		,1.718013944e-016
		,1.731437852e-016
		,1.754651475e-016
		,1.801759740e-016
		,1.906219601e-016
		,2.120888991e-016
		,2.457202788e-016
		,2.828493896e-016
		,3.150155841e-016
		,3.407355803e-016
		,3.606839788e-016
		,3.754999186e-016
		,3.862843590e-016
		,3.942454463e-016
		,4.003113457e-016
		,4.051139395e-016
		,4.090979706e-016
		,4.126338387e-016
		,4.161145433e-016
		,4.199972356e-016
		,4.246602422e-016
		,4.300436412e-016
		,4.355466297e-016
		,4.405170411e-016
		,4.446749462e-016
		,4.480569314e-016
		,4.508132723e-016
		,1.662187304e-016
		,1.659364348e-016
		,1.660280744e-016
		,1.662542952e-016
		,1.665320015e-016
		,1.668334287e-016
		,1.671499798e-016
		,1.674801987e-016
		,1.678260803e-016
		,1.681922143e-016
		,1.685863295e-016
		,1.690206369e-016
		,1.695135176e-016
		,1.701080206e-016
		,1.708601747e-016
		,1.719237517e-016
		,1.735497020e-016
		,1.763498516e-016
		,1.826331467e-016
		,1.932801001e-016
		,2.083862695e-016
		,2.324430920e-016
		,2.689028399e-016
		,3.011073926e-016
		,3.244130165e-016
		,3.434256541e-016
		,3.583153183e-016
		,3.699390324e-016
		,3.808008860e-016
		,3.882276771e-016
		,3.938336722e-016
		,3.983746703e-016
		,4.023204733e-016
		,4.062168541e-016
		,4.104867437e-016
		,4.155634782e-016
		,4.217840857e-016
		,4.290054992e-016
		,4.354952883e-016
		,4.405418423e-016
		,4.445630761e-016
		,1.716933908e-016
		,1.677665950e-016
		,1.663388698e-016
		,1.660125027e-016
		,1.661004053e-016
		,1.663387948e-016
		,1.666365619e-016
		,1.669642116e-016
		,1.673141955e-016
		,1.676887123e-016
		,1.680957708e-016
		,1.685501380e-016
		,1.690713347e-016
		,1.696979636e-016
		,1.705075520e-016
		,1.715679025e-016
		,1.731120114e-016
		,1.753444594e-016
		,1.792484491e-016
		,1.853001274e-016
		,1.956324235e-016
		,2.077074784e-016
		,2.247183710e-016
		,2.492921994e-016
		,2.812705076e-016
		,3.081340639e-016
		,3.253390453e-016
		,3.375341213e-016
		,3.476145452e-016
		,3.560384874e-016
		,3.674572955e-016
		,3.768679861e-016
		,3.827631818e-016
		,3.878939343e-016
		,3.927055813e-016
		,3.976016014e-016
		,4.029976461e-016
		,4.092671530e-016
		,4.166028350e-016
		,4.251959137e-016
		,4.332697744e-016
		,2.009771657e-016
		,1.821331815e-016
		,1.725419345e-016
		,1.681463773e-016
		,1.665404439e-016
		,1.661600117e-016
		,1.662436305e-016
		,1.665007324e-016
		,1.668346316e-016
		,1.672182506e-016
		,1.676520287e-016
		,1.681463454e-016
		,1.687309450e-016
		,1.694751785e-016
		,1.704537514e-016
		,1.716043870e-016
		,1.731498261e-016
		,1.747246247e-016
		,1.762015337e-016
		,1.802577161e-016
		,1.841172817e-016
		,1.932519723e-016
		,1.995776138e-016
		,2.170340189e-016
		,2.299179961e-016
		,2.560441211e-016
		,2.824950925e-016
		,3.047147837e-016
		,3.183856641e-016
		,3.284982841e-016
		,3.365570161e-016
		,3.435548967e-016
		,3.552528971e-016
		,3.671372102e-016
		,3.734982197e-016
		,3.792006768e-016
		,3.847579569e-016
		,3.905575553e-016
		,3.969929227e-016
		,4.044281751e-016
		,4.131999866e-016
		,2.800075894e-016
		,2.423212654e-016
		,2.071107774e-016
		,1.848575605e-016
		,1.736800532e-016
		,1.686770184e-016
		,1.668549528e-016
		,1.664203510e-016
		,1.665208557e-016
		,1.668402440e-016
		,1.672756872e-016
		,1.678104901e-016
		,1.684977199e-016
		,1.693797425e-016
		,1.704335058e-016
		,1.717373199e-016
		,1.734569736e-016
		,1.746293134e-016
		,1.758502131e-016
		,1.766615504e-016
		,1.789027729e-016
		,1.791865482e-016
		,1.855410488e-016
		,1.905362764e-016
		,1.994410179e-016
		,2.194949043e-016
		,2.332226905e-016
		,2.590422097e-016
		,2.830522166e-016
		,3.006579621e-016
		,3.125977205e-016
		,3.215214358e-016
		,3.285652870e-016
		,3.346331247e-016
		,3.469798520e-016
		,3.601862743e-016
		,3.666632949e-016
		,3.725289348e-016
		,3.784279610e-016
		,3.848441786e-016
		,3.921971998e-016
		,3.406776952e-016
		,3.193177830e-016
		,2.903741969e-016
		,2.531141553e-016
		,2.149558711e-016
		,1.886124597e-016
		,1.752576256e-016
		,1.694486764e-016
		,1.673846814e-016
		,1.669367063e-016
		,1.671323249e-016
		,1.676604444e-016
		,1.684409103e-016
		,1.694382132e-016
		,1.704652928e-016
		,1.719792212e-016
		,1.734378390e-016
		,1.739516904e-016
		,1.739693593e-016
		,1.758561701e-016
		,1.756211116e-016
		,1.761040172e-016
		,1.749548772e-016
		,1.750149858e-016
		,1.846993708e-016
		,1.884438342e-016
		,2.035803062e-016
		,2.173736371e-016
		,2.383257177e-016
		,2.627747657e-016
		,2.840248497e-016
		,2.977757022e-016
		,3.080138629e-016
		,3.160108997e-016
		,3.222269303e-016
		,3.275105664e-016
		,3.409218825e-016
		,3.542682374e-016
		,3.605518091e-016
		,3.664134487e-016
		,3.725560491e-016
		,3.731993047e-016
		,3.620954505e-016
		,3.475532038e-016
		,3.279451583e-016
		,3.009693772e-016
		,2.649678253e-016
		,2.248029180e-016
		,1.939067478e-016
		,1.775929017e-016
		,1.706943355e-016
		,1.684109819e-016
		,1.681344052e-016
		,1.687331068e-016
		,1.695334996e-016
		,1.708079687e-016
		,1.722701619e-016
		,1.732784006e-016
		,1.728786412e-016
		,1.722800622e-016
		,1.726639572e-016
		,1.733698244e-016
		,1.718873998e-016
		,1.714409243e-016
		,1.730693704e-016
		,1.722167034e-016
		,1.776231534e-016
		,1.803855520e-016
		,1.910534778e-016
		,2.081398274e-016
		,2.223826446e-016
		,2.452868397e-016
		,2.667547350e-016
		,2.830284066e-016
		,2.941395979e-016
		,3.029138164e-016
		,3.100871052e-016
		,3.155122038e-016
		,3.203299023e-016
		,3.365769124e-016
		,3.493713708e-016
		,3.551727687e-016
		,3.916013680e-016
		,3.851606357e-016
		,3.771695525e-016
		,3.670504726e-016
		,3.538478829e-016
		,3.360532361e-016
		,3.113447671e-016
		,2.773498620e-016
		,2.365697144e-016
		,2.013096310e-016
		,1.812667633e-016
		,1.730340615e-016
		,1.705213932e-016
		,1.703853626e-016
		,1.713692698e-016
		,1.723380960e-016
		,1.726623633e-016
		,1.719054865e-016
		,1.705806230e-016
		,1.689233494e-016
		,1.708968129e-016
		,1.690907390e-016
		,1.688068586e-016
		,1.693058087e-016
		,1.702997656e-016
		,1.708207626e-016
		,1.733116974e-016
		,1.814078448e-016
		,1.823778521e-016
		,1.925525021e-016
		,2.094779295e-016
		,2.292463305e-016
		,2.501615520e-016
		,2.694831353e-016
		,2.822487456e-016
		,2.917933500e-016
		,2.993482278e-016
		,3.051402653e-016
		,3.094151532e-016
		,3.140321353e-016
		,3.350715152e-016
		,4.023950917e-016
		,3.982779304e-016
		,3.933776917e-016
		,3.874452301e-016
		,3.801233571e-016
		,3.708802933e-016
		,3.588875673e-016
		,3.427957334e-016
		,3.204509734e-016
		,2.891535377e-016
		,2.489339100e-016
		,2.100037021e-016
		,1.856391066e-016
		,1.761091778e-016
		,1.733959562e-016
		,1.726536071e-016
		,1.718422398e-016
		,1.705282614e-016
		,1.687701752e-016
		,1.654323609e-016
		,1.680084704e-016
		,1.666817410e-016
		,1.675762992e-016
		,1.684596201e-016
		,1.678349575e-016
		,1.687472265e-016
		,1.692872396e-016
		,1.712626063e-016
		,1.794104679e-016
		,1.828365992e-016
		,1.850454800e-016
		,1.939189880e-016
		,2.073817878e-016
		,2.363691683e-016
		,2.549041842e-016
		,2.691455318e-016
		,2.797924273e-016
		,2.884301837e-016
		,2.952454309e-016
		,3.003472356e-016
		,3.039908454e-016
		,4.108895089e-016
		,4.079539196e-016
		,4.046168381e-016
		,4.005521110e-016
		,3.959234430e-016
		,3.903262834e-016
		,3.834251839e-016
		,3.747108591e-016
		,3.632147243e-016
		,3.463260374e-016
		,3.238422880e-016
		,2.939578060e-016
		,2.533902143e-016
		,2.120272508e-016
		,1.872442629e-016
		,1.770173323e-016
		,1.726662230e-016
		,1.691609642e-016
		,1.662925846e-016
		,1.633229514e-016
		,1.655936642e-016
		,1.640546629e-016
		,1.675909376e-016
		,1.665982313e-016
		,1.674243079e-016
		,1.666162295e-016
		,1.691982773e-016
		,1.708727540e-016
		,1.711518134e-016
		,1.742159735e-016
		,1.801629128e-016
		,1.826462312e-016
		,1.908193432e-016
		,1.957473673e-016
		,2.101123108e-016
		,2.316099658e-016
		,2.556012741e-016
		,2.677943550e-016
		,2.774968165e-016
		,2.854021449e-016
		,2.915777064e-016
		,4.165528886e-016
		,4.144959867e-016
		,4.121545735e-016
		,4.094664817e-016
		,4.063350059e-016
		,4.025808972e-016
		,3.979370121e-016
		,3.924221256e-016
		,3.854702319e-016
		,3.764529443e-016
		,3.644268838e-016
		,3.475360156e-016
		,3.226510435e-016
		,2.847584147e-016
		,2.382586967e-016
		,2.019515480e-016
		,1.833077345e-016
		,1.719380993e-016
		,1.653764763e-016
		,1.619527668e-016
		,1.634784573e-016
		,1.638299849e-016
		,1.662347661e-016
		,1.666993542e-016
		,1.652659870e-016
		,1.665170168e-016
		,1.684326973e-016
		,1.692528330e-016
		,1.705293728e-016
		,1.708822787e-016
		,1.719938718e-016
		,1.790611649e-016
		,1.809618944e-016
		,1.842382603e-016
		,1.919924761e-016
		,1.974411690e-016
		,2.181109625e-016
		,2.293886384e-016
		,2.403987345e-016
		,2.649621811e-016
		,2.755807202e-016
		,4.248694637e-016
		,4.231551587e-016
		,4.210234202e-016
		,4.188203001e-016
		,4.165972164e-016
		,4.140931614e-016
		,4.108811077e-016
		,4.069926075e-016
		,4.017427824e-016
		,3.954920403e-016
		,3.872300635e-016
		,3.757375979e-016
		,3.582434325e-016
		,3.345268155e-016
		,2.976271337e-016
		,2.572297782e-016
		,2.186534974e-016
		,1.905833379e-016
		,1.746390776e-016
		,1.659179545e-016
		,1.617002397e-016
		,1.652901826e-016
		,1.667349904e-016
		,1.648593971e-016
		,1.653533193e-016
		,1.659498316e-016
		,1.682349120e-016
		,1.681811446e-016
		,1.686279996e-016
		,1.699194301e-016
		,1.715982865e-016
		,1.723600036e-016
		,1.757282473e-016
		,1.790469273e-016
		,1.799321027e-016
		,1.871289245e-016
		,1.913604216e-016
		,2.032800867e-016
		,2.230102785e-016
		,2.319461466e-016
		,2.360968513e-016
		,4.316538438e-016
		,4.301548517e-016
		,4.285356968e-016
		,4.267877395e-016
		,4.248599460e-016
		,4.227028685e-016
		,4.202497366e-016
		,4.162316407e-016
		,4.125006643e-016
		,4.083608074e-016
		,4.031909819e-016
		,3.943041260e-016
		,3.798151787e-016
		,3.676573735e-016
		,3.454736963e-016
		,3.136384265e-016
		,2.732669053e-016
		,2.314907976e-016
		,2.016999122e-016
		,1.860983179e-016
		,1.714174083e-016
		,1.697242813e-016
		,1.686387075e-016
		,1.652030266e-016
		,1.639890658e-016
		,1.674681969e-016
		,1.669133865e-016
		,1.677213594e-016
		,1.680634242e-016
		,1.690315205e-016
		,1.709195051e-016
		,1.709643825e-016
		,1.716397828e-016
		,1.731888972e-016
		,1.772174142e-016
		,1.780299629e-016
		,1.816335250e-016
		,1.874569453e-016
		,1.920751144e-016
		,2.097993096e-016
		,2.262348159e-016
		,4.372380116e-016
		,4.357184395e-016
		,4.345105649e-016
		,4.331898472e-016
		,4.317891348e-016
		,4.304296561e-016
		,4.257806659e-016
		,4.244246184e-016
		,4.227479931e-016
		,4.210389486e-016
		,4.123208282e-016
		,4.087727248e-016
		,4.032305463e-016
		,3.943132254e-016
		,3.792885535e-016
		,3.578976105e-016
		,3.276482540e-016
		,2.877275459e-016
		,2.438240182e-016
		,2.215143248e-016
		,1.997992116e-016
		,1.879898167e-016
		,1.780681585e-016
		,1.706672154e-016
		,1.674360036e-016
		,1.664226208e-016
		,1.672419420e-016
		,1.669571965e-016
		,1.676543725e-016
		,1.694757650e-016
		,1.695597893e-016
		,1.702797026e-016
		,1.705312263e-016
		,1.710262161e-016
		,1.715540116e-016
		,1.751989327e-016
		,1.765451715e-016
		,1.775536785e-016
		,1.836629388e-016
		,1.868883441e-016
		,1.941474620e-016
		,4.407044786e-016
		,4.397318319e-016
		,4.386940873e-016
		,4.376641719e-016
		,4.367310443e-016
		,4.358181053e-016
		,4.349326938e-016
		,4.340689405e-016
		,4.299964711e-016
		,4.268452591e-016
		,4.251355579e-016
		,4.225462092e-016
		,4.185598725e-016
		,4.127011714e-016
		,4.031775243e-016
		,3.880111427e-016
		,3.669494541e-016
		,3.370552208e-016
		,2.953052773e-016
		,2.611513764e-016
		,2.389938598e-016
		,2.159039968e-016
		,2.022452911e-016
		,1.884768395e-016
		,1.807660150e-016
		,1.731410528e-016
		,1.680832156e-016
		,1.674789775e-016
		,1.678056901e-016
		,1.688300439e-016
		,1.694551457e-016
		,1.694231855e-016
		,1.698117003e-016
		,1.704996202e-016
		,1.706635851e-016
		,1.705471303e-016
		,1.725603040e-016
		,1.756870700e-016
		,1.760226738e-016
		,1.792380373e-016
		,1.829113787e-016
		,4.477203957e-016
		,4.466807031e-016
		,4.456521743e-016
		,4.446590331e-016
		,4.434561297e-016
		,4.405951446e-016
		,4.389501835e-016
		,4.386453744e-016
		,4.364099852e-016
		,4.347210000e-016
		,4.342574287e-016
		,4.327473372e-016
		,4.301413443e-016
		,4.262424710e-016
		,4.201708170e-016
		,4.093158366e-016
		,3.946834799e-016
		,3.695855177e-016
		,3.382109145e-016
		,2.954890749e-016
		,2.772352327e-016
		,2.513567065e-016
		,2.289423996e-016
		,2.187586773e-016
		,2.053954044e-016
		,1.926344829e-016
		,1.817617351e-016
		,1.734962326e-016
		,1.708057583e-016
		,1.690258942e-016
		,1.682425673e-016
		,1.690975867e-016
		,1.695302223e-016
		,1.695732303e-016
		,1.705364429e-016
		,1.703535996e-016
		,1.707185099e-016
		,1.707206066e-016
		,1.738597547e-016
		,1.746604498e-016
		,1.766312616e-016
		,4.548511309e-016
		,4.517893580e-016
		,4.499080217e-016
		,4.489773856e-016
		,4.481664751e-016
		,4.474644043e-016
		,4.468593726e-016
		,4.444194118e-016
		,4.442496949e-016
		,4.438657911e-016
		,4.422211280e-016
		,4.413216788e-016
		,4.360173552e-016
		,4.287402505e-016
		,4.250886361e-016
		,4.181043001e-016
		,4.107175396e-016
		,3.989512280e-016
		,3.709599297e-016
		,3.379771615e-016
		,3.122110491e-016
		,2.873555271e-016
		,2.604109029e-016
		,2.420713486e-016
		,2.348809883e-016
		,2.212168536e-016
		,2.075890334e-016
		,1.958038452e-016
		,1.835495570e-016
		,1.756400323e-016
		,1.713375531e-016
		,1.691463719e-016
		,1.689945409e-016
		,1.686693456e-016
		,1.695985175e-016
		,1.705240561e-016
		,1.701791132e-016
		,1.708601100e-016
		,1.708067748e-016
		,1.720315519e-016
		,1.737508871e-016
		,1.696567638e-016
		,1.703903546e-016
		,1.713322355e-016
		,1.725533330e-016
		,1.741366333e-016
		,1.761846561e-016
		,1.787888006e-016
		,1.820314469e-016
		,1.861984457e-016
		,1.914274097e-016
		,1.989630042e-016
		,2.045906658e-016
		,2.116263133e-016
		,2.220980430e-016
		,2.200950624e-016
		,2.359575746e-016
		,2.713241012e-016
		,3.000388293e-016
		,3.383311924e-016
		,3.724605945e-016
		,3.884665074e-016
		,3.935879420e-016
		,3.989558673e-016
		,4.040303530e-016
		,4.058941351e-016
		,4.095344542e-016
		,4.133126300e-016
		,4.167317227e-016
		,4.200230775e-016
		,4.235696363e-016
		,4.277057153e-016
		,4.324652395e-016
		,4.375196422e-016
		,4.423022678e-016
		,4.464097389e-016
		,4.497716493e-016
		,4.524999925e-016
		,4.547428798e-016
		,4.566305847e-016
		,4.582769893e-016
		,4.598404416e-016
		,1.684197510e-016
		,1.688081373e-016
		,1.692557598e-016
		,1.697872242e-016
		,1.704385153e-016
		,1.712635875e-016
		,1.723415854e-016
		,1.737938969e-016
		,1.757713935e-016
		,1.785370400e-016
		,1.825229655e-016
		,1.872635231e-016
		,1.942325193e-016
		,1.996819937e-016
		,2.096920488e-016
		,2.178629051e-016
		,2.269841180e-016
		,2.544287157e-016
		,2.924846109e-016
		,3.303357278e-016
		,3.594232055e-016
		,3.803867059e-016
		,3.974687999e-016
		,4.049582378e-016
		,4.078488224e-016
		,4.117079433e-016
		,4.125266924e-016
		,4.127365165e-016
		,4.155634620e-016
		,4.191998124e-016
		,4.230943570e-016
		,4.274518831e-016
		,4.324087003e-016
		,4.376360495e-016
		,4.425213856e-016
		,4.466947402e-016
		,4.502645283e-016
		,4.538196992e-016
		,4.567205785e-016
		,4.586362355e-016
		,4.601685352e-016
		,1.677436419e-016
		,1.680468645e-016
		,1.683697355e-016
		,1.687179438e-016
		,1.691003267e-016
		,1.695303640e-016
		,1.700286618e-016
		,1.706275884e-016
		,1.713810203e-016
		,1.723701467e-016
		,1.737300854e-016
		,1.757058843e-016
		,1.787370565e-016
		,1.832384296e-016
		,1.892926469e-016
		,1.966710034e-016
		,2.073184817e-016
		,2.193165695e-016
		,2.423536864e-016
		,2.841191833e-016
		,3.264243829e-016
		,3.570731402e-016
		,3.795276407e-016
		,3.949043551e-016
		,4.051919357e-016
		,4.118803622e-016
		,4.150965577e-016
		,4.158123586e-016
		,4.174480393e-016
		,4.189046099e-016
		,4.197390625e-016
		,4.218671228e-016
		,4.262733403e-016
		,4.322656891e-016
		,4.386622834e-016
		,4.441982354e-016
		,4.488837624e-016
		,4.526661414e-016
		,4.556639308e-016
		,4.580987344e-016
		,4.601339090e-016
		,1.672036416e-016
		,1.674826460e-016
		,1.677736462e-016
		,1.680758826e-016
		,1.683913164e-016
		,1.687238616e-016
		,1.690796587e-016
		,1.694678523e-016
		,1.699019597e-016
		,1.704029478e-016
		,1.710035197e-016
		,1.717608239e-016
		,1.727723277e-016
		,1.742187252e-016
		,1.764285141e-016
		,1.801520209e-016
		,1.853417808e-016
		,1.956217678e-016
		,2.163044269e-016
		,2.486301511e-016
		,2.876246647e-016
		,3.227447203e-016
		,3.498638445e-016
		,3.692218580e-016
		,3.843019585e-016
		,3.954231882e-016
		,4.034902007e-016
		,4.095933883e-016
		,4.144353931e-016
		,4.183320488e-016
		,4.208840549e-016
		,4.231930307e-016
		,4.260827543e-016
		,4.294612965e-016
		,4.335139387e-016
		,4.380069216e-016
		,4.424086979e-016
		,4.462775899e-016
		,4.494966326e-016
		,4.521440575e-016
		,4.543395665e-016
		,1.667525093e-016
		,1.669792441e-016
		,1.672484564e-016
		,1.675358257e-016
		,1.678342443e-016
		,1.681430419e-016
		,1.684645408e-016
		,1.688031303e-016
		,1.691653082e-016
		,1.695602679e-016
		,1.700011003e-016
		,1.705071268e-016
		,1.711088105e-016
		,1.718591889e-016
		,1.728628751e-016
		,1.743541744e-016
		,1.769116149e-016
		,1.820073249e-016
		,1.930040942e-016
		,2.149009572e-016
		,2.483063749e-016
		,2.847057278e-016
		,3.162146454e-016
		,3.415127875e-016
		,3.612069533e-016
		,3.758676357e-016
		,3.865544309e-016
		,3.944515460e-016
		,4.004736586e-016
		,4.052450742e-016
		,4.092061684e-016
		,4.127247326e-016
		,4.161921478e-016
		,4.200644807e-016
		,4.247191891e-016
		,4.300956043e-016
		,4.355924989e-016
		,4.405576300e-016
		,4.447110574e-016
		,4.480892798e-016
		,4.508424477e-016
		,1.669614487e-016
		,1.667030650e-016
		,1.668058686e-016
		,1.670368574e-016
		,1.673157457e-016
		,1.676166876e-016
		,1.679330404e-016
		,1.682655607e-016
		,1.686187203e-016
		,1.689998650e-016
		,1.694190383e-016
		,1.698919603e-016
		,1.704426616e-016
		,1.711266400e-016
		,1.719979608e-016
		,1.732679106e-016
		,1.753536106e-016
		,1.788923108e-016
		,1.867468065e-016
		,2.001022285e-016
		,2.174856484e-016
		,2.425386297e-016
		,2.796053110e-016
		,3.096098663e-016
		,3.329507036e-016
		,3.505215568e-016
		,3.630765605e-016
		,3.730624524e-016
		,3.827542095e-016
		,3.899018850e-016
		,3.950324754e-016
		,3.993019128e-016
		,4.031319413e-016
		,4.069541046e-016
		,4.112355745e-016
		,4.163633127e-016
		,4.223565037e-016
		,4.289780813e-016
		,4.357284238e-016
		,4.411079851e-016
		,4.450369524e-016
		,1.722877990e-016
		,1.684833243e-016
		,1.671047431e-016
		,1.667960356e-016
		,1.668894191e-016
		,1.671295495e-016
		,1.674296677e-016
		,1.677634857e-016
		,1.681263880e-016
		,1.685228636e-016
		,1.689651757e-016
		,1.694726846e-016
		,1.700742793e-016
		,1.707997683e-016
		,1.717732435e-016
		,1.731770985e-016
		,1.753213421e-016
		,1.784780368e-016
		,1.841473092e-016
		,1.929131804e-016
		,2.059672056e-016
		,2.222188856e-016
		,2.432400348e-016
		,2.685415424e-016
		,3.005834934e-016
		,3.245940030e-016
		,3.424543927e-016
		,3.538833196e-016
		,3.618569644e-016
		,3.676118981e-016
		,3.729569105e-016
		,3.818443084e-016
		,3.866537213e-016
		,3.905081223e-016
		,3.944816493e-016
		,3.990000929e-016
		,4.043280769e-016
		,4.103981428e-016
		,4.167214349e-016
		,4.228363891e-016
		,4.288570670e-016
		,2.003278847e-016
		,1.823506118e-016
		,1.731231054e-016
		,1.688646864e-016
		,1.673100214e-016
		,1.669494775e-016
		,1.670452235e-016
		,1.673167101e-016
		,1.676718390e-016
		,1.680890269e-016
		,1.685732003e-016
		,1.691436768e-016
		,1.698196495e-016
		,1.707116100e-016
		,1.719721133e-016
		,1.735946358e-016
		,1.756719002e-016
		,1.785984305e-016
		,1.812826021e-016
		,1.876436618e-016
		,1.931035032e-016
		,2.072381010e-016
		,2.175209250e-016
		,2.445868962e-016
		,2.612291901e-016
		,2.858807258e-016
		,3.101679082e-016
		,3.285393125e-016
		,3.410134145e-016
		,3.491377832e-016
		,3.547183181e-016
		,3.586321639e-016
		,3.617484478e-016
		,3.698374666e-016
		,3.789269406e-016
		,3.830876876e-016
		,3.872570263e-016
		,3.922155136e-016
		,3.979336195e-016
		,4.040481999e-016
		,4.100442911e-016
		,2.778030577e-016
		,2.403680221e-016
		,2.061867917e-016
		,1.849363836e-016
		,1.742218357e-016
		,1.693924418e-016
		,1.676409824e-016
		,1.672464213e-016
		,1.673862011e-016
		,1.677573356e-016
		,1.682696033e-016
		,1.688874237e-016
		,1.697046251e-016
		,1.708286447e-016
		,1.723312762e-016
		,1.739509387e-016
		,1.767347972e-016
		,1.795017008e-016
		,1.820788100e-016
		,1.836137856e-016
		,1.879680446e-016
		,1.901094140e-016
		,2.041850571e-016
		,2.140660520e-016
		,2.288632825e-016
		,2.539681242e-016
		,2.678160481e-016
		,2.903288491e-016
		,3.088285720e-016
		,3.249479195e-016
		,3.359601939e-016
		,3.424503505e-016
		,3.466378226e-016
		,3.493623398e-016
		,3.514181410e-016
		,3.574434655e-016
		,3.703515748e-016
		,3.755306672e-016
		,3.802348541e-016
		,3.857930125e-016
		,3.918731193e-016
		,3.390893176e-016
		,3.174410425e-016
		,2.882525511e-016
		,2.510489786e-016
		,2.137341712e-016
		,1.885088483e-016
		,1.757651780e-016
		,1.702029197e-016
		,1.682586870e-016
		,1.679085313e-016
		,1.681946570e-016
		,1.688429885e-016
		,1.698385903e-016
		,1.712277815e-016
		,1.725664275e-016
		,1.747077415e-016
		,1.775655793e-016
		,1.798270194e-016
		,1.809473047e-016
		,1.832881647e-016
		,1.853298471e-016
		,1.889282866e-016
		,1.909684307e-016
		,1.962739171e-016
		,2.032181465e-016
		,2.142750030e-016
		,2.360936025e-016
		,2.537761856e-016
		,2.683997364e-016
		,2.897495479e-016
		,3.053773605e-016
		,3.198323417e-016
		,3.288340353e-016
		,3.345357146e-016
		,3.384814075e-016
		,3.410760791e-016
		,3.429389382e-016
		,3.490784034e-016
		,3.659616215e-016
		,3.728263049e-016
		,3.782114519e-016
		,3.723173752e-016
		,3.610189418e-016
		,3.462153409e-016
		,3.262997771e-016
		,2.990165348e-016
		,2.629099522e-016
		,2.233497288e-016
		,1.936338207e-016
		,1.781419683e-016
		,1.716105190e-016
		,1.695256424e-016
		,1.694701733e-016
		,1.704038742e-016
		,1.717063438e-016
		,1.731390734e-016
		,1.757861429e-016
		,1.783556618e-016
		,1.795844595e-016
		,1.801014799e-016
		,1.808364775e-016
		,1.842286877e-016
		,1.843199214e-016
		,1.873360114e-016
		,1.887756614e-016
		,1.906525558e-016
		,1.988682130e-016
		,2.012862395e-016
		,2.044872805e-016
		,2.325040547e-016
		,2.521043365e-016
		,2.697091837e-016
		,2.887388075e-016
		,3.051547263e-016
		,3.172277948e-016
		,3.245486471e-016
		,3.295232018e-016
		,3.329827252e-016
		,3.352622220e-016
		,3.368387612e-016
		,3.440611899e-016
		,3.641458130e-016
		,3.911166800e-016
		,3.845959617e-016
		,3.765063330e-016
		,3.662268940e-016
		,3.528224312e-016
		,3.347602671e-016
		,3.097703785e-016
		,2.756469941e-016
		,2.351854070e-016
		,2.010520656e-016
		,1.820636661e-016
		,1.744721243e-016
		,1.725856045e-016
		,1.725484321e-016
		,1.743658403e-016
		,1.768508902e-016
		,1.786521368e-016
		,1.790137989e-016
		,1.790810759e-016
		,1.798943964e-016
		,1.809538617e-016
		,1.829350142e-016
		,1.827533024e-016
		,1.825995279e-016
		,1.832220418e-016
		,1.824402177e-016
		,1.925448298e-016
		,1.973159513e-016
		,1.978045920e-016
		,2.077379605e-016
		,2.181329583e-016
		,2.504492485e-016
		,2.747037751e-016
		,2.907097406e-016
		,3.048629417e-016
		,3.140792555e-016
		,3.203944241e-016
		,3.249593510e-016
		,3.281551744e-016
		,3.301959117e-016
		,3.316367941e-016
		,4.024197249e-016
		,3.982568090e-016
		,3.932941763e-016
		,3.870721873e-016
		,3.796942916e-016
		,3.703728419e-016
		,3.582789212e-016
		,3.420401711e-016
		,3.195302066e-016
		,2.882076245e-016
		,2.485643021e-016
		,2.110391941e-016
		,1.876575583e-016
		,1.786499955e-016
		,1.771558895e-016
		,1.781116958e-016
		,1.784897177e-016
		,1.782290900e-016
		,1.787358998e-016
		,1.776232217e-016
		,1.792009192e-016
		,1.789484564e-016
		,1.798363926e-016
		,1.791397758e-016
		,1.784947048e-016
		,1.797769786e-016
		,1.785766048e-016
		,1.818504454e-016
		,1.899630913e-016
		,1.947600361e-016
		,2.017748833e-016
		,2.117139559e-016
		,2.251488603e-016
		,2.401752870e-016
		,2.657519222e-016
		,2.908100041e-016
		,3.028131127e-016
		,3.107154528e-016
		,3.166058362e-016
		,3.213361131e-016
		,3.243292592e-016
		,4.107154770e-016
		,4.078307277e-016
		,4.045111457e-016
		,4.005017949e-016
		,3.958624748e-016
		,3.901423563e-016
		,3.831982128e-016
		,3.745379743e-016
		,3.632897324e-016
		,3.482065871e-016
		,3.256347907e-016
		,2.946147069e-016
		,2.554551029e-016
		,2.157494075e-016
		,1.921770962e-016
		,1.832819951e-016
		,1.793256343e-016
		,1.781120753e-016
		,1.778627341e-016
		,1.768627317e-016
		,1.751357382e-016
		,1.773183816e-016
		,1.750836137e-016
		,1.759606837e-016
		,1.760232402e-016
		,1.748178447e-016
		,1.761385430e-016
		,1.761332306e-016
		,1.759542905e-016
		,1.866218575e-016
		,1.929337726e-016
		,1.948287307e-016
		,2.052690685e-016
		,2.115866091e-016
		,2.325157914e-016
		,2.495641599e-016
		,2.600266159e-016
		,2.690083927e-016
		,2.942234643e-016
		,3.068975177e-016
		,3.130302646e-016
		,4.180401802e-016
		,4.151109059e-016
		,4.115088039e-016
		,4.089105604e-016
		,4.058719288e-016
		,4.022484092e-016
		,3.978401256e-016
		,3.923009632e-016
		,3.855342171e-016
		,3.768196287e-016
		,3.651835899e-016
		,3.489862743e-016
		,3.252056090e-016
		,2.896420247e-016
		,2.447009056e-016
		,2.091352288e-016
		,1.900270084e-016
		,1.823528881e-016
		,1.775680725e-016
		,1.751025225e-016
		,1.741710152e-016
		,1.725770349e-016
		,1.731411865e-016
		,1.732531143e-016
		,1.730310889e-016
		,1.728510606e-016
		,1.720884615e-016
		,1.727442404e-016
		,1.743709078e-016
		,1.780228919e-016
		,1.827349009e-016
		,1.891121476e-016
		,1.916070387e-016
		,1.965068441e-016
		,2.054445118e-016
		,2.149681319e-016
		,2.421575611e-016
		,2.562840306e-016
		,2.674709912e-016
		,2.725275063e-016
		,2.707314937e-016
		,4.247297216e-016
		,4.230259418e-016
		,4.210647883e-016
		,4.187418478e-016
		,4.165077244e-016
		,4.140746358e-016
		,4.109231670e-016
		,4.071227934e-016
		,4.024041622e-016
		,3.963686184e-016
		,3.884521817e-016
		,3.774789394e-016
		,3.609392783e-016
		,3.376912754e-016
		,3.029907022e-016
		,2.612207810e-016
		,2.252987261e-016
		,2.017382477e-016
		,1.870406494e-016
		,1.766420991e-016
		,1.720061362e-016
		,1.725602826e-016
		,1.685786652e-016
		,1.730155710e-016
		,1.709212336e-016
		,1.703094215e-016
		,1.709026161e-016
		,1.701215544e-016
		,1.727726141e-016
		,1.761882171e-016
		,1.771578355e-016
		,1.787175945e-016
		,1.858286440e-016
		,1.890734748e-016
		,1.904426958e-016
		,2.016215061e-016
		,2.056692497e-016
		,2.243970285e-016
		,2.470166454e-016
		,2.601498620e-016
		,2.692999739e-016
		,4.317296389e-016
		,4.301501745e-016
		,4.284999153e-016
		,4.267152833e-016
		,4.247380651e-016
		,4.225161177e-016
		,4.199699452e-016
		,4.169915671e-016
		,4.134082780e-016
		,4.090162773e-016
		,4.036463014e-016
		,3.946943268e-016
		,3.850963090e-016
		,3.642315483e-016
		,3.442116572e-016
		,3.140522387e-016
		,2.765421163e-016
		,2.386022816e-016
		,2.118783729e-016
		,1.935434691e-016
		,1.782818571e-016
		,1.751462224e-016
		,1.714667779e-016
		,1.698693550e-016
		,1.699060232e-016
		,1.695694301e-016
		,1.683963106e-016
		,1.696137626e-016
		,1.728916258e-016
		,1.736064447e-016
		,1.752338548e-016
		,1.757861040e-016
		,1.767584655e-016
		,1.825208651e-016
		,1.878931371e-016
		,1.897743595e-016
		,1.946999858e-016
		,2.010217258e-016
		,2.050511514e-016
		,2.342244192e-016
		,2.502697227e-016
		,4.363779254e-016
		,4.349813404e-016
		,4.334643429e-016
		,4.318267533e-016
		,4.300572412e-016
		,4.281794026e-016
		,4.262059927e-016
		,4.241426050e-016
		,4.185935581e-016
		,4.163717290e-016
		,4.082979045e-016
		,4.033339033e-016
		,3.936289940e-016
		,3.772369608e-016
		,3.545307279e-016
		,3.246156378e-016
		,2.872320962e-016
		,2.467064506e-016
		,2.244885681e-016
		,2.088973614e-016
		,1.958261536e-016
		,1.891414000e-016
		,1.822696875e-016
		,1.774858340e-016
		,1.699252038e-016
		,1.682813186e-016
		,1.673237953e-016
		,1.692543761e-016
		,1.728692451e-016
		,1.729350973e-016
		,1.729161502e-016
		,1.747924946e-016
		,1.751800729e-016
		,1.756063709e-016
		,1.813369422e-016
		,1.867675995e-016
		,1.878588093e-016
		,1.886281064e-016
		,1.962575309e-016
		,1.991718464e-016
		,2.113454204e-016
		,4.434430008e-016
		,4.424566552e-016
		,4.414593483e-016
		,4.394235633e-016
		,4.370776947e-016
		,4.365546241e-016
		,4.356776454e-016
		,4.345428936e-016
		,4.334524869e-016
		,4.315711988e-016
		,4.261285231e-016
		,4.252885952e-016
		,4.208473826e-016
		,4.142935569e-016
		,4.037585868e-016
		,3.875510544e-016
		,3.649751294e-016
		,3.339282295e-016
		,2.947344256e-016
		,2.602964947e-016
		,2.409106380e-016
		,2.157669591e-016
		,2.051111904e-016
		,1.956479042e-016
		,1.842968427e-016
		,1.732086696e-016
		,1.691236859e-016
		,1.713542127e-016
		,1.704389276e-016
		,1.715755519e-016
		,1.729414337e-016
		,1.728689344e-016
		,1.746181822e-016
		,1.768360550e-016
		,1.778010905e-016
		,1.774007451e-016
		,1.833410138e-016
		,1.861228494e-016
		,1.866678632e-016
		,1.915570087e-016
		,1.943108776e-016
		,4.469643696e-016
		,4.459180462e-016
		,4.448692815e-016
		,4.438519606e-016
		,4.429905345e-016
		,4.423997036e-016
		,4.419637102e-016
		,4.419037555e-016
		,4.388625224e-016
		,4.381631883e-016
		,4.367271992e-016
		,4.353052434e-016
		,4.322991611e-016
		,4.280002145e-016
		,4.218840108e-016
		,4.103121677e-016
		,3.955433625e-016
		,3.738503837e-016
		,3.449289446e-016
		,3.020064499e-016
		,2.799101405e-016
		,2.539058681e-016
		,2.325841478e-016
		,2.218247063e-016
		,2.076762753e-016
		,1.956066647e-016
		,1.837495287e-016
		,1.777987812e-016
		,1.738874111e-016
		,1.712940336e-016
		,1.711522141e-016
		,1.712349973e-016
		,1.741281647e-016
		,1.766518221e-016
		,1.769071634e-016
		,1.776836311e-016
		,1.767407777e-016
		,1.801299164e-016
		,1.840526223e-016
		,1.843677312e-016
		,1.872048366e-016
		,4.536100280e-016
		,4.525679567e-016
		,4.515532213e-016
		,4.505962080e-016
		,4.494376931e-016
		,4.478896026e-016
		,4.449858533e-016
		,4.451666755e-016
		,4.455064165e-016
		,4.441955301e-016
		,4.449785315e-016
		,4.443825553e-016
		,4.421623721e-016
		,4.388453815e-016
		,4.344198690e-016
		,4.259253045e-016
		,4.141317204e-016
		,3.981306959e-016
		,3.754658220e-016
		,3.463164728e-016
		,3.106204599e-016
		,2.921244981e-016
		,2.663870829e-016
		,2.429124129e-016
		,2.352583015e-016
		,2.233198271e-016
		,2.139494037e-016
		,1.990611180e-016
		,1.868559371e-016
		,1.792901927e-016
		,1.740657814e-016
		,1.726030808e-016
		,1.741227632e-016
		,1.737107394e-016
		,1.743492922e-016
		,1.770759405e-016
		,1.773989748e-016
		,1.771482569e-016
		,1.774014781e-016
		,1.828578831e-016
		,1.834822376e-016
		,1.703593873e-016
		,1.711244327e-016
		,1.720960052e-016
		,1.733514501e-016
		,1.749772379e-016
		,1.770522776e-016
		,1.796384491e-016
		,1.827662334e-016
		,1.868961340e-016
		,1.921201237e-016
		,1.998151632e-016
		,2.052068870e-016
		,2.116751609e-016
		,2.218852789e-016
		,2.203400744e-016
		,2.285089189e-016
		,2.678132537e-016
		,2.945049943e-016
		,3.294558215e-016
		,3.639199017e-016
		,3.878007312e-016
		,3.912318438e-016
		,3.960486996e-016
		,3.965560518e-016
		,4.023547898e-016
		,4.100382712e-016
		,4.144279385e-016
		,4.177890424e-016
		,4.206875834e-016
		,4.235673708e-016
		,4.268979894e-016
		,4.310368751e-016
		,4.359043495e-016
		,4.408758406e-016
		,4.452734175e-016
		,4.488673476e-016
		,4.517594090e-016
		,4.541215183e-016
		,4.560973168e-016
		,4.577893316e-016
		,4.592682842e-016
		,1.690594720e-016
		,1.694550116e-016
		,1.699107798e-016
		,1.704526262e-016
		,1.711197625e-016
		,1.719673513e-016
		,1.730808682e-016
		,1.745746712e-016
		,1.765803904e-016
		,1.793348722e-016
		,1.832449886e-016
		,1.879105771e-016
		,1.951370088e-016
		,2.003665715e-016
		,2.100694701e-016
		,2.187361722e-016
		,2.224076521e-016
		,2.518705943e-016
		,2.840131329e-016
		,3.212354048e-016
		,3.551964500e-016
		,3.774186287e-016
		,3.934321818e-016
		,4.027864125e-016
		,4.064559565e-016
		,4.093447088e-016
		,4.091234073e-016
		,4.112496317e-016
		,4.151243048e-016
		,4.188985291e-016
		,4.226133850e-016
		,4.266537080e-016
		,4.313043237e-016
		,4.364027176e-016
		,4.413631518e-016
		,4.456878085e-016
		,4.492505053e-016
		,4.521637860e-016
		,4.546102398e-016
		,4.568478710e-016
		,4.593602388e-016
		,1.683705056e-016
		,1.686704436e-016
		,1.689887020e-016
		,1.693324402e-016
		,1.697121212e-016
		,1.701431050e-016
		,1.706484638e-016
		,1.712633723e-016
		,1.720452829e-016
		,1.730715682e-016
		,1.744734227e-016
		,1.765175600e-016
		,1.796132116e-016
		,1.841601880e-016
		,1.902701309e-016
		,1.970454399e-016
		,2.076706173e-016
		,2.169857678e-016
		,2.380797307e-016
		,2.768154382e-016
		,3.202337363e-016
		,3.497067790e-016
		,3.753823414e-016
		,3.928368171e-016
		,4.044798400e-016
		,4.118891725e-016
		,4.148883671e-016
		,4.164268157e-016
		,4.182835202e-016
		,4.188545951e-016
		,4.188410308e-016
		,4.209113557e-016
		,4.249547487e-016
		,4.301560393e-016
		,4.358808030e-016
		,4.414911002e-016
		,4.467710882e-016
		,4.510328042e-016
		,4.542421571e-016
		,4.569272133e-016
		,4.592599901e-016
		,1.678292668e-016
		,1.681007917e-016
		,1.683830337e-016
		,1.686765804e-016
		,1.689848351e-016
		,1.693132554e-016
		,1.696694560e-016
		,1.700641465e-016
		,1.705123640e-016
		,1.710367185e-016
		,1.716724932e-016
		,1.724776442e-016
		,1.735475644e-016
		,1.750640742e-016
		,1.773642336e-016
		,1.812276332e-016
		,1.863677165e-016
		,1.965284500e-016
		,2.154510830e-016
		,2.449137219e-016
		,2.832382246e-016
		,3.205937093e-016
		,3.486174844e-016
		,3.679967957e-016
		,3.830417081e-016
		,3.945026714e-016
		,4.030519647e-016
		,4.094061667e-016
		,4.142074543e-016
		,4.176382578e-016
		,4.195567831e-016
		,4.220620631e-016
		,4.255748130e-016
		,4.295390417e-016
		,4.335574287e-016
		,4.378994424e-016
		,4.422721906e-016
		,4.461643528e-016
		,4.494130865e-016
		,4.520839293e-016
		,4.542975315e-016
		,1.673773305e-016
		,1.675955800e-016
		,1.678550617e-016
		,1.681333051e-016
		,1.684247501e-016
		,1.687301543e-016
		,1.690531988e-016
		,1.693995622e-016
		,1.697769248e-016
		,1.701954875e-016
		,1.706691139e-016
		,1.712177307e-016
		,1.718726732e-016
		,1.726893013e-016
		,1.737784775e-016
		,1.753891451e-016
		,1.781291549e-016
		,1.835133989e-016
		,1.949007344e-016
		,2.170579985e-016
		,2.502330228e-016
		,2.860701952e-016
		,3.170936150e-016
		,3.420833311e-016
		,3.615918225e-016
		,3.761389458e-016
		,3.867541800e-016
		,3.946043223e-016
		,4.005942270e-016
		,4.053426724e-016
		,4.092868437e-016
		,4.127926246e-016
		,4.162502110e-016
		,4.201148745e-016
		,4.247634327e-016
		,4.301346631e-016
		,4.356270249e-016
		,4.405882219e-016
		,4.447383088e-016
		,4.481137214e-016
		,4.508645176e-016
		,1.675707952e-016
		,1.673132240e-016
		,1.674100977e-016
		,1.676344696e-016
		,1.679090254e-016
		,1.682097915e-016
		,1.685315372e-016
		,1.688762805e-016
		,1.692494906e-016
		,1.696592468e-016
		,1.701161878e-016
		,1.706347658e-016
		,1.712437832e-016
		,1.720033232e-016
		,1.729820081e-016
		,1.743822618e-016
		,1.767829061e-016
		,1.809430394e-016
		,1.897310365e-016
		,2.045977651e-016
		,2.243368171e-016
		,2.485011021e-016
		,2.854659791e-016
		,3.158071993e-016
		,3.380026453e-016
		,3.542920892e-016
		,3.669159399e-016
		,3.755132378e-016
		,3.837706170e-016
		,3.908461652e-016
		,3.957435689e-016
		,3.998443300e-016
		,4.035858434e-016
		,4.074142206e-016
		,4.117902282e-016
		,4.170251879e-016
		,4.229739306e-016
		,4.291996178e-016
		,4.355485030e-016
		,4.412786726e-016
		,4.454743001e-016
		,1.727740391e-016
		,1.690449492e-016
		,1.676918167e-016
		,1.673899773e-016
		,1.674864785e-016
		,1.677323509e-016
		,1.680437558e-016
		,1.683960254e-016
		,1.687856631e-016
		,1.692171121e-016
		,1.697028640e-016
		,1.702645389e-016
		,1.709373126e-016
		,1.717529378e-016
		,1.728315490e-016
		,1.744758933e-016
		,1.771469671e-016
		,1.807961920e-016
		,1.879801955e-016
		,1.980517925e-016
		,2.135021050e-016
		,2.313294171e-016
		,2.553857958e-016
		,2.785280104e-016
		,3.102325011e-016
		,3.337551408e-016
		,3.495575610e-016
		,3.603644016e-016
		,3.679276807e-016
		,3.733843056e-016
		,3.778562481e-016
		,3.856854522e-016
		,3.919623324e-016
		,3.957584849e-016
		,3.996177823e-016
		,4.041098528e-016
		,4.092244528e-016
		,4.146086566e-016
		,4.199423610e-016
		,4.249139662e-016
		,4.293722454e-016
		,1.998931451e-016
		,1.825406933e-016
		,1.735691210e-016
		,1.694090523e-016
		,1.678957507e-016
		,1.675585621e-016
		,1.676764373e-016
		,1.679754412e-016
		,1.683643883e-016
		,1.688243167e-016
		,1.693614565e-016
		,1.700024034e-016
		,1.707637666e-016
		,1.717487984e-016
		,1.732003202e-016
		,1.752426529e-016
		,1.775905253e-016
		,1.813839645e-016
		,1.851401061e-016
		,1.931694514e-016
		,1.999706210e-016
		,2.157757983e-016
		,2.295647524e-016
		,2.587396904e-016
		,2.802198173e-016
		,3.006639056e-016
		,3.242262853e-016
		,3.406361027e-016
		,3.540784101e-016
		,3.624216471e-016
		,3.674079934e-016
		,3.699148726e-016
		,3.715825782e-016
		,3.748978644e-016
		,3.850261365e-016
		,3.917813000e-016
		,3.969894883e-016
		,4.027797196e-016
		,4.087046993e-016
		,4.142328002e-016
		,4.190170659e-016
		,2.761082382e-016
		,2.388979672e-016
		,2.055228934e-016
		,1.850182016e-016
		,1.746466634e-016
		,1.699563666e-016
		,1.682737843e-016
		,1.679264814e-016
		,1.681139037e-016
		,1.685396028e-016
		,1.691224018e-016
		,1.698266272e-016
		,1.707228736e-016
		,1.720150280e-016
		,1.738483414e-016
		,1.758209788e-016
		,1.790474244e-016
		,1.830048172e-016
		,1.866900482e-016
		,1.891172102e-016
		,1.941187185e-016
		,1.979139840e-016
		,2.152639660e-016
		,2.290860702e-016
		,2.498699306e-016
		,2.766627872e-016
		,2.935592006e-016
		,3.129018690e-016
		,3.285985420e-016
		,3.392212761e-016
		,3.500681432e-016
		,3.572670337e-016
		,3.616591661e-016
		,3.644888467e-016
		,3.664764867e-016
		,3.685148341e-016
		,3.766893482e-016
		,3.904866391e-016
		,3.976935494e-016
		,4.039778900e-016
		,4.096001835e-016
		,3.378246673e-016
		,3.159645876e-016
		,2.866022906e-016
		,2.494761688e-016
		,2.128523509e-016
		,1.884869546e-016
		,1.762071088e-016
		,1.708439856e-016
		,1.690056453e-016
		,1.687435344e-016
		,1.691276216e-016
		,1.698451511e-016
		,1.709901282e-016
		,1.726379016e-016
		,1.744530335e-016
		,1.766063075e-016
		,1.804383156e-016
		,1.839388603e-016
		,1.862196731e-016
		,1.890760983e-016
		,1.911836716e-016
		,1.980585982e-016
		,2.007914541e-016
		,2.138105632e-016
		,2.223130384e-016
		,2.309096848e-016
		,2.630807561e-016
		,2.821931434e-016
		,2.952971087e-016
		,3.132764896e-016
		,3.266658640e-016
		,3.367506477e-016
		,3.454593369e-016
		,3.509317378e-016
		,3.542589691e-016
		,3.564573345e-016
		,3.580890682e-016
		,3.598283082e-016
		,3.661137651e-016
		,3.849162051e-016
		,3.949944059e-016
		,3.716057349e-016
		,3.601498595e-016
		,3.451497232e-016
		,3.249972291e-016
		,2.974950086e-016
		,2.613504815e-016
		,2.223181566e-016
		,1.935309688e-016
		,1.786635619e-016
		,1.724335999e-016
		,1.704804500e-016
		,1.705826503e-016
		,1.717589188e-016
		,1.735985993e-016
		,1.749059138e-016
		,1.781618668e-016
		,1.818962720e-016
		,1.843805675e-016
		,1.860590291e-016
		,1.862176990e-016
		,1.911263798e-016
		,1.928875343e-016
		,1.981307975e-016
		,2.037013505e-016
		,2.118435349e-016
		,2.230373007e-016
		,2.266929118e-016
		,2.359687993e-016
		,2.524668356e-016
		,2.666508643e-016
		,2.921684217e-016
		,3.106434616e-016
		,3.211554978e-016
		,3.301199417e-016
		,3.374218656e-016
		,3.421987968e-016
		,3.454694148e-016
		,3.478370645e-016
		,3.501329933e-016
		,3.526443126e-016
		,3.594971252e-016
		,3.907174841e-016
		,3.841260319e-016
		,3.759474701e-016
		,3.655601136e-016
		,3.519985898e-016
		,3.337461911e-016
		,3.085285131e-016
		,2.743231923e-016
		,2.342511283e-016
		,2.009764538e-016
		,1.827744972e-016
		,1.756584121e-016
		,1.742292946e-016
		,1.744643343e-016
		,1.764015741e-016
		,1.798491016e-016
		,1.829723162e-016
		,1.844149466e-016
		,1.850849644e-016
		,1.864103421e-016
		,1.882723636e-016
		,1.919631047e-016
		,1.944321300e-016
		,1.988793018e-016
		,2.007696906e-016
		,2.056349062e-016
		,2.159071108e-016
		,2.228157159e-016
		,2.272401137e-016
		,2.394706389e-016
		,2.576609277e-016
		,2.653991967e-016
		,2.745941912e-016
		,2.814096366e-016
		,3.008994881e-016
		,3.228234929e-016
		,3.311293888e-016
		,3.361259302e-016
		,3.398330712e-016
		,3.428926407e-016
		,3.456267088e-016
		,3.982687992e-016
		,3.931446796e-016
		,3.870391762e-016
		,3.795023934e-016
		,3.699615057e-016
		,3.577732385e-016
		,3.414279249e-016
		,3.187979795e-016
		,2.874468510e-016
		,2.482698613e-016
		,2.117292919e-016
		,1.894976462e-016
		,1.804232647e-016
		,1.796762369e-016
		,1.817572229e-016
		,1.834752354e-016
		,1.841829985e-016
		,1.849514110e-016
		,1.848942147e-016
		,1.881709179e-016
		,1.875894973e-016
		,1.930847947e-016
		,1.946948065e-016
		,1.962631441e-016
		,1.978819953e-016
		,1.996306715e-016
		,2.094017946e-016
		,2.142912548e-016
		,2.168733416e-016
		,2.244375701e-016
		,2.353741518e-016
		,2.545635688e-016
		,2.644333735e-016
		,2.804863928e-016
		,2.899075647e-016
		,2.970460192e-016
		,2.980609464e-016
		,2.944138936e-016
		,3.182419451e-016
		,3.277075791e-016
		,3.335014172e-016
		,4.105255982e-016
		,4.076326631e-016
		,4.043062127e-016
		,4.004269787e-016
		,3.958086382e-016
		,3.901151762e-016
		,3.832498405e-016
		,3.743982052e-016
		,3.632310393e-016
		,3.482396638e-016
		,3.271401347e-016
		,2.958232401e-016
		,2.566754209e-016
		,2.183452126e-016
		,1.954999594e-016
		,1.876549498e-016
		,1.848649964e-016
		,1.839200010e-016
		,1.853494588e-016
		,1.854153833e-016
		,1.843707150e-016
		,1.872765452e-016
		,1.887831616e-016
		,1.916082126e-016
		,1.915893397e-016
		,1.917880511e-016
		,1.940161455e-016
		,1.952821542e-016
		,2.009570844e-016
		,2.052142814e-016
		,2.076872778e-016
		,2.103530309e-016
		,2.206793511e-016
		,2.374061363e-016
		,2.553205605e-016
		,2.696549753e-016
		,2.831755366e-016
		,2.930063694e-016
		,3.018898365e-016
		,3.061639716e-016
		,3.060553841e-016
		,4.178944339e-016
		,4.157949360e-016
		,4.132412047e-016
		,4.099192406e-016
		,4.055622601e-016
		,4.018682233e-016
		,3.975722830e-016
		,3.922487171e-016
		,3.855195302e-016
		,3.769855100e-016
		,3.655968563e-016
		,3.498362351e-016
		,3.267611487e-016
		,2.924941073e-016
		,2.491795477e-016
		,2.146517193e-016
		,1.957224236e-016
		,1.882808592e-016
		,1.861578770e-016
		,1.859372401e-016
		,1.840613464e-016
		,1.830657307e-016
		,1.876718225e-016
		,1.869157885e-016
		,1.879481818e-016
		,1.878151731e-016
		,1.882195406e-016
		,1.889267235e-016
		,1.898414241e-016
		,1.919558716e-016
		,1.974114292e-016
		,2.001123670e-016
		,2.047252662e-016
		,2.133323517e-016
		,2.193768339e-016
		,2.412939939e-016
		,2.576376010e-016
		,2.739200112e-016
		,2.852345709e-016
		,2.960186882e-016
		,3.032985357e-016
		,4.246159985e-016
		,4.229288494e-016
		,4.210843496e-016
		,4.187357136e-016
		,4.164701167e-016
		,4.140932449e-016
		,4.110024750e-016
		,4.072652388e-016
		,4.026708795e-016
		,3.968266132e-016
		,3.890828022e-016
		,3.784503022e-016
		,3.629120226e-016
		,3.397509363e-016
		,3.068834175e-016
		,2.655035778e-016
		,2.295096725e-016
		,2.084322948e-016
		,1.961924562e-016
		,1.890792051e-016
		,1.849187747e-016
		,1.821135255e-016
		,1.829186538e-016
		,1.851153542e-016
		,1.835890344e-016
		,1.845079524e-016
		,1.845912708e-016
		,1.836846970e-016
		,1.834772509e-016
		,1.835691777e-016
		,1.855857321e-016
		,1.923779282e-016
		,1.986177441e-016
		,2.015132723e-016
		,2.045846601e-016
		,2.132377434e-016
		,2.187965048e-016
		,2.457577266e-016
		,2.629008565e-016
		,2.760101822e-016
		,2.878908454e-016
		,4.319860177e-016
		,4.303557204e-016
		,4.284928950e-016
		,4.266309781e-016
		,4.246640287e-016
		,4.224596269e-016
		,4.199222441e-016
		,4.169548733e-016
		,4.134029941e-016
		,4.090295292e-016
		,4.034759067e-016
		,3.948450892e-016
		,3.848250969e-016
		,3.687748030e-016
		,3.434268980e-016
		,3.126052800e-016
		,2.775884920e-016
		,2.446295823e-016
		,2.206917667e-016
		,2.051455106e-016
		,1.921583231e-016
		,1.881901313e-016
		,1.823405172e-016
		,1.805109457e-016
		,1.810680994e-016
		,1.808118487e-016
		,1.811104023e-016
		,1.806077986e-016
		,1.796783718e-016
		,1.798222631e-016
		,1.794294522e-016
		,1.834478241e-016
		,1.902289398e-016
		,1.956990115e-016
		,1.982850829e-016
		,1.990394167e-016
		,2.063520930e-016
		,2.108165454e-016
		,2.231492882e-016
		,2.513088353e-016
		,2.677372594e-016
		,4.374189787e-016
		,4.359416662e-016
		,4.343564224e-016
		,4.326517927e-016
		,4.308049861e-016
		,4.278935413e-016
		,4.253065360e-016
		,4.227995356e-016
		,4.200654215e-016
		,4.165414628e-016
		,4.081025990e-016
		,3.988084952e-016
		,3.908268703e-016
		,3.739852590e-016
		,3.516829506e-016
		,3.220150790e-016
		,2.871675904e-016
		,2.527884142e-016
		,2.323742191e-016
		,2.179093863e-016
		,2.073502494e-016
		,2.012810048e-016
		,1.941764230e-016
		,1.847079523e-016
		,1.806323073e-016
		,1.792662844e-016
		,1.766442413e-016
		,1.757849149e-016
		,1.776267989e-016
		,1.766359667e-016
		,1.782875582e-016
		,1.823521526e-016
		,1.831619705e-016
		,1.848832763e-016
		,1.917117605e-016
		,1.954915113e-016
		,1.977985522e-016
		,2.001490597e-016
		,2.056542696e-016
		,2.095413031e-016
		,2.343464115e-016
		,4.449704459e-016
		,4.440227677e-016
		,4.427612173e-016
		,4.414528381e-016
		,4.401421983e-016
		,4.388798963e-016
		,4.359952856e-016
		,4.335800389e-016
		,4.331284077e-016
		,4.326269350e-016
		,4.277857573e-016
		,4.258779355e-016
		,4.206798673e-016
		,4.127299770e-016
		,3.997595873e-016
		,3.827642585e-016
		,3.593697348e-016
		,3.293742743e-016
		,2.895411470e-016
		,2.620997990e-016
		,2.441830967e-016
		,2.224895605e-016
		,2.113548669e-016
		,2.057710240e-016
		,1.927004653e-016
		,1.830755068e-016
		,1.785721008e-016
		,1.752285284e-016
		,1.735053074e-016
		,1.725144548e-016
		,1.768098266e-016
		,1.813108848e-016
		,1.815078388e-016
		,1.827677677e-016
		,1.821978123e-016
		,1.883811482e-016
		,1.924755818e-016
		,1.950894639e-016
		,1.977288695e-016
		,2.061858736e-016
		,2.072391910e-016
		,4.501917315e-016
		,4.482598453e-016
		,4.464591715e-016
		,4.462942213e-016
		,4.461252418e-016
		,4.456636555e-016
		,4.449439986e-016
		,4.441777378e-016
		,4.437105592e-016
		,4.414820390e-016
		,4.400738853e-016
		,4.399775191e-016
		,4.359105536e-016
		,4.299598061e-016
		,4.210301187e-016
		,4.074112439e-016
		,3.925466396e-016
		,3.686890566e-016
		,3.382815585e-016
		,2.960649847e-016
		,2.801107488e-016
		,2.520397724e-016
		,2.327866956e-016
		,2.294207327e-016
		,2.189277609e-016
		,2.033747201e-016
		,1.906916093e-016
		,1.821673234e-016
		,1.758038895e-016
		,1.738727438e-016
		,1.770381067e-016
		,1.767987771e-016
		,1.764733078e-016
		,1.807149165e-016
		,1.825248209e-016
		,1.825768539e-016
		,1.842554758e-016
		,1.913555500e-016
		,1.963255926e-016
		,1.968734619e-016
		,2.002389485e-016
		,4.535936308e-016
		,4.522188866e-016
		,4.512810596e-016
		,4.504828105e-016
		,4.500109100e-016
		,4.499972886e-016
		,4.503666281e-016
		,4.488676611e-016
		,4.492828124e-016
		,4.491939132e-016
		,4.494902880e-016
		,4.472143977e-016
		,4.435646792e-016
		,4.382562986e-016
		,4.284933574e-016
		,4.152759628e-016
		,3.962353437e-016
		,3.719281188e-016
		,3.445290980e-016
		,3.112512166e-016
		,3.012694702e-016
		,2.872533900e-016
		,2.617219787e-016
		,2.507763599e-016
		,2.415726119e-016
		,2.324836630e-016
		,2.174396181e-016
		,2.024913057e-016
		,1.909206849e-016
		,1.846796124e-016
		,1.806787208e-016
		,1.776527667e-016
		,1.772428401e-016
		,1.766690506e-016
		,1.767238669e-016
		,1.783798155e-016
		,1.836824556e-016
		,1.844625166e-016
		,1.917225692e-016
		,1.946676993e-016
		,1.956030091e-016
		,1.709269892e-016
		,1.717040186e-016
		,1.726943854e-016
		,1.739796710e-016
		,1.756392279e-016
		,1.777307139e-016
		,1.802667309e-016
		,1.833594889e-016
		,1.874991002e-016
		,1.927129433e-016
		,2.005193238e-016
		,2.056472900e-016
		,2.115109917e-016
		,2.217935168e-016
		,2.207607023e-016
		,2.249832719e-016
		,2.626389431e-016
		,2.926270960e-016
		,3.206724220e-016
		,3.566851629e-016
		,3.839263746e-016
		,3.905026421e-016
		,3.942084720e-016
		,3.933629720e-016
		,3.982655302e-016
		,4.067543964e-016
		,4.142756175e-016
		,4.182966270e-016
		,4.214313733e-016
		,4.243198911e-016
		,4.273863921e-016
		,4.310330765e-016
		,4.353548487e-016
		,4.399380301e-016
		,4.442392430e-016
		,4.479856617e-016
		,4.511077586e-016
		,4.536376229e-016
		,4.556998327e-016
		,4.574283065e-016
		,4.589200456e-016
		,1.695621317e-016
		,1.699537480e-016
		,1.704105945e-016
		,1.709602324e-016
		,1.716431501e-016
		,1.725155113e-016
		,1.736646647e-016
		,1.752003149e-016
		,1.772316335e-016
		,1.800125562e-016
		,1.838846397e-016
		,1.885647701e-016
		,1.960009678e-016
		,2.008626931e-016
		,2.103880288e-016
		,2.193515708e-016
		,2.193543695e-016
		,2.485719865e-016
		,2.778208865e-016
		,3.157505790e-016
		,3.499966138e-016
		,3.751991773e-016
		,3.909450635e-016
		,3.982360415e-016
		,4.051432828e-016
		,4.076856710e-016
		,4.073456783e-016
		,4.103695691e-016
		,4.145302794e-016
		,4.185208046e-016
		,4.222499441e-016
		,4.261251514e-016
		,4.305563149e-016
		,4.355415611e-016
		,4.405623739e-016
		,4.450402336e-016
		,4.487468668e-016
		,4.517450544e-016
		,4.541913583e-016
		,4.562342200e-016
		,4.579931982e-016
		,1.688523167e-016
		,1.691430421e-016
		,1.694551409e-016
		,1.697968147e-016
		,1.701797144e-016
		,1.706202214e-016
		,1.711428077e-016
		,1.717844143e-016
		,1.726021426e-016
		,1.736731518e-016
		,1.751282908e-016
		,1.772394020e-016
		,1.803951038e-016
		,1.849831615e-016
		,1.910792314e-016
		,1.975032125e-016
		,2.080202862e-016
		,2.154465730e-016
		,2.360262330e-016
		,2.723219092e-016
		,3.141045329e-016
		,3.453827964e-016
		,3.709697766e-016
		,3.903563123e-016
		,4.029936955e-016
		,4.108684149e-016
		,4.137514303e-016
		,4.161597297e-016
		,4.182520148e-016
		,4.184698806e-016
		,4.186402686e-016
		,4.209831731e-016
		,4.248035576e-016
		,4.296501075e-016
		,4.350879906e-016
		,4.404072964e-016
		,4.450756124e-016
		,4.490006494e-016
		,4.524805307e-016
		,4.557173759e-016
		,4.581718695e-016
		,1.683034669e-016
		,1.685656935e-016
		,1.688415778e-016
		,1.691324650e-016
		,1.694424941e-016
		,1.697779077e-016
		,1.701471358e-016
		,1.705614501e-016
		,1.710363317e-016
		,1.715944927e-016
		,1.722715577e-016
		,1.731266404e-016
		,1.742495211e-016
		,1.758311764e-016
		,1.781868663e-016
		,1.821626106e-016
		,1.873530262e-016
		,1.972356409e-016
		,2.155872797e-016
		,2.417822414e-016
		,2.799937248e-016
		,3.179739458e-016
		,3.478329751e-016
		,3.674244086e-016
		,3.825500955e-016
		,3.939614127e-016
		,4.024250125e-016
		,4.088894434e-016
		,4.138963622e-016
		,4.173212696e-016
		,4.191745104e-016
		,4.216607030e-016
		,4.247881081e-016
		,4.284103688e-016
		,4.326823285e-016
		,4.376215136e-016
		,4.422712599e-016
		,4.462103273e-016
		,4.494715317e-016
		,4.521516193e-016
		,4.543723436e-016
		,1.678475032e-016
		,1.680588708e-016
		,1.683141831e-016
		,1.685920296e-016
		,1.688876377e-016
		,1.692024279e-016
		,1.695406055e-016
		,1.699081375e-016
		,1.703126233e-016
		,1.707637283e-016
		,1.712744225e-016
		,1.718638224e-016
		,1.725634384e-016
		,1.734311855e-016
		,1.745848027e-016
		,1.762871999e-016
		,1.791706209e-016
		,1.847806967e-016
		,1.964619446e-016
		,2.187889775e-016
		,2.517493538e-016
		,2.871352932e-016
		,3.177791904e-016
		,3.425291792e-016
		,3.618933123e-016
		,3.763519852e-016
		,3.869113724e-016
		,3.947247905e-016
		,4.006894738e-016
		,4.054199052e-016
		,4.093507874e-016
		,4.128465179e-016
		,4.162963689e-016
		,4.201549908e-016
		,4.247986992e-016
		,4.301658355e-016
		,4.356546122e-016
		,4.406126935e-016
		,4.447601320e-016
		,4.481333150e-016
		,4.508822277e-016
		,1.680281358e-016
		,1.677740474e-016
		,1.678724412e-016
		,1.681007136e-016
		,1.683834365e-016
		,1.686975989e-016
		,1.690383943e-016
		,1.694078546e-016
		,1.698110165e-016
		,1.702550339e-016
		,1.707497641e-016
		,1.713081282e-016
		,1.719618094e-016
		,1.727774203e-016
		,1.738433317e-016
		,1.753421940e-016
		,1.779592414e-016
		,1.826566270e-016
		,1.920693261e-016
		,2.081828977e-016
		,2.294067136e-016
		,2.532335457e-016
		,2.890763643e-016
		,3.191003088e-016
		,3.421123008e-016
		,3.579483143e-016
		,3.688499608e-016
		,3.774801604e-016
		,3.855468494e-016
		,3.918795649e-016
		,3.962927306e-016
		,4.002507572e-016
		,4.039398963e-016
		,4.077917205e-016
		,4.122510101e-016
		,4.175622646e-016
		,4.234728190e-016
		,4.294475892e-016
		,4.353228537e-016
		,4.410083911e-016
		,4.454637333e-016
		,1.731364403e-016
		,1.694718503e-016
		,1.681474276e-016
		,1.678621893e-016
		,1.679743539e-016
		,1.682392912e-016
		,1.685746800e-016
		,1.689559194e-016
		,1.693789276e-016
		,1.698473618e-016
		,1.703710042e-016
		,1.709749495e-016
		,1.716993560e-016
		,1.725934087e-016
		,1.737393579e-016
		,1.755658752e-016
		,1.786698135e-016
		,1.827113771e-016
		,1.909868109e-016
		,2.019867649e-016
		,2.199302821e-016
		,2.374998391e-016
		,2.631699491e-016
		,2.873254861e-016
		,3.160966344e-016
		,3.375701927e-016
		,3.553009955e-016
		,3.650627917e-016
		,3.711494201e-016
		,3.762907396e-016
		,3.803909751e-016
		,3.868231222e-016
		,3.939262715e-016
		,3.979768623e-016
		,4.021324689e-016
		,4.070689945e-016
		,4.126937982e-016
		,4.184908298e-016
		,4.238470701e-016
		,4.284461893e-016
		,4.322836039e-016
		,1.995428045e-016
		,1.826848856e-016
		,1.739219359e-016
		,1.698517459e-016
		,1.683855698e-016
		,1.680820009e-016
		,1.682320782e-016
		,1.685657724e-016
		,1.689918512e-016
		,1.694900010e-016
		,1.700698862e-016
		,1.707626032e-016
		,1.716009158e-016
		,1.726426935e-016
		,1.742326492e-016
		,1.765940097e-016
		,1.793023296e-016
		,1.835781770e-016
		,1.883090239e-016
		,1.973488863e-016
		,2.056864958e-016
		,2.221597520e-016
		,2.384784149e-016
		,2.685364073e-016
		,2.895813313e-016
		,3.118986399e-016
		,3.324267524e-016
		,3.461336213e-016
		,3.586418363e-016
		,3.673902336e-016
		,3.730124962e-016
		,3.768354722e-016
		,3.796099267e-016
		,3.822479841e-016
		,3.896584432e-016
		,3.982902619e-016
		,4.036521098e-016
		,4.095344878e-016
		,4.153863826e-016
		,4.206385286e-016
		,4.250774739e-016
		,2.747121327e-016
		,2.377111180e-016
		,2.050113839e-016
		,1.851102635e-016
		,1.750210198e-016
		,1.704550236e-016
		,1.688408359e-016
		,1.685420587e-016
		,1.687731420e-016
		,1.692439425e-016
		,1.698803597e-016
		,1.706610944e-016
		,1.716061955e-016
		,1.730217202e-016
		,1.751158606e-016
		,1.775149930e-016
		,1.807756298e-016
		,1.857443442e-016
		,1.903633936e-016
		,1.936048322e-016
		,1.994849213e-016
		,2.031889186e-016
		,2.238671300e-016
		,2.374255970e-016
		,2.630016195e-016
		,2.909908058e-016
		,3.059255740e-016
		,3.233062215e-016
		,3.404074534e-016
		,3.507057269e-016
		,3.590388959e-016
		,3.643129421e-016
		,3.675217853e-016
		,3.705058463e-016
		,3.731470505e-016
		,3.759337211e-016
		,3.810964405e-016
		,3.959321703e-016
		,4.069023746e-016
		,4.137916965e-016
		,4.193716759e-016
		,3.367638044e-016
		,3.147419634e-016
		,2.852529421e-016
		,2.482221805e-016
		,2.121976158e-016
		,1.885379369e-016
		,1.766329718e-016
		,1.714338552e-016
		,1.696825284e-016
		,1.694898935e-016
		,1.699614286e-016
		,1.707215303e-016
		,1.719699638e-016
		,1.738230733e-016
		,1.761103408e-016
		,1.781667967e-016
		,1.826852594e-016
		,1.871582793e-016
		,1.903155912e-016
		,1.939111167e-016
		,1.957219090e-016
		,2.040514456e-016
		,2.083230845e-016
		,2.237652497e-016
		,2.366828959e-016
		,2.420666593e-016
		,2.728818180e-016
		,3.000039284e-016
		,3.130183281e-016
		,3.245754076e-016
		,3.367057332e-016
		,3.451889136e-016
		,3.527637754e-016
		,3.588222636e-016
		,3.629929280e-016
		,3.662572438e-016
		,3.693519429e-016
		,3.727284469e-016
		,3.771317488e-016
		,3.894781000e-016
		,4.064553432e-016
		,3.710031455e-016
		,3.594204902e-016
		,3.442582558e-016
		,3.239286912e-016
		,2.962661472e-016
		,2.601273134e-016
		,2.215670317e-016
		,1.935417767e-016
		,1.791670059e-016
		,1.731816321e-016
		,1.713262795e-016
		,1.715373667e-016
		,1.728984031e-016
		,1.751214499e-016
		,1.765949039e-016
		,1.799013429e-016
		,1.845159679e-016
		,1.880332085e-016
		,1.907413287e-016
		,1.911693050e-016
		,1.953999932e-016
		,1.992768779e-016
		,2.045784810e-016
		,2.119348062e-016
		,2.277893569e-016
		,2.378446397e-016
		,2.458798131e-016
		,2.605733291e-016
		,2.797849300e-016
		,2.922422312e-016
		,3.009333027e-016
		,3.124930789e-016
		,3.202795977e-016
		,3.327299909e-016
		,3.450276079e-016
		,3.517264308e-016
		,3.560760570e-016
		,3.597112606e-016
		,3.632802101e-016
		,3.668919813e-016
		,3.708432845e-016
		,3.903807141e-016
		,3.837333052e-016
		,3.754821482e-016
		,3.650030877e-016
		,3.513183633e-016
		,3.329075777e-016
		,3.075373962e-016
		,2.732830280e-016
		,2.335765771e-016
		,2.010163074e-016
		,1.834167555e-016
		,1.766652771e-016
		,1.755608920e-016
		,1.763308784e-016
		,1.779299356e-016
		,1.820919179e-016
		,1.862574782e-016
		,1.883869440e-016
		,1.900188103e-016
		,1.913462980e-016
		,1.926434656e-016
		,1.988131964e-016
		,2.005543478e-016
		,2.087615717e-016
		,2.138816218e-016
		,2.238556871e-016
		,2.365575796e-016
		,2.414533472e-016
		,2.484635840e-016
		,2.667435717e-016
		,2.892543300e-016
		,2.988983490e-016
		,3.081602451e-016
		,3.205230614e-016
		,3.275998964e-016
		,3.326610179e-016
		,3.375850927e-016
		,3.404177989e-016
		,3.402900540e-016
		,3.344371670e-016
		,2.928552535e-016
		,4.023311803e-016
		,3.981201263e-016
		,3.931105005e-016
		,3.869314185e-016
		,3.793429102e-016
		,3.697857940e-016
		,3.573587487e-016
		,3.409373230e-016
		,3.181952716e-016
		,2.868275877e-016
		,2.480355823e-016
		,2.123159729e-016
		,1.911141962e-016
		,1.819019622e-016
		,1.815413281e-016
		,1.844393066e-016
		,1.872993826e-016
		,1.887397255e-016
		,1.897761143e-016
		,1.897941210e-016
		,1.932807561e-016
		,1.940765542e-016
		,1.998923524e-016
		,2.048583717e-016
		,2.098422728e-016
		,2.135049371e-016
		,2.216928366e-016
		,2.289676351e-016
		,2.351202798e-016
		,2.408135490e-016
		,2.534345323e-016
		,2.739245748e-016
		,2.892441824e-016
		,2.963490763e-016
		,3.060043766e-016
		,3.159467827e-016
		,3.220903831e-016
		,3.280165812e-016
		,3.338286646e-016
		,3.380098139e-016
		,3.407971937e-016
		,4.103956852e-016
		,4.074984605e-016
		,4.041675624e-016
		,4.002760776e-016
		,3.956717755e-016
		,3.901296852e-016
		,3.831432197e-016
		,3.745547636e-016
		,3.631153682e-016
		,3.481942143e-016
		,3.275176983e-016
		,2.974209220e-016
		,2.576676728e-016
		,2.202444788e-016
		,1.979812355e-016
		,1.908141069e-016
		,1.890215992e-016
		,1.890712848e-016
		,1.901087555e-016
		,1.904589654e-016
		,1.909332736e-016
		,1.928198243e-016
		,1.963964898e-016
		,2.029950526e-016
		,2.045001338e-016
		,2.084258057e-016
		,2.110458584e-016
		,2.155738382e-016
		,2.251014101e-016
		,2.304520982e-016
		,2.336969537e-016
		,2.408928496e-016
		,2.493386030e-016
		,2.736357713e-016
		,2.819231520e-016
		,2.895067766e-016
		,3.018335799e-016
		,3.110339685e-016
		,3.187796815e-016
		,3.271556595e-016
		,3.342220775e-016
		,4.182913803e-016
		,4.156677596e-016
		,4.133110258e-016
		,4.106528119e-016
		,4.068603861e-016
		,4.026760327e-016
		,3.972872253e-016
		,3.921186853e-016
		,3.854639089e-016
		,3.770126151e-016
		,3.658917742e-016
		,3.502905543e-016
		,3.276663495e-016
		,2.943069336e-016
		,2.528115292e-016
		,2.187767289e-016
		,2.004815620e-016
		,1.929692528e-016
		,1.916436195e-016
		,1.918439185e-016
		,1.906207936e-016
		,1.894505934e-016
		,1.956184275e-016
		,1.991016400e-016
		,2.014155707e-016
		,2.033957504e-016
		,2.041528643e-016
		,2.063406392e-016
		,2.128672517e-016
		,2.203932570e-016
		,2.238365340e-016
		,2.251188658e-016
		,2.269009160e-016
		,2.338313694e-016
		,2.459208481e-016
		,2.678903644e-016
		,2.765930200e-016
		,2.888453560e-016
		,3.013297038e-016
		,3.102201342e-016
		,3.195473918e-016
		,4.245280397e-016
		,4.228574258e-016
		,4.210295665e-016
		,4.188383064e-016
		,4.164538885e-016
		,4.141211402e-016
		,4.110719506e-016
		,4.074256871e-016
		,4.029194109e-016
		,3.971491525e-016
		,3.896091219e-016
		,3.792027547e-016
		,3.642744502e-016
		,3.407330215e-016
		,3.090281180e-016
		,2.692929404e-016
		,2.340944094e-016
		,2.124262682e-016
		,2.021246812e-016
		,1.965088070e-016
		,1.936255446e-016
		,1.863004397e-016
		,1.929790007e-016
		,1.973547421e-016
		,1.974311051e-016
		,1.993598391e-016
		,1.995129593e-016
		,2.023278187e-016
		,2.031970705e-016
		,2.065502183e-016
		,2.130599276e-016
		,2.162503427e-016
		,2.163220936e-016
		,2.158874767e-016
		,2.208778236e-016
		,2.268058493e-016
		,2.493926979e-016
		,2.663821256e-016
		,2.767474104e-016
		,2.908674841e-016
		,3.010457745e-016
		,4.319316248e-016
		,4.302329988e-016
		,4.285929412e-016
		,4.268432690e-016
		,4.248916906e-016
		,4.227065640e-016
		,4.202088418e-016
		,4.172864525e-016
		,4.137773132e-016
		,4.093760424e-016
		,4.038613407e-016
		,3.955168345e-016
		,3.843032222e-016
		,3.699390690e-016
		,3.446259454e-016
		,3.122187996e-016
		,2.779001176e-016
		,2.482431189e-016
		,2.261837579e-016
		,2.124599270e-016
		,2.037403066e-016
		,1.929540030e-016
		,1.920497296e-016
		,1.945846673e-016
		,1.939392914e-016
		,1.933089454e-016
		,1.963316724e-016
		,1.982827538e-016
		,1.997976627e-016
		,1.993936546e-016
		,1.995850081e-016
		,2.034881581e-016
		,2.069152035e-016
		,2.084843943e-016
		,2.109902474e-016
		,2.151088292e-016
		,2.201198183e-016
		,2.226787172e-016
		,2.532659991e-016
		,2.659454123e-016
		,2.799842085e-016
		,4.385931042e-016
		,4.371515944e-016
		,4.356411685e-016
		,4.340146579e-016
		,4.322577148e-016
		,4.303433475e-016
		,4.282289092e-016
		,4.258373658e-016
		,4.230870371e-016
		,4.199661344e-016
		,4.161052768e-016
		,4.095720879e-016
		,3.998358861e-016
		,3.848607290e-016
		,3.705333459e-016
		,3.487241634e-016
		,3.194271738e-016
		,2.872968417e-016
		,2.570621906e-016
		,2.384321828e-016
		,2.219786609e-016
		,2.091156936e-016
		,2.045554557e-016
		,1.971250552e-016
		,1.942696703e-016
		,1.918752550e-016
		,1.921922175e-016
		,1.922687451e-016
		,1.920979256e-016
		,1.954712487e-016
		,1.943372050e-016
		,1.937239372e-016
		,1.949831069e-016
		,2.000030082e-016
		,2.055272155e-016
		,2.082107829e-016
		,2.100547245e-016
		,2.160855891e-016
		,2.180055346e-016
		,2.242615667e-016
		,2.534045369e-016
		,4.458296274e-016
		,4.439957923e-016
		,4.426030566e-016
		,4.411351627e-016
		,4.395964536e-016
		,4.379895517e-016
		,4.363218159e-016
		,4.346160274e-016
		,4.327629877e-016
		,4.284749483e-016
		,4.275121356e-016
		,4.213161810e-016
		,4.174454878e-016
		,4.088721405e-016
		,3.945012384e-016
		,3.774617762e-016
		,3.543978592e-016
		,3.247340430e-016
		,2.880185604e-016
		,2.657738645e-016
		,2.493716134e-016
		,2.270547968e-016
		,2.249266723e-016
		,2.146457019e-016
		,2.034298161e-016
		,1.972176337e-016
		,1.935731493e-016
		,1.914071577e-016
		,1.896014771e-016
		,1.877327308e-016
		,1.861367112e-016
		,1.856061430e-016
		,1.896019337e-016
		,1.901890625e-016
		,1.991109692e-016
		,2.031190211e-016
		,2.049762025e-016
		,2.068218216e-016
		,2.096721975e-016
		,2.153943167e-016
		,2.161982872e-016
		,4.531127767e-016
		,4.522680122e-016
		,4.513592252e-016
		,4.504307830e-016
		,4.492480298e-016
		,4.457101254e-016
		,4.457518688e-016
		,4.456384215e-016
		,4.451831717e-016
		,4.451707047e-016
		,4.407001024e-016
		,4.418193453e-016
		,4.358924751e-016
		,4.279145389e-016
		,4.155451081e-016
		,4.000187099e-016
		,3.802793740e-016
		,3.579434350e-016
		,3.272743070e-016
		,2.932690987e-016
		,2.783810222e-016
		,2.527846039e-016
		,2.407073574e-016
		,2.375655893e-016
		,2.259642226e-016
		,2.147908406e-016
		,2.056153891e-016
		,1.973428869e-016
		,1.909880640e-016
		,1.866292163e-016
		,1.841051361e-016
		,1.831545898e-016
		,1.809002775e-016
		,1.827222260e-016
		,1.894780888e-016
		,1.937454400e-016
		,2.003642009e-016
		,2.027321821e-016
		,2.047482865e-016
		,2.060896093e-016
		,2.113633034e-016
		,4.555400045e-016
		,4.552826219e-016
		,4.552946455e-016
		,4.553707372e-016
		,4.553792534e-016
		,4.551916561e-016
		,4.549954307e-016
		,4.551231967e-016
		,4.541028238e-016
		,4.544164658e-016
		,4.569867097e-016
		,4.540307719e-016
		,4.485454431e-016
		,4.404714430e-016
		,4.270299183e-016
		,4.097973962e-016
		,3.876042437e-016
		,3.616059975e-016
		,3.238232598e-016
		,3.068163711e-016
		,2.963123581e-016
		,2.822166462e-016
		,2.596247747e-016
		,2.544598433e-016
		,2.511747579e-016
		,2.393290194e-016
		,2.280973265e-016
		,2.161062935e-016
		,2.045509688e-016
		,1.945287007e-016
		,1.866965236e-016
		,1.822021836e-016
		,1.821316183e-016
		,1.850433581e-016
		,1.843595395e-016
		,1.837428826e-016
		,1.813521515e-016
		,1.960029511e-016
		,2.011659642e-016
		,2.032135462e-016
		,2.048097153e-016
		,1.713625194e-016
		,1.721560068e-016
		,1.731733163e-016
		,1.744897450e-016
		,1.761786419e-016
		,1.782735071e-016
		,1.807772849e-016
		,1.839060335e-016
		,1.880389129e-016
		,1.932336952e-016
		,2.011276668e-016
		,2.059367796e-016
		,2.113093210e-016
		,2.219376264e-016
		,2.211984581e-016
		,2.250021488e-016
		,2.552883832e-016
		,2.904426566e-016
		,3.159354472e-016
		,3.517745489e-016
		,3.757445135e-016
		,3.895798011e-016
		,3.931223308e-016
		,3.919242959e-016
		,3.971954967e-016
		,4.036375503e-016
		,4.111484859e-016
		,4.178401030e-016
		,4.214789483e-016
		,4.245004355e-016
		,4.276057191e-016
		,4.311937026e-016
		,4.353902387e-016
		,4.398603181e-016
		,4.440512357e-016
		,4.476502281e-016
		,4.506615126e-016
		,4.532195046e-016
		,4.554174303e-016
		,4.572771047e-016
		,4.588397548e-016
		,1.699436823e-016
		,1.703383128e-016
		,1.708038874e-016
		,1.713694405e-016
		,1.720761956e-016
		,1.729818241e-016
		,1.741720719e-016
		,1.757472294e-016
		,1.778126077e-016
		,1.806467264e-016
		,1.844753372e-016
		,1.891967157e-016
		,1.967680721e-016
		,2.012789681e-016
		,2.106453425e-016
		,2.198014528e-016
		,2.191369368e-016
		,2.432468293e-016
		,2.749160923e-016
		,3.092735380e-016
		,3.442855447e-016
		,3.743354073e-016
		,3.898112917e-016
		,3.950896874e-016
		,4.015526238e-016
		,4.055991045e-016
		,4.065919949e-016
		,4.103896287e-016
		,4.143554745e-016
		,4.180698240e-016
		,4.217455584e-016
		,4.255863057e-016
		,4.298946698e-016
		,4.347876552e-016
		,4.398505596e-016
		,4.444703813e-016
		,4.483337094e-016
		,4.514574199e-016
		,4.539889216e-016
		,4.560792549e-016
		,4.578465243e-016
		,1.692199902e-016
		,1.695103791e-016
		,1.698259978e-016
		,1.701757133e-016
		,1.705721218e-016
		,1.710324282e-016
		,1.715817911e-016
		,1.722578431e-016
		,1.731143458e-016
		,1.742295995e-016
		,1.757382923e-016
		,1.779024374e-016
		,1.811066425e-016
		,1.857285807e-016
		,1.917304281e-016
		,1.979050478e-016
		,2.083613821e-016
		,2.145259593e-016
		,2.348221019e-016
		,2.680541454e-016
		,3.093501013e-016
		,3.430626747e-016
		,3.670299193e-016
		,3.880624996e-016
		,4.015092857e-016
		,4.095693884e-016
		,4.123975834e-016
		,4.153834006e-016
		,4.174289909e-016
		,4.174723967e-016
		,4.184801340e-016
		,4.213056079e-016
		,4.250083627e-016
		,4.295245252e-016
		,4.347044757e-016
		,4.399296783e-016
		,4.445937903e-016
		,4.484792812e-016
		,4.516594257e-016
		,4.543088203e-016
		,4.566584993e-016
		,1.686701037e-016
		,1.689328873e-016
		,1.692129114e-016
		,1.695120252e-016
		,1.698348265e-016
		,1.701879210e-016
		,1.705799423e-016
		,1.710218964e-016
		,1.715285311e-016
		,1.721213130e-016
		,1.728347325e-016
		,1.737281738e-016
		,1.748897203e-016
		,1.765189467e-016
		,1.789191513e-016
		,1.829456017e-016
		,1.882049376e-016
		,1.978367452e-016
		,2.157576556e-016
		,2.395647771e-016
		,2.770821285e-016
		,3.157285763e-016
		,3.468619073e-016
		,3.671000934e-016
		,3.823203773e-016
		,3.937535766e-016
		,4.022069238e-016
		,4.086062270e-016
		,4.135074654e-016
		,4.167897229e-016
		,4.187156615e-016
		,4.213684883e-016
		,4.244690333e-016
		,4.279607853e-016
		,4.321234619e-016
		,4.369108507e-016
		,4.415908099e-016
		,4.458411177e-016
		,4.494095634e-016
		,4.521966158e-016
		,4.544502237e-016
		,1.682171091e-016
		,1.684319296e-016
		,1.686939619e-016
		,1.689825375e-016
		,1.692933066e-016
		,1.696278094e-016
		,1.699899628e-016
		,1.703849329e-016
		,1.708190230e-016
		,1.713003653e-016
		,1.718407108e-016
		,1.724590335e-016
		,1.731885696e-016
		,1.740915335e-016
		,1.752933460e-016
		,1.770694490e-016
		,1.800714652e-016
		,1.858666628e-016
		,1.977798249e-016
		,2.202235524e-016
		,2.529886810e-016
		,2.880011255e-016
		,3.183365458e-016
		,3.428923538e-016
		,3.621394592e-016
		,3.765262968e-016
		,3.870402445e-016
		,3.948237328e-016
		,4.007678302e-016
		,4.054835388e-016
		,4.094035467e-016
		,4.128910442e-016
		,4.163345523e-016
		,4.201882159e-016
		,4.248279404e-016
		,4.301917098e-016
		,4.356775344e-016
		,4.406330472e-016
		,4.447783007e-016
		,4.481496425e-016
		,4.508969987e-016
		,1.683940887e-016
		,1.681528562e-016
		,1.682633745e-016
		,1.685064407e-016
		,1.688078195e-016
		,1.691446462e-016
		,1.695115302e-016
		,1.699092233e-016
		,1.703413073e-016
		,1.708135259e-016
		,1.713352231e-016
		,1.719206294e-016
		,1.726032417e-016
		,1.734584685e-016
		,1.745935801e-016
		,1.761873558e-016
		,1.789560284e-016
		,1.840917825e-016
		,1.940352407e-016
		,2.111592359e-016
		,2.333001922e-016
		,2.572899991e-016
		,2.919438642e-016
		,3.212245002e-016
		,3.442226986e-016
		,3.604219108e-016
		,3.716325183e-016
		,3.790522041e-016
		,3.862745249e-016
		,3.932401795e-016
		,3.976788845e-016
		,4.009107312e-016
		,4.043346824e-016
		,4.081712556e-016
		,4.126889183e-016
		,4.180522894e-016
		,4.239243508e-016
		,4.297205010e-016
		,4.352283358e-016
		,4.406561261e-016
		,4.453073336e-016
		,1.734314822e-016
		,1.698306571e-016
		,1.685414927e-016
		,1.682819043e-016
		,1.684187804e-016
		,1.687101684e-016
		,1.690738575e-016
		,1.694841323e-016
		,1.699355688e-016
		,1.704316434e-016
		,1.709803203e-016
		,1.716110768e-016
		,1.723716599e-016
		,1.733288090e-016
		,1.745351925e-016
		,1.765055554e-016
		,1.799535587e-016
		,1.844234866e-016
		,1.933729815e-016
		,2.054823617e-016
		,2.251250043e-016
		,2.425390295e-016
		,2.685420094e-016
		,2.928845334e-016
		,3.227912058e-016
		,3.408756500e-016
		,3.571360493e-016
		,3.683543630e-016
		,3.753013651e-016
		,3.786580900e-016
		,3.821249732e-016
		,3.875135875e-016
		,3.950479534e-016
		,3.994019319e-016
		,4.037790524e-016
		,4.089593888e-016
		,4.147153612e-016
		,4.204626068e-016
		,4.256415236e-016
		,4.300236282e-016
		,4.336496718e-016
		,1.992623919e-016
		,1.828208613e-016
		,1.742399068e-016
		,1.702556929e-016
		,1.688396549e-016
		,1.685731426e-016
		,1.687559093e-016
		,1.691202965e-016
		,1.695753978e-016
		,1.700988225e-016
		,1.707066476e-016
		,1.714346310e-016
		,1.723376259e-016
		,1.734294641e-016
		,1.751214872e-016
		,1.777442908e-016
		,1.808711751e-016
		,1.853559350e-016
		,1.909135587e-016
		,2.007546304e-016
		,2.109733958e-016
		,2.269503212e-016
		,2.447434853e-016
		,2.779392913e-016
		,2.962048488e-016
		,3.168909802e-016
		,3.398709377e-016
		,3.516874175e-016
		,3.612101170e-016
		,3.699140726e-016
		,3.756678852e-016
		,3.795593512e-016
		,3.824186315e-016
		,3.851335791e-016
		,3.915228437e-016
		,4.023598117e-016
		,4.093807600e-016
		,4.157520572e-016
		,4.214318126e-016
		,4.261414859e-016
		,4.297842822e-016
		,2.735310211e-016
		,2.367342162e-016
		,2.046255521e-016
		,1.852356251e-016
		,1.753871530e-016
		,1.709305015e-016
		,1.693760953e-016
		,1.691174514e-016
		,1.693786539e-016
		,1.698799468e-016
		,1.705525033e-016
		,1.713953592e-016
		,1.723889502e-016
		,1.738923418e-016
		,1.761998194e-016
		,1.790374575e-016
		,1.822282159e-016
		,1.880286402e-016
		,1.934874807e-016
		,1.971747743e-016
		,2.041327034e-016
		,2.082025262e-016
		,2.299399671e-016
		,2.445116451e-016
		,2.703027324e-016
		,3.012337741e-016
		,3.157926916e-016
		,3.289111072e-016
		,3.451982629e-016
		,3.549696251e-016
		,3.627035621e-016
		,3.693023892e-016
		,3.737773717e-016
		,3.766891892e-016
		,3.783743317e-016
		,3.801147662e-016
		,3.842359417e-016
		,3.965070548e-016
		,4.104143714e-016
		,4.178082968e-016
		,4.232566352e-016
		,3.358545380e-016
		,3.137087223e-016
		,2.841291292e-016
		,2.472082783e-016
		,2.117172480e-016
		,1.886517643e-016
		,1.770541650e-016
		,1.719847277e-016
		,1.702987189e-016
		,1.701556929e-016
		,1.706949280e-016
		,1.715071814e-016
		,1.728178124e-016
		,1.748349159e-016
		,1.775022157e-016
		,1.796524644e-016
		,1.844812283e-016
		,1.897642064e-016
		,1.937107365e-016
		,1.978239769e-016
		,2.001520295e-016
		,2.081319244e-016
		,2.157913551e-016
		,2.304740472e-016
		,2.445173162e-016
		,2.563060886e-016
		,2.773411928e-016
		,3.040107378e-016
		,3.210708283e-016
		,3.341581501e-016
		,3.455150498e-016
		,3.505338626e-016
		,3.554148776e-016
		,3.612007824e-016
		,3.659511437e-016
		,3.700267785e-016
		,3.740879190e-016
		,3.784235466e-016
		,3.831491684e-016
		,3.914317029e-016
		,4.094267798e-016
		,3.587964288e-016
		,3.435015859e-016
		,3.230337108e-016
		,2.952586194e-016
		,2.591482271e-016
		,2.210093960e-016
		,1.936198235e-016
		,1.796402663e-016
		,1.738472301e-016
		,1.720911763e-016
		,1.723682206e-016
		,1.738765405e-016
		,1.763608197e-016
		,1.782836268e-016
		,1.812467409e-016
		,1.866390614e-016
		,1.910755291e-016
		,1.946333890e-016
		,1.953880245e-016
		,1.992354158e-016
		,2.030835911e-016
		,2.108842750e-016
		,2.171406442e-016
		,2.377221370e-016
		,2.500218063e-016
		,2.561846558e-016
		,2.749986960e-016
		,3.013069483e-016
		,3.121805045e-016
		,3.169036713e-016
		,3.280521942e-016
		,3.393497355e-016
		,3.460302019e-016
		,3.519081813e-016
		,3.577816710e-016
		,3.618381575e-016
		,3.631110164e-016
		,3.581856059e-016
		,3.350735691e-016
		,3.620833679e-016
		,3.735945698e-016
		,3.900940630e-016
		,3.833998997e-016
		,3.750903575e-016
		,3.645304743e-016
		,3.507456162e-016
		,3.322086868e-016
		,3.067227211e-016
		,2.724483724e-016
		,2.330567488e-016
		,2.011255910e-016
		,1.839967756e-016
		,1.775399272e-016
		,1.767052343e-016
		,1.780755762e-016
		,1.792089995e-016
		,1.838349298e-016
		,1.887193421e-016
		,1.915753787e-016
		,1.941611455e-016
		,1.962219003e-016
		,1.957172160e-016
		,2.035148602e-016
		,2.056949038e-016
		,2.144346148e-016
		,2.229256739e-016
		,2.370897638e-016
		,2.477631016e-016
		,2.563334313e-016
		,2.668401947e-016
		,2.841821641e-016
		,3.046850333e-016
		,3.150995439e-016
		,3.241698919e-016
		,3.363037388e-016
		,3.455849629e-016
		,3.518873815e-016
		,3.581286861e-016
		,3.650075963e-016
		,3.711091801e-016
		,3.757466936e-016
		,3.787656338e-016
		,4.021989200e-016
		,3.979686552e-016
		,3.929271358e-016
		,3.868255197e-016
		,3.791917462e-016
		,3.696062011e-016
		,3.571101782e-016
		,3.404936374e-016
		,3.177064244e-016
		,2.863623911e-016
		,2.478577858e-016
		,2.128224760e-016
		,1.924578333e-016
		,1.833367798e-016
		,1.830007526e-016
		,1.865776630e-016
		,1.904867322e-016
		,1.921641050e-016
		,1.938227636e-016
		,1.945497738e-016
		,1.961417981e-016
		,1.996700358e-016
		,2.040906180e-016
		,2.106041883e-016
		,2.195746814e-016
		,2.237074798e-016
		,2.360284704e-016
		,2.467056206e-016
		,2.496022547e-016
		,2.545631640e-016
		,2.697882782e-016
		,2.977584753e-016
		,3.106157996e-016
		,3.190647409e-016
		,3.280261433e-016
		,3.395313070e-016
		,3.473450855e-016
		,3.537631002e-016
		,3.604877593e-016
		,3.675660609e-016
		,3.733283598e-016
		,4.102990570e-016
		,4.073994735e-016
		,4.040553661e-016
		,4.001674708e-016
		,3.955675649e-016
		,3.899952742e-016
		,3.831604517e-016
		,3.744352062e-016
		,3.632916056e-016
		,3.481088807e-016
		,3.274936201e-016
		,2.984406194e-016
		,2.590487840e-016
		,2.217410142e-016
		,1.999101664e-016
		,1.932716150e-016
		,1.923277585e-016
		,1.931729382e-016
		,1.943424007e-016
		,1.943684600e-016
		,1.950628570e-016
		,1.977467617e-016
		,2.005929094e-016
		,2.091621310e-016
		,2.148463670e-016
		,2.179456292e-016
		,2.245674778e-016
		,2.344564505e-016
		,2.391081865e-016
		,2.448754188e-016
		,2.503687004e-016
		,2.621105842e-016
		,2.794685130e-016
		,3.027114722e-016
		,3.111177427e-016
		,3.181530986e-016
		,3.278569203e-016
		,3.378138821e-016
		,3.445677053e-016
		,3.509207334e-016
		,3.580519340e-016
		,4.182367938e-016
		,4.161545619e-016
		,4.137831096e-016
		,4.105961825e-016
		,4.075184614e-016
		,4.033584284e-016
		,3.986680260e-016
		,3.919159791e-016
		,3.854165984e-016
		,3.769755930e-016
		,3.658261890e-016
		,3.505028420e-016
		,3.281352415e-016
		,2.958610321e-016
		,2.558777291e-016
		,2.220736435e-016
		,2.040680115e-016
		,1.974349272e-016
		,1.956859531e-016
		,1.958885847e-016
		,1.942939811e-016
		,1.951192128e-016
		,1.995802697e-016
		,2.060907208e-016
		,2.118292172e-016
		,2.134515544e-016
		,2.177858308e-016
		,2.208714448e-016
		,2.285594738e-016
		,2.376651489e-016
		,2.432464797e-016
		,2.463047917e-016
		,2.531557645e-016
		,2.604880382e-016
		,2.873900996e-016
		,2.996115198e-016
		,3.056750884e-016
		,3.123579549e-016
		,3.234098723e-016
		,3.323285903e-016
		,3.389078490e-016
		,4.244560647e-016
		,4.228040418e-016
		,4.209947304e-016
		,4.189470840e-016
		,4.164324241e-016
		,4.141600065e-016
		,4.111715949e-016
		,4.075697634e-016
		,4.030996123e-016
		,3.974722897e-016
		,3.899537391e-016
		,3.795791345e-016
		,3.647477177e-016
		,3.413482066e-016
		,3.105157177e-016
		,2.726531220e-016
		,2.381992468e-016
		,2.163958864e-016
		,2.061063179e-016
		,2.014605683e-016
		,1.984671207e-016
		,1.900596815e-016
		,1.981176040e-016
		,2.044693072e-016
		,2.080327786e-016
		,2.101499169e-016
		,2.140524380e-016
		,2.140471813e-016
		,2.169932253e-016
		,2.263230670e-016
		,2.347280048e-016
		,2.400561270e-016
		,2.424810011e-016
		,2.446708239e-016
		,2.492738640e-016
		,2.563028771e-016
		,2.831986632e-016
		,2.911610932e-016
		,2.977786093e-016
		,3.071605749e-016
		,3.190219424e-016
		,4.319329651e-016
		,4.301724876e-016
		,4.285277992e-016
		,4.267962179e-016
		,4.248751944e-016
		,4.227211685e-016
		,4.202590088e-016
		,4.173595794e-016
		,4.138584986e-016
		,4.095835815e-016
		,4.039585468e-016
		,3.961632799e-016
		,3.841489507e-016
		,3.702545568e-016
		,3.446486182e-016
		,3.135989023e-016
		,2.798906793e-016
		,2.504239906e-016
		,2.300267944e-016
		,2.170072306e-016
		,2.110457117e-016
		,1.956198946e-016
		,1.975104424e-016
		,2.034023942e-016
		,2.041023316e-016
		,2.050358516e-016
		,2.079466124e-016
		,2.101626396e-016
		,2.136660089e-016
		,2.166801749e-016
		,2.227064911e-016
		,2.303620366e-016
		,2.340097159e-016
		,2.349616236e-016
		,2.349962436e-016
		,2.387369511e-016
		,2.395927383e-016
		,2.554002866e-016
		,2.749605564e-016
		,2.839211511e-016
		,2.946142896e-016
		,4.369479453e-016
		,4.354326115e-016
		,4.337991671e-016
		,4.320324720e-016
		,4.300875519e-016
		,4.279318674e-016
		,4.255145188e-016
		,4.227293708e-016
		,4.194703268e-016
		,4.154786958e-016
		,4.081321349e-016
		,4.012546590e-016
		,3.869510936e-016
		,3.669657363e-016
		,3.447305188e-016
		,3.164236278e-016
		,2.879089097e-016
		,2.599310049e-016
		,2.419266260e-016
		,2.338529277e-016
		,2.253760839e-016
		,2.120447261e-016
		,2.095266617e-016
		,2.069333763e-016
		,2.051273055e-016
		,2.046637635e-016
		,2.033397540e-016
		,2.042203960e-016
		,2.068723472e-016
		,2.093610453e-016
		,2.149026788e-016
		,2.168755074e-016
		,2.240126620e-016
		,2.263224752e-016
		,2.262584978e-016
		,2.259006978e-016
		,2.271982820e-016
		,2.314197044e-016
		,2.338259332e-016
		,2.590476286e-016
		,2.729927220e-016
		,4.446709429e-016
		,4.432185832e-016
		,4.416761844e-016
		,4.400430284e-016
		,4.383072860e-016
		,4.364463830e-016
		,4.342162506e-016
		,4.311154989e-016
		,4.287743191e-016
		,4.256989461e-016
		,4.176436821e-016
		,4.106901882e-016
		,4.050242463e-016
		,3.904409691e-016
		,3.732153579e-016
		,3.503300847e-016
		,3.207603656e-016
		,2.883043310e-016
		,2.679842727e-016
		,2.595393274e-016
		,2.480030692e-016
		,2.300705165e-016
		,2.307239434e-016
		,2.232702360e-016
		,2.144796784e-016
		,2.094890554e-016
		,2.044628747e-016
		,2.040883734e-016
		,2.053116205e-016
		,2.071513952e-016
		,2.068205516e-016
		,2.051473041e-016
		,2.026328914e-016
		,2.143255733e-016
		,2.177826582e-016
		,2.186226107e-016
		,2.185971287e-016
		,2.211976247e-016
		,2.264434171e-016
		,2.286111504e-016
		,2.338096732e-016
		,4.545022254e-016
		,4.534182581e-016
		,4.522428892e-016
		,4.510072591e-016
		,4.497343103e-016
		,4.484795548e-016
		,4.472711319e-016
		,4.442878074e-016
		,4.423364259e-016
		,4.426422336e-016
		,4.402454957e-016
		,4.373851035e-016
		,4.316135058e-016
		,4.223072141e-016
		,4.076993181e-016
		,3.923085074e-016
		,3.725611649e-016
		,3.493851695e-016
		,3.183267743e-016
		,2.924249791e-016
		,2.802671144e-016
		,2.510008363e-016
		,2.481506912e-016
		,2.445784547e-016
		,2.336259808e-016
		,2.240868203e-016
		,2.163349171e-016
		,2.116562903e-016
		,2.075688684e-016
		,2.053931976e-016
		,2.052016833e-016
		,2.034272828e-016
		,2.014503299e-016
		,1.978897391e-016
		,1.953618917e-016
		,1.987967123e-016
		,2.126592612e-016
		,2.167805464e-016
		,2.180407803e-016
		,2.204784905e-016
		,2.248018322e-016
		,4.615716122e-016
		,4.613088242e-016
		,4.609265573e-016
		,4.605301775e-016
		,4.575452762e-016
		,4.576530877e-016
		,4.581000906e-016
		,4.582965899e-016
		,4.583319964e-016
		,4.588331088e-016
		,4.567396026e-016
		,4.598153034e-016
		,4.550370371e-016
		,4.460639965e-016
		,4.328465544e-016
		,4.169968043e-016
		,3.977041852e-016
		,3.753086433e-016
		,3.487175112e-016
		,3.110670996e-016
		,3.007148596e-016
		,2.863863669e-016
		,2.586999997e-016
		,2.627954151e-016
		,2.544688609e-016
		,2.437131925e-016
		,2.365623689e-016
		,2.290842052e-016
		,2.211239166e-016
		,2.129899560e-016
		,2.062098850e-016
		,2.026231089e-016
		,1.986208223e-016
		,1.962963728e-016
		,1.941829622e-016
		,1.908901841e-016
		,1.977956094e-016
		,1.970212876e-016
		,2.012250540e-016
		,2.144063589e-016
		,2.163158482e-016
		,1.717198384e-016
		,1.725370247e-016
		,1.735852010e-016
		,1.749324088e-016
		,1.766405768e-016
		,1.787377103e-016
		,1.812472679e-016
		,1.844207520e-016
		,1.885310452e-016
		,1.936901454e-016
		,2.016440026e-016
		,2.061140179e-016
		,2.111899168e-016
		,2.222201079e-016
		,2.216143898e-016
		,2.250131116e-016
		,2.488984105e-016
		,2.880494873e-016
		,3.149464683e-016
		,3.452779185e-016
		,3.702099003e-016
		,3.855315909e-016
		,3.918364520e-016
		,3.916733435e-016
		,3.969590962e-016
		,4.028933913e-016
		,4.083604141e-016
		,4.150884331e-016
		,4.209583244e-016
		,4.243387636e-016
		,4.274364110e-016
		,4.309489772e-016
		,4.351127045e-016
		,4.396482187e-016
		,4.439626003e-016
		,4.476559586e-016
		,4.506753159e-016
		,4.531479410e-016
		,4.552348673e-016
		,4.570683797e-016
		,4.587135654e-016
		,1.702577289e-016
		,1.706629152e-016
		,1.711445117e-016
		,1.717327559e-016
		,1.724698437e-016
		,1.734142657e-016
		,1.746469266e-016
		,1.762564851e-016
		,1.783672894e-016
		,1.812425490e-016
		,1.850196212e-016
		,1.897759126e-016
		,1.974152427e-016
		,2.016400035e-016
		,2.108648244e-016
		,2.201816617e-016
		,2.189998341e-016
		,2.383420339e-016
		,2.730718769e-016
		,3.033369682e-016
		,3.403740218e-016
		,3.716662892e-016
		,3.891713427e-016
		,3.938688949e-016
		,3.985288963e-016
		,4.020178529e-016
		,4.059863509e-016
		,4.105227385e-016
		,4.145213961e-016
		,4.180273951e-016
		,4.213890449e-016
		,4.250145109e-016
		,4.292210283e-016
		,4.340596189e-016
		,4.391623684e-016
		,4.439124482e-016
		,4.479279914e-016
		,4.511799344e-016
		,4.538052251e-016
		,4.559595074e-016
		,4.577677052e-016
		,1.695273059e-016
		,1.698254617e-016
		,1.701527063e-016
		,1.705184677e-016
		,1.709358233e-016
		,1.714225366e-016
		,1.720033963e-016
		,1.727151565e-016
		,1.736080865e-016
		,1.747612001e-016
		,1.763101600e-016
		,1.785137385e-016
		,1.817495449e-016
		,1.863859644e-016
		,1.922618923e-016
		,1.982230482e-016
		,2.086614989e-016
		,2.148402984e-016
		,2.328750722e-016
		,2.644036874e-016
		,3.065690360e-016
		,3.400007463e-016
		,3.650959307e-016
		,3.850846014e-016
		,4.002324098e-016
		,4.082062767e-016
		,4.112039138e-016
		,4.145829452e-016
		,4.163246363e-016
		,4.163326681e-016
		,4.181490624e-016
		,4.213959671e-016
		,4.251826875e-016
		,4.295667535e-016
		,4.345498074e-016
		,4.396564904e-016
		,4.442923371e-016
		,4.481875651e-016
		,4.513753282e-016
		,4.539990986e-016
		,4.562038109e-016
		,1.689824966e-016
		,1.692541552e-016
		,1.695466637e-016
		,1.698621545e-016
		,1.702052466e-016
		,1.705821884e-016
		,1.710007827e-016
		,1.714708419e-016
		,1.720055171e-016
		,1.726249029e-016
		,1.733629572e-016
		,1.742788682e-016
		,1.754650071e-016
		,1.771278854e-016
		,1.795647203e-016
		,1.836051854e-016
		,1.889118095e-016
		,1.984497798e-016
		,2.157350065e-016
		,2.381819098e-016
		,2.747759272e-016
		,3.138365491e-016
		,3.452177511e-016
		,3.667821023e-016
		,3.822049341e-016
		,3.936528724e-016
		,4.021041370e-016
		,4.084955887e-016
		,4.133545311e-016
		,4.164648726e-016
		,4.183367729e-016
		,4.209813780e-016
		,4.240265821e-016
		,4.274600648e-016
		,4.317067262e-016
		,4.367121251e-016
		,4.415120900e-016
		,4.455484877e-016
		,4.488671418e-016
		,4.517508133e-016
		,4.542837738e-016
		,1.685384203e-016
		,1.687649880e-016
		,1.690419982e-016
		,1.693491044e-016
		,1.696817244e-016
		,1.700406086e-016
		,1.704283437e-016
		,1.708484121e-016
		,1.713054993e-016
		,1.718067668e-016
		,1.723641970e-016
		,1.729985298e-016
		,1.737463669e-016
		,1.746748782e-016
		,1.759163649e-016
		,1.777562684e-016
		,1.808610311e-016
		,1.868131454e-016
		,1.989154619e-016
		,2.214421524e-016
		,2.540302777e-016
		,2.887260351e-016
		,3.188034042e-016
		,3.431971369e-016
		,3.623464652e-016
		,3.766731810e-016
		,3.871490346e-016
		,3.949073932e-016
		,4.008341826e-016
		,4.055374977e-016
		,4.094483414e-016
		,4.129288937e-016
		,4.163670460e-016
		,4.202165196e-016
		,4.248528746e-016
		,4.302137936e-016
		,4.356971166e-016
		,4.406504510e-016
		,4.447938498e-016
		,4.481636277e-016
		,4.509096608e-016
		,1.687188921e-016
		,1.684978142e-016
		,1.686280567e-016
		,1.688928139e-016
		,1.692180498e-016
		,1.695799652e-016
		,1.699716484e-016
		,1.703920520e-016
		,1.708436257e-016
		,1.713320321e-016
		,1.718679368e-016
		,1.724692319e-016
		,1.731712749e-016
		,1.740570660e-016
		,1.752506746e-016
		,1.769411941e-016
		,1.798203486e-016
		,1.853210752e-016
		,1.956923670e-016
		,2.137065408e-016
		,2.362294208e-016
		,2.608704366e-016
		,2.946069045e-016
		,3.229197584e-016
		,3.456989823e-016
		,3.617463006e-016
		,3.730723386e-016
		,3.810574020e-016
		,3.876200270e-016
		,3.939162985e-016
		,3.983163295e-016
		,4.020926514e-016
		,4.054429694e-016
		,4.087902546e-016
		,4.132214989e-016
		,4.185895569e-016
		,4.244015081e-016
		,4.300402103e-016
		,4.352612382e-016
		,4.403560750e-016
		,4.450724089e-016
		,1.737025139e-016
		,1.701654363e-016
		,1.689156648e-016
		,1.686863156e-016
		,1.688506873e-016
		,1.691680538e-016
		,1.695554443e-016
		,1.699861722e-016
		,1.704545181e-016
		,1.709654183e-016
		,1.715281127e-016
		,1.721748416e-016
		,1.729634097e-016
		,1.739724601e-016
		,1.752466166e-016
		,1.773256049e-016
		,1.810654823e-016
		,1.859841098e-016
		,1.953702557e-016
		,2.086480985e-016
		,2.289119028e-016
		,2.475258578e-016
		,2.726140273e-016
		,2.967198599e-016
		,3.267548837e-016
		,3.457254414e-016
		,3.594678835e-016
		,3.696705997e-016
		,3.769210237e-016
		,3.819871227e-016
		,3.847827517e-016
		,3.882682211e-016
		,3.958048307e-016
		,4.004869780e-016
		,4.050681539e-016
		,4.104418926e-016
		,4.162747775e-016
		,4.219532001e-016
		,4.269775182e-016
		,4.311858675e-016
		,4.346462707e-016
		,1.990531095e-016
		,1.829740799e-016
		,1.745555563e-016
		,1.706516129e-016
		,1.692826737e-016
		,1.690484570e-016
		,1.692557950e-016
		,1.696396458e-016
		,1.701113399e-016
		,1.706479284e-016
		,1.712724641e-016
		,1.720272299e-016
		,1.729856635e-016
		,1.741337649e-016
		,1.758983478e-016
		,1.787329985e-016
		,1.823028726e-016
		,1.868636504e-016
		,1.931110746e-016
		,2.038530232e-016
		,2.156061095e-016
		,2.308722279e-016
		,2.497866923e-016
		,2.844262749e-016
		,3.042193968e-016
		,3.205923605e-016
		,3.425818506e-016
		,3.564982195e-016
		,3.658369297e-016
		,3.717592632e-016
		,3.771943302e-016
		,3.810753300e-016
		,3.839980961e-016
		,3.868000574e-016
		,3.923583266e-016
		,4.038873320e-016
		,4.117550192e-016
		,4.182743221e-016
		,4.239543846e-016
		,4.287300668e-016
		,4.326536302e-016
		,2.725235865e-016
		,2.359296125e-016
		,2.043495737e-016
		,1.854006869e-016
		,1.757570325e-016
		,1.713907923e-016
		,1.698815476e-016
		,1.696497049e-016
		,1.699271656e-016
		,1.704473870e-016
		,1.711460708e-016
		,1.720421817e-016
		,1.730911002e-016
		,1.746563551e-016
		,1.771295124e-016
		,1.803778640e-016
		,1.835886882e-016
		,1.899756247e-016
		,1.961426848e-016
		,2.001421669e-016
		,2.084070067e-016
		,2.127345457e-016
		,2.340172963e-016
		,2.519995557e-016
		,2.758184740e-016
		,3.063248100e-016
		,3.236977720e-016
		,3.353470714e-016
		,3.480637737e-016
		,3.573327218e-016
		,3.642815593e-016
		,3.705116851e-016
		,3.752658220e-016
		,3.788453024e-016
		,3.821161284e-016
		,3.856548543e-016
		,3.899252793e-016
		,3.988022392e-016
		,4.127164849e-016
		,4.201800714e-016
		,4.253227380e-016
		,3.350690941e-016
		,3.128289637e-016
		,2.831862527e-016
		,2.463837191e-016
		,2.113691954e-016
		,1.888067839e-016
		,1.774605787e-016
		,1.724902617e-016
		,1.708520875e-016
		,1.707455219e-016
		,1.713401074e-016
		,1.722185973e-016
		,1.735617057e-016
		,1.757162941e-016
		,1.786710145e-016
		,1.811285380e-016
		,1.859026505e-016
		,1.919487215e-016
		,1.967409809e-016
		,2.010245291e-016
		,2.039918252e-016
		,2.121164835e-016
		,2.215071489e-016
		,2.373923109e-016
		,2.497354555e-016
		,2.648622559e-016
		,2.911373097e-016
		,3.053317703e-016
		,3.202749601e-016
		,3.358324161e-016
		,3.486438294e-016
		,3.559880513e-016
		,3.611127608e-016
		,3.647927257e-016
		,3.677713981e-016
		,3.718145031e-016
		,3.763923512e-016
		,3.811984788e-016
		,3.860310100e-016
		,3.924279845e-016
		,4.088811670e-016
		,3.700431487e-016
		,3.582583159e-016
		,3.428537994e-016
		,3.222745303e-016
		,2.944187692e-016
		,2.583472517e-016
		,2.205826281e-016
		,1.937287677e-016
		,1.800725972e-016
		,1.744383217e-016
		,1.727871986e-016
		,1.731000770e-016
		,1.747346330e-016
		,1.774321213e-016
		,1.799046315e-016
		,1.823565044e-016
		,1.884466871e-016
		,1.936860771e-016
		,1.978129120e-016
		,1.988502124e-016
		,2.031130069e-016
		,2.061311991e-016
		,2.166488908e-016
		,2.218305258e-016
		,2.438161149e-016
		,2.589884715e-016
		,2.657643272e-016
		,2.841987741e-016
		,3.112361442e-016
		,3.240928809e-016
		,3.331590544e-016
		,3.406619803e-016
		,3.477058637e-016
		,3.538744026e-016
		,3.598566415e-016
		,3.665182574e-016
		,3.733691431e-016
		,3.791129404e-016
		,3.835275249e-016
		,3.862020050e-016
		,3.865772263e-016
		,3.898468113e-016
		,3.831145072e-016
		,3.747523976e-016
		,3.641270930e-016
		,3.502569856e-016
		,3.316115039e-016
		,3.060334631e-016
		,2.717567080e-016
		,2.326436799e-016
		,2.012741462e-016
		,1.845209906e-016
		,1.783122037e-016
		,1.777150758e-016
		,1.796120670e-016
		,1.804421184e-016
		,1.852115943e-016
		,1.907103512e-016
		,1.943467587e-016
		,1.978702070e-016
		,2.000682528e-016
		,1.990796060e-016
		,2.062720971e-016
		,2.114992099e-016
		,2.181932191e-016
		,2.286971927e-016
		,2.481263508e-016
		,2.560474275e-016
		,2.636371721e-016
		,2.777391814e-016
		,3.033581440e-016
		,3.186765443e-016
		,3.242645698e-016
		,3.323353682e-016
		,3.432834839e-016
		,3.539537481e-016
		,3.612913285e-016
		,3.681840544e-016
		,3.756546856e-016
		,3.832366741e-016
		,3.894306823e-016
		,3.939120645e-016
		,4.020829177e-016
		,3.978331818e-016
		,3.927732184e-016
		,3.866408972e-016
		,3.790449916e-016
		,3.694269341e-016
		,3.569349023e-016
		,3.401451070e-016
		,3.172655407e-016
		,2.859755209e-016
		,2.477299414e-016
		,2.132835910e-016
		,1.935417464e-016
		,1.848327148e-016
		,1.841776146e-016
		,1.883566266e-016
		,1.930392745e-016
		,1.948668738e-016
		,1.972893116e-016
		,1.996846176e-016
		,1.979909533e-016
		,2.031925184e-016
		,2.088673317e-016
		,2.144966293e-016
		,2.247782602e-016
		,2.341484059e-016
		,2.450366602e-016
		,2.556327290e-016
		,2.629340067e-016
		,2.699370079e-016
		,2.815916924e-016
		,3.095463070e-016
		,3.212930153e-016
		,3.302755875e-016
		,3.389451700e-016
		,3.506704294e-016
		,3.605725116e-016
		,3.684495644e-016
		,3.759099140e-016
		,3.832270471e-016
		,3.900769065e-016
		,4.102222427e-016
		,4.073114883e-016
		,4.039756022e-016
		,4.000882011e-016
		,3.954615854e-016
		,3.899097869e-016
		,3.830754824e-016
		,3.744117223e-016
		,3.632051666e-016
		,3.481848506e-016
		,3.275429159e-016
		,2.991334513e-016
		,2.604279864e-016
		,2.229326329e-016
		,2.014715585e-016
		,1.953061262e-016
		,1.952373756e-016
		,1.964534103e-016
		,1.977310220e-016
		,1.987042748e-016
		,1.976954657e-016
		,2.016147034e-016
		,2.043530708e-016
		,2.129207636e-016
		,2.207457716e-016
		,2.269946181e-016
		,2.326182402e-016
		,2.461599104e-016
		,2.550754440e-016
		,2.560424676e-016
		,2.594539156e-016
		,2.724549901e-016
		,2.973896841e-016
		,3.170923257e-016
		,3.264904551e-016
		,3.347401126e-016
		,3.444326144e-016
		,3.563750671e-016
		,3.656171118e-016
		,3.732019978e-016
		,3.798547259e-016
		,4.181791965e-016
		,4.161021433e-016
		,4.137649288e-016
		,4.111288893e-016
		,4.078154569e-016
		,4.039640033e-016
		,3.990151562e-016
		,3.933925666e-016
		,3.852962358e-016
		,3.768173195e-016
		,3.658735413e-016
		,3.504126897e-016
		,3.282516367e-016
		,2.973760441e-016
		,2.584249750e-016
		,2.246599106e-016
		,2.069547487e-016
		,2.011353595e-016
		,1.997097056e-016
		,1.993855171e-016
		,1.965141149e-016
		,2.003733020e-016
		,2.020544727e-016
		,2.102346027e-016
		,2.181357875e-016
		,2.225577094e-016
		,2.247720474e-016
		,2.334994692e-016
		,2.447166037e-016
		,2.478379447e-016
		,2.533146656e-016
		,2.577902604e-016
		,2.669756268e-016
		,2.789313673e-016
		,3.098046140e-016
		,3.203859924e-016
		,3.288239434e-016
		,3.372158512e-016
		,3.481524191e-016
		,3.588515811e-016
		,3.666679791e-016
		,4.243908634e-016
		,4.227599782e-016
		,4.209654239e-016
		,4.189755539e-016
		,4.164972025e-016
		,4.142171168e-016
		,4.112548142e-016
		,4.076727387e-016
		,4.033287814e-016
		,3.976068310e-016
		,3.902370722e-016
		,3.799237209e-016
		,3.648022409e-016
		,3.414908127e-016
		,3.120903611e-016
		,2.754720316e-016
		,2.414068551e-016
		,2.201458574e-016
		,2.095250673e-016
		,2.053412989e-016
		,2.011153609e-016
		,1.946216778e-016
		,2.008575851e-016
		,2.082177973e-016
		,2.154634808e-016
		,2.180896534e-016
		,2.225283439e-016
		,2.267817717e-016
		,2.291863659e-016
		,2.376616502e-016
		,2.463635474e-016
		,2.528258753e-016
		,2.571025082e-016
		,2.637080625e-016
		,2.696172936e-016
		,2.897219402e-016
		,3.099131400e-016
		,3.188660486e-016
		,3.271417398e-016
		,3.360909066e-016
		,3.466744173e-016
		,4.319472901e-016
		,4.301368722e-016
		,4.284986108e-016
		,4.267897481e-016
		,4.248921157e-016
		,4.227637919e-016
		,4.203022987e-016
		,4.174326509e-016
		,4.140149020e-016
		,4.096587634e-016
		,4.041500905e-016
		,3.964221809e-016
		,3.839630588e-016
		,3.693950323e-016
		,3.443931875e-016
		,3.153405704e-016
		,2.821591056e-016
		,2.529372524e-016
		,2.325768234e-016
		,2.206045618e-016
		,2.149738839e-016
		,1.991008420e-016
		,2.006647523e-016
		,2.081533085e-016
		,2.125115442e-016
		,2.124518763e-016
		,2.160151539e-016
		,2.229750882e-016
		,2.222039520e-016
		,2.259972942e-016
		,2.371237415e-016
		,2.452225991e-016
		,2.507710009e-016
		,2.539504766e-016
		,2.576027562e-016
		,2.637039256e-016
		,2.680398485e-016
		,2.952160101e-016
		,3.055211208e-016
		,3.128817024e-016
		,3.209153146e-016
		,4.370314491e-016
		,4.355273151e-016
		,4.338845505e-016
		,4.321187999e-016
		,4.301871026e-016
		,4.280405986e-016
		,4.256071153e-016
		,4.227496435e-016
		,4.193314158e-016
		,4.152037673e-016
		,4.076774685e-016
		,4.005770007e-016
		,3.861571537e-016
		,3.669544081e-016
		,3.421673469e-016
		,3.148483901e-016
		,2.880511146e-016
		,2.620495446e-016
		,2.441191949e-016
		,2.373664806e-016
		,2.317966719e-016
		,2.148137997e-016
		,2.120099701e-016
		,2.126058674e-016
		,2.141413675e-016
		,2.121264830e-016
		,2.147389563e-016
		,2.156092050e-016
		,2.151391789e-016
		,2.171548216e-016
		,2.235114923e-016
		,2.342974378e-016
		,2.424982492e-016
		,2.470620419e-016
		,2.492506061e-016
		,2.506912641e-016
		,2.547212683e-016
		,2.558526466e-016
		,2.674900446e-016
		,2.890595732e-016
		,2.979015855e-016
		,4.457226249e-016
		,4.443461622e-016
		,4.428669076e-016
		,4.412880292e-016
		,4.396057767e-016
		,4.378030301e-016
		,4.358288835e-016
		,4.336433110e-016
		,4.312319710e-016
		,4.285689144e-016
		,4.249276025e-016
		,4.195211359e-016
		,4.102615705e-016
		,3.970221341e-016
		,3.859824741e-016
		,3.691751756e-016
		,3.452635262e-016
		,3.193401787e-016
		,2.886160657e-016
		,2.691766209e-016
		,2.567895048e-016
		,2.330497937e-016
		,2.326777508e-016
		,2.283111406e-016
		,2.238171100e-016
		,2.177558728e-016
		,2.166365328e-016
		,2.131289616e-016
		,2.142679932e-016
		,2.178018326e-016
		,2.202359155e-016
		,2.216792603e-016
		,2.233273626e-016
		,2.275933935e-016
		,2.393397892e-016
		,2.425184000e-016
		,2.426072407e-016
		,2.433827918e-016
		,2.454447709e-016
		,2.459983697e-016
		,2.670125451e-016
		,4.540241897e-016
		,4.527584731e-016
		,4.514029023e-016
		,4.496095696e-016
		,4.475174229e-016
		,4.459138863e-016
		,4.442401474e-016
		,4.425124784e-016
		,4.408299186e-016
		,4.353986638e-016
		,4.305696209e-016
		,4.273878509e-016
		,4.167325267e-016
		,4.023098133e-016
		,3.864111690e-016
		,3.669376754e-016
		,3.423798519e-016
		,3.139700454e-016
		,2.921499932e-016
		,2.866738492e-016
		,2.809506485e-016
		,2.486413103e-016
		,2.519958403e-016
		,2.483904790e-016
		,2.410403600e-016
		,2.330973448e-016
		,2.270237280e-016
		,2.189174187e-016
		,2.172760415e-016
		,2.179868168e-016
		,2.192357719e-016
		,2.206468589e-016
		,2.215272459e-016
		,2.217651079e-016
		,2.272736497e-016
		,2.258078763e-016
		,2.188813044e-016
		,2.206532111e-016
		,2.326275399e-016
		,2.355546561e-016
		,2.372197432e-016
		,4.641989338e-016
		,4.636424309e-016
		,4.631052802e-016
		,4.623529918e-016
		,4.615825177e-016
		,4.607748278e-016
		,4.589362827e-016
		,4.568062240e-016
		,4.571552255e-016
		,4.575373705e-016
		,4.571219581e-016
		,4.535159675e-016
		,4.491275340e-016
		,4.377546244e-016
		,4.221401267e-016
		,4.062989582e-016
		,3.873820039e-016
		,3.666216037e-016
		,3.358755518e-016
		,3.081155301e-016
		,3.002621464e-016
		,2.761490034e-016
		,2.649285165e-016
		,2.681179690e-016
		,2.595050486e-016
		,2.510905798e-016
		,2.413470840e-016
		,2.362220155e-016
		,2.305399075e-016
		,2.257687953e-016
		,2.228111618e-016
		,2.203437387e-016
		,2.196065630e-016
		,2.190145559e-016
		,2.168756797e-016
		,2.212404470e-016
		,2.207427784e-016
		,2.181539545e-016
		,2.133504442e-016
		,2.044854498e-016
		,2.093274607e-016
		,1.720375374e-016
		,1.728822872e-016
		,1.739620453e-016
		,1.753383705e-016
		,1.770602623e-016
		,1.791774747e-016
		,1.817047614e-016
		,1.849056852e-016
		,1.889720604e-016
