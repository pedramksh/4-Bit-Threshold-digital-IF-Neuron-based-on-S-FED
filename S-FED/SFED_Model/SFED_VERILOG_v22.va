	,2.351852085e-004
	,2.354792291e-004
	,2.357692484e-004
	,2.360543175e-004
	,2.363341449e-004
	,2.366095103e-004
	,2.368813618e-004
	,2.371502833e-004
	,2.374165656e-004
	,2.376803594e-004
	,2.379417564e-004
	,2.382008255e-004
	,2.384576312e-004
	,2.387122414e-004
	,2.389647305e-004
	,2.392151793e-004
	,2.394636759e-004
	,2.397103077e-004
	,2.399551403e-004
	,2.401982106e-004
	,2.404395448e-004
	,2.406791732e-004
	,2.409171339e-004
	,2.411534639e-004
	,2.413881583e-004
	,2.416211657e-004
	,2.418527606e-004
	,2.420832696e-004
	,2.423125525e-004
	,2.425401451e-004
	,2.427657822e-004
	,2.429898150e-004
	,2.432124947e-004
	,2.434339198e-004
	,2.436544128e-004
	,2.438741474e-004
	,2.440932866e-004
	,2.443119692e-004
	,2.445301043e-004
	,2.447473243e-004
	,2.449632016e-004
	,2.451776102e-004
	,2.453909130e-004
	,2.456035741e-004
	,2.458158042e-004
	,2.460276939e-004
	,2.462393206e-004
	,2.464507323e-004
	,2.466619559e-004
	,2.468730346e-004
	,2.470840879e-004
	,2.472953339e-004
	,2.475068707e-004
	,2.477185804e-004
	,2.479303439e-004
	,2.481420578e-004
	,2.483536330e-004
	,2.485650191e-004
	,2.487762066e-004
	,2.489872192e-004
	,2.491981106e-004
	,2.494089701e-004
	,2.496199427e-004
	,2.498312548e-004
	,2.500430894e-004
	,2.502551049e-004
	,2.504654832e-004
	,2.506739109e-004
	,2.508825213e-004
	,2.510921080e-004
	,2.513030856e-004
	,2.515158893e-004
	,2.517310578e-004
	,2.519492867e-004
	,2.521714957e-004
	,2.523989150e-004
	,2.526331891e-004
	,2.528764888e-004
	,2.531315500e-004
	,2.534016691e-004
	,2.536909840e-004
	,-6.116742051e-004
	,-5.933209981e-004
	,-5.749324669e-004
	,-5.566615610e-004
	,-5.386705678e-004
	,-5.210083817e-004
	,-5.036498428e-004
	,-4.866115760e-004
	,-4.699106338e-004
	,-4.535096414e-004
	,-4.373204042e-004
	,-4.212304176e-004
	,-4.051790591e-004
	,-3.891381724e-004
	,-3.730360924e-004
	,-3.568260708e-004
	,-3.405823445e-004
	,-3.244430525e-004
	,-3.084990230e-004
	,-2.927516023e-004
	,-2.771685710e-004
	,-2.617493081e-004
	,-2.464971458e-004
	,-2.313907604e-004
	,-2.163941471e-004
	,-2.014786130e-004
	,-1.866516492e-004
	,-1.719441011e-004
	,-1.573848212e-004
	,-1.429841111e-004
	,-1.287316984e-004
	,-1.146217015e-004
	,-1.006788215e-004
	,-8.694687383e-005
	,-7.347611083e-005
	,-6.031867610e-005
	,-4.750562741e-005
	,-3.505170493e-005
	,-2.297337154e-005
	,-1.128754135e-005
	,1.301806138e-015
	,1.089143299e-005
	,2.138948403e-005
	,3.149537753e-005
	,4.121185138e-005
	,5.054677242e-005
	,5.951327446e-005
	,6.812741895e-005
	,7.640600748e-005
	,8.436531081e-005
	,9.202037835e-005
	,9.938474668e-005
	,1.064699444e-004
	,1.132848746e-004
	,1.198351080e-004
	,1.261216989e-004
	,1.321378885e-004
	,1.378622657e-004
	,1.432655781e-004
	,1.483549373e-004
	,1.531750624e-004
	,1.577636588e-004
	,1.621428043e-004
	,1.663257015e-004
	,1.703208749e-004
	,1.741336641e-004
	,1.777659629e-004
	,1.812141628e-004
	,1.844683924e-004
	,1.875276542e-004
	,1.904134494e-004
	,1.931483041e-004
	,1.957451716e-004
	,1.982114921e-004
	,2.005524174e-004
	,2.027721126e-004
	,2.048741997e-004
	,2.068617941e-004
	,2.087372316e-004
	,2.105014318e-004
	,2.121531147e-004
	,2.136905108e-004
	,2.151200634e-004
	,2.164590493e-004
	,2.177235767e-004
	,2.189235945e-004
	,2.200650560e-004
	,2.211518896e-004
	,2.221868420e-004
	,2.231715961e-004
	,2.241061934e-004
	,2.249871939e-004
	,2.258043822e-004
	,2.265458972e-004
	,2.272207921e-004
	,2.278508000e-004
	,2.284498468e-004
	,2.290251031e-004
	,2.295806437e-004
	,2.301190199e-004
	,2.306419555e-004
	,2.311507006e-004
	,2.316462250e-004
	,2.321293285e-004
	,2.326007132e-004
	,2.330610349e-004
	,2.335109358e-004
	,2.339510495e-004
	,2.343819822e-004
	,2.348042865e-004
	,2.352184362e-004
	,2.356247975e-004
	,2.360235672e-004
	,2.364146112e-004
	,2.367969588e-004
	,2.371669961e-004
	,2.375135532e-004
	,2.378279320e-004
	,2.381278572e-004
	,2.384248659e-004
	,2.387207287e-004
	,2.390152458e-004
	,2.393079262e-004
	,2.395981503e-004
	,2.398847333e-004
	,2.401650460e-004
	,2.404389995e-004
	,2.407097318e-004
	,2.409783421e-004
	,2.412448308e-004
	,2.415090499e-004
	,2.417709762e-004
	,2.420306288e-004
	,2.422880007e-004
	,2.425430293e-004
	,2.427955414e-004
	,2.430452044e-004
	,2.432918448e-004
	,2.435359431e-004
	,2.437781101e-004
	,2.440186585e-004
	,2.442577132e-004
	,2.444953260e-004
	,2.447315232e-004
	,2.449663235e-004
	,2.451997459e-004
	,2.454318147e-004
	,2.456625631e-004
	,2.458920337e-004
	,2.461202763e-004
	,2.463473438e-004
	,2.465732880e-004
	,2.467981365e-004
	,2.470218358e-004
	,2.472441820e-004
	,2.474648225e-004
	,2.476836428e-004
	,2.479010960e-004
	,2.481176611e-004
	,2.483336063e-004
	,2.485492102e-004
	,2.487646754e-004
	,2.489799842e-004
	,2.491949464e-004
	,2.494088687e-004
	,2.496208000e-004
	,2.498308978e-004
	,2.500390875e-004
	,2.502456949e-004
	,2.504513798e-004
	,2.506566055e-004
	,2.508616282e-004
	,2.510666495e-004
	,2.512718030e-004
	,2.514770064e-004
	,2.516820585e-004
	,2.518868187e-004
	,2.520912253e-004
	,2.522951596e-004
	,2.524984227e-004
	,2.527007535e-004
	,2.529017175e-004
	,2.531006217e-004
	,2.532966232e-004
	,2.534892613e-004
	,2.536789639e-004
	,2.538667673e-004
	,2.540537543e-004
	,2.542407254e-004
	,2.544280048e-004
	,2.546157148e-004
	,2.548039330e-004
	,2.549925909e-004
	,2.551811001e-004
	,2.553673851e-004
	,2.555518530e-004
	,2.557365970e-004
	,2.559222395e-004
	,2.561090771e-004
	,2.562974371e-004
	,2.564877809e-004
	,-6.266255693e-004
	,-6.079141672e-004
	,-5.892718186e-004
	,-5.708803985e-004
	,-5.528364977e-004
	,-5.351178289e-004
	,-5.176884226e-004
	,-5.005667571e-004
	,-4.837291741e-004
	,-4.670839130e-004
	,-4.505115017e-004
	,-4.339514522e-004
	,-4.173779662e-004
	,-4.007258308e-004
	,-3.839367975e-004
	,-3.670772221e-004
	,-3.502883369e-004
	,-3.336544387e-004
	,-3.171980809e-004
	,-3.009454993e-004
	,-2.849233423e-004
	,-2.691231713e-004
	,-2.535086615e-004
	,-2.380509609e-004
	,-2.227398182e-004
	,-2.075696708e-004
	,-1.925203505e-004
	,-1.775487399e-004
	,-1.626140099e-004
	,-1.477230822e-004
	,-1.329333489e-004
	,-1.183064494e-004
	,-1.038845713e-004
	,-8.971153897e-005
	,-7.584167411e-005
	,-6.230859942e-005
	,-4.912396385e-005
	,-3.629381232e-005
	,-2.382678642e-005
	,-1.172829896e-005
	,1.954457012e-016
	,1.135601755e-005
	,2.233542020e-005
	,3.293313746e-005
	,4.314832805e-005
	,5.298651822e-005
	,6.245709476e-005
	,7.157079961e-005
	,8.033850065e-005
	,8.877048747e-005
	,9.687578545e-005
	,1.046612022e-004
	,1.121297449e-004
	,1.192776069e-004
	,1.260878954e-004
	,1.325270479e-004
	,1.385816133e-004
	,1.442930939e-004
	,1.497098431e-004
	,1.548619620e-004
	,1.597678463e-004
	,1.644403374e-004
	,1.688895256e-004
	,1.731236279e-004
	,1.771496576e-004
	,1.809738208e-004
	,1.846017843e-004
	,1.880388834e-004
	,1.912902894e-004
	,1.943611374e-004
	,1.972566057e-004
	,1.999819234e-004
	,2.025422562e-004
	,2.049423558e-004
	,2.071856959e-004
	,2.092725709e-004
	,2.111976444e-004
	,2.129560634e-004
	,2.145653515e-004
	,2.160587581e-004
	,2.174593442e-004
	,2.187788341e-004
	,2.200234812e-004
	,2.211964999e-004
	,2.222967880e-004
	,2.233130701e-004
	,2.242260836e-004
	,2.250482399e-004
	,2.258123121e-004
	,2.265355069e-004
	,2.272256793e-004
	,2.278881356e-004
	,2.285269703e-004
	,2.291452025e-004
	,2.297450349e-004
	,2.303281351e-004
	,2.308958307e-004
	,2.314492242e-004
	,2.319892619e-004
	,2.325167735e-004
	,2.330324979e-004
	,2.335371005e-004
	,2.340311845e-004
	,2.345153001e-004
	,2.349899510e-004
	,2.354556002e-004
	,2.359126738e-004
	,2.363615657e-004
	,2.368026394e-004
	,2.372362315e-004
	,2.376626534e-004
	,2.380821924e-004
	,2.384951128e-004
	,2.389016551e-004
	,2.393020342e-004
	,2.396964337e-004
	,2.400849933e-004
	,2.404677802e-004
	,2.408447184e-004
	,2.412153981e-004
	,2.415784853e-004
	,2.419297106e-004
	,2.422575464e-004
	,2.425564344e-004
	,2.428447636e-004
	,2.431324881e-004
	,2.434205783e-004
	,2.437083568e-004
	,2.439950800e-004
	,2.442801327e-004
	,2.445630081e-004
	,2.448432980e-004
	,2.451207720e-004
	,2.453954410e-004
	,2.456674043e-004
	,2.459364543e-004
	,2.462011742e-004
	,2.464591092e-004
	,2.467120461e-004
	,2.469625197e-004
	,2.472112736e-004
	,2.474584804e-004
	,2.477041700e-004
	,2.479483287e-004
	,2.481909217e-004
	,2.484318949e-004
	,2.486711626e-004
	,2.489085808e-004
	,2.491438905e-004
	,2.493766126e-004
	,2.496059495e-004
	,2.498309738e-004
	,2.500509448e-004
	,2.502657140e-004
	,2.504761879e-004
	,2.506836979e-004
	,2.508892543e-004
	,2.510934434e-004
	,2.512965604e-004
	,2.514987033e-004
	,2.516997853e-004
	,2.518995387e-004
	,2.520978204e-004
	,2.522950321e-004
	,2.524917153e-004
	,2.526881716e-004
	,2.528845380e-004
	,2.530808804e-004
	,2.532772083e-004
	,2.534734661e-004
	,2.536695315e-004
	,2.538651835e-004
	,2.540600507e-004
	,2.542537243e-004
	,2.544461149e-004
	,2.546375350e-004
	,2.548281560e-004
	,2.550177573e-004
	,2.552071260e-004
	,2.553966196e-004
	,2.555862414e-004
	,2.557759600e-004
	,2.559657492e-004
	,2.561555930e-004
	,2.563454867e-004
	,2.565354416e-004
	,2.567254955e-004
	,2.569157369e-004
	,2.571063298e-004
	,2.572974413e-004
	,2.574890570e-004
	,2.576810561e-004
	,2.578733557e-004
	,2.580658668e-004
	,2.582585798e-004
	,2.584515405e-004
	,2.586448157e-004
	,2.588384829e-004
	,2.590326183e-004
	,2.592272566e-004
	,2.594222510e-004
	,-6.401769776e-004
	,-6.211997400e-004
	,-6.024198819e-004
	,-5.839805043e-004
	,-5.659011198e-004
	,-5.481129043e-004
	,-5.305915139e-004
	,-5.133314422e-004
	,-4.962498652e-004
	,-4.792227517e-004
	,-4.621794413e-004
	,-4.450808943e-004
	,-4.278663623e-004
	,-4.104934755e-004
	,-3.930179519e-004
	,-3.756007223e-004
	,-3.583643374e-004
	,-3.413499934e-004
	,-3.245754233e-004
	,-3.080385722e-004
	,-2.917240036e-004
	,-2.756264835e-004
	,-2.597359062e-004
	,-2.440189942e-004
	,-2.284235284e-004
	,-2.128840433e-004
	,-1.973351640e-004
	,-1.817727314e-004
	,-1.662726787e-004
	,-1.509231557e-004
	,-1.357755002e-004
	,-1.208460475e-004
	,-1.061531524e-004
	,-9.173614306e-005
	,-7.762230746e-005
	,-6.382285783e-005
	,-5.034790744e-005
	,-3.721543707e-005
	,-2.444274014e-005
	,-1.203757298e-005
	,5.430485451e-017
	,1.167506135e-005
	,2.299561578e-005
	,3.397011667e-005
	,4.460514048e-005
	,5.490330333e-005
	,6.486131899e-005
	,7.446971593e-005
	,8.371796960e-005
	,9.260188522e-005
	,1.011221172e-004
	,1.092749167e-004
	,1.170407277e-004
	,1.243796504e-004
	,1.312781219e-004
	,1.377835124e-004
	,1.439456610e-004
	,1.497949672e-004
	,1.553507405e-004
	,1.606270310e-004
	,1.656350799e-004
	,1.703844090e-004
	,1.748833955e-004
	,1.791396405e-004
	,1.831602474e-004
	,1.869520510e-004
	,1.905218107e-004
	,1.938763655e-004
	,1.970227362e-004
	,1.999681432e-004
	,2.027198416e-004
	,2.052847550e-004
	,2.076686138e-004
	,2.098732704e-004
	,2.118977274e-004
	,2.137560180e-004
	,2.154779505e-004
	,2.170843107e-004
	,2.185848142e-004
	,2.199807265e-004
	,2.212571650e-004
	,2.223833705e-004
	,2.233841672e-004
	,2.243087101e-004
	,2.251760970e-004
	,2.259922279e-004
	,2.267607013e-004
	,2.274870486e-004
	,2.281791400e-004
	,2.288439009e-004
	,2.294859130e-004
	,2.301081419e-004
	,2.307126776e-004
	,2.313011259e-004
	,2.318747989e-004
	,2.324348124e-004
	,2.329821393e-004
	,2.335176420e-004
	,2.340420932e-004
	,2.345561900e-004
	,2.350605644e-004
	,2.355557919e-004
	,2.360423975e-004
	,2.365208611e-004
	,2.369916222e-004
	,2.374550837e-004
	,2.379116152e-004
	,2.383615563e-004
	,2.388052187e-004
	,2.392428893e-004
	,2.396748319e-004
	,2.401012889e-004
	,2.405224835e-004
	,2.409386204e-004
	,2.413498872e-004
	,2.417564552e-004
	,2.421584790e-004
	,2.425560962e-004
	,2.429494257e-004
	,2.433385638e-004
	,2.437235774e-004
	,2.441044906e-004
	,2.444812586e-004
	,2.448537109e-004
	,2.452214201e-004
	,2.455833509e-004
	,2.459367900e-004
	,2.462740871e-004
	,2.465815367e-004
	,2.468651950e-004
	,2.471421939e-004
	,2.474141406e-004
	,2.476790185e-004
	,2.479387004e-004
	,2.481957067e-004
	,2.484511750e-004
	,2.487054379e-004
	,2.489585209e-004
	,2.492103796e-004
	,2.494610428e-004
	,2.497106013e-004
	,2.499590908e-004
	,2.502064623e-004
	,2.504526116e-004
	,2.506973942e-004
	,2.509406175e-004
	,2.511820033e-004
	,2.514209213e-004
	,2.516554368e-004
	,2.518841148e-004
	,2.521095948e-004
	,2.523336940e-004
	,2.525569215e-004
	,2.527794179e-004
	,2.530012217e-004
	,2.532223389e-004
	,2.534427648e-004
	,2.536624910e-004
	,2.538815087e-004
	,2.540998079e-004
	,2.543173763e-004
	,2.545341941e-004
	,2.547502237e-004
	,2.549653895e-004
	,2.551795705e-004
	,2.553926889e-004
	,2.556047008e-004
	,2.558153643e-004
	,2.560244736e-004
	,2.562323882e-004
	,2.564396847e-004
	,2.566466810e-004
	,2.568534802e-004
	,2.570600922e-004
	,2.572664884e-004
	,2.574726151e-004
	,2.576783829e-004
	,2.578836311e-004
	,2.580880715e-004
	,2.582913021e-004
	,2.584930741e-004
	,2.586935518e-004
	,2.588931086e-004
	,2.590920486e-004
	,2.592905429e-004
	,2.594886796e-004
	,2.596865394e-004
	,2.598842333e-004
	,2.600816919e-004
	,2.602784638e-004
	,2.604749347e-004
	,2.606716509e-004
	,2.608687566e-004
	,2.610662075e-004
	,2.612638917e-004
	,2.614617244e-004
	,2.616596593e-004
	,2.618576758e-004
	,2.620557693e-004
	,2.622539475e-004
	,2.624522303e-004
	,-6.527613792e-004
	,-6.336096041e-004
	,-6.147568895e-004
	,-5.962764767e-004
	,-5.781149730e-004
	,-5.601722653e-004
	,-5.424061409e-004
	,-5.247456182e-004
	,-5.071098991e-004
	,-4.894782169e-004
	,-4.718547421e-004
	,-4.542128080e-004
	,-4.364962082e-004
	,-4.186683837e-004
	,-4.008193712e-004
	,-3.830882741e-004
	,-3.655511377e-004
	,-3.482424842e-004
	,-3.311855066e-004
	,-3.143995121e-004
	,-2.978844169e-004
	,-2.816126193e-004
	,-2.655245886e-004
	,-2.495229314e-004
	,-2.334917906e-004
	,-2.173662154e-004
	,-2.011981099e-004
	,-1.851061496e-004
	,-1.691864130e-004
	,-1.534864529e-004
	,-1.380171861e-004
	,-1.227909522e-004
	,-1.078475040e-004
	,-9.321529165e-005
	,-7.889973673e-005
	,-6.489982141e-005
	,-5.122364313e-005
	,-3.788789130e-005
	,-2.490378572e-005
	,-1.227495320e-005
	,5.007532858e-017
	,1.192588533e-005
	,2.350940199e-005
	,3.475752825e-005
	,4.567626947e-005
	,5.626997816e-005
	,6.654099947e-005
	,7.648907218e-005
	,8.610976878e-005
	,9.539079681e-005
	,1.043034926e-004
	,1.127898134e-004
	,1.207881955e-004
	,1.283111214e-004
	,1.354106544e-004
	,1.421269294e-004
	,1.484875390e-004
	,1.545124719e-004
	,1.602169954e-004
	,1.656133901e-004
	,1.707120249e-004
	,1.755220548e-004
	,1.800519092e-004
	,1.843096627e-004
	,1.883033286e-004
	,1.920410861e-004
	,1.955314335e-004
	,1.987832321e-004
	,2.018055574e-004
	,2.046071223e-004
	,2.071946437e-004
	,2.095697568e-004
	,2.117345621e-004
	,2.137146877e-004
	,2.155429100e-004
	,2.172354699e-004
	,2.187904195e-004
	,2.201756350e-004
	,2.213831026e-004
	,2.224787525e-004
	,2.235000728e-004
	,2.244590936e-004
	,2.253617949e-004
	,2.262148725e-004
	,2.270260029e-004
	,2.278016942e-004
	,2.285467907e-004
	,2.292649160e-004
	,2.299588856e-004
	,2.306309612e-004
	,2.312829952e-004
	,2.319165015e-004
	,2.325326617e-004
	,2.331322472e-004
	,2.337154137e-004
	,2.342814210e-004
	,2.348290248e-004
	,2.353586160e-004
	,2.358731618e-004
	,2.363758947e-004
	,2.368689780e-004
	,2.373537356e-004
	,2.378310384e-004
	,2.383015198e-004
	,2.387656790e-004
	,2.392239315e-004
	,2.396766349e-004
	,2.401241033e-004
	,2.405666165e-004
	,2.410044248e-004
	,2.414377529e-004
	,2.418668020e-004
	,2.422917510e-004
	,2.427127557e-004
	,2.431299468e-004
	,2.435434226e-004
	,2.439532333e-004
	,2.443593401e-004
	,2.447615017e-004
	,2.451588991e-004
	,2.455486827e-004
	,2.459223750e-004
	,2.462752809e-004
	,2.466180753e-004
	,2.469573388e-004
	,2.472948962e-004
	,2.476312241e-004
	,2.479663707e-004
	,2.483001644e-004
	,2.486322004e-004
	,2.489616327e-004
	,2.492864818e-004
	,2.496013283e-004
	,2.498929017e-004
	,2.501572645e-004
	,2.504161401e-004
	,2.506787811e-004
	,2.509450902e-004
	,2.512137875e-004
	,2.514837641e-004
	,2.517541494e-004
	,2.520242519e-004
	,2.522935822e-004
	,2.525619477e-004
	,2.528293867e-004
	,2.530959376e-004
	,2.533615417e-004
	,2.536260816e-004
	,2.538894341e-004
	,2.541515001e-004
	,2.544122115e-004
	,2.546715224e-004
	,2.549293993e-004
	,2.551858134e-004
	,2.554407369e-004
	,2.556941362e-004
	,2.559459559e-004
	,2.561960771e-004
	,2.564441801e-004
	,2.566892337e-004
	,2.569286020e-004
	,2.571617274e-004
	,2.573917527e-004
	,2.576203453e-004
	,2.578480284e-004
	,2.580749776e-004
	,2.583012547e-004
	,2.585268770e-004
	,2.587518386e-004
	,2.589761124e-004
	,2.591996392e-004
	,2.594222970e-004
	,2.596438380e-004
	,2.598638339e-004
	,2.600819222e-004
	,2.602984135e-004
	,2.605140394e-004
	,2.607292547e-004
	,2.609441987e-004
	,2.611589034e-004
	,2.613734175e-004
	,2.615877562e-004
	,2.618018635e-004
	,2.620156067e-004
	,2.622287479e-004
	,2.624409361e-004
	,2.626518543e-004
	,2.628614627e-004
	,2.630699575e-004
	,2.632775544e-004
	,2.634844045e-004
	,2.636906069e-004
	,2.638962344e-004
	,2.641013511e-004
	,2.643060202e-004
	,2.645103051e-004
	,2.647142711e-004
	,2.649179905e-004
	,2.651215381e-004
	,2.653249683e-004
	,2.655282762e-004
	,-6.645788962e-004
	,-6.452413894e-004
	,-6.261880345e-004
	,-6.074135381e-004
	,-5.888647752e-004
	,-5.705124895e-004
	,-5.523574107e-004
	,-5.343308027e-004
	,-5.163588512e-004
	,-4.984173959e-004
	,-4.804811739e-004
	,-4.624999214e-004
	,-4.443987912e-004
	,-4.261720088e-004
	,-4.079521692e-004
	,-3.898780033e-004
	,-3.720464100e-004
	,-3.545165478e-004
	,-3.373090067e-004
	,-3.204123421e-004
	,-3.037859086e-004
	,-2.873500348e-004
	,-2.709685063e-004
	,-2.544773843e-004
	,-2.378164379e-004
	,-2.210875696e-004
	,-2.044373534e-004
	,-1.879667756e-004
	,-1.717230807e-004
	,-1.557149627e-004
	,-1.399473258e-004
	,-1.244598656e-004
	,-1.092899813e-004
	,-9.444781742e-005
	,-7.993129651e-005
	,-6.574248854e-005
	,-5.189489488e-005
	,-3.839920766e-005
	,-2.525564285e-005
	,-1.245844373e-005
	,-2.663204595e-018
	,1.212672214e-005
	,2.392689168e-005
	,3.540351218e-005
	,4.655778678e-005
	,5.738955684e-005
	,6.789721365e-005
	,7.807643838e-005
	,8.791638495e-005
	,9.738984059e-005
	,1.064413186e-004
	,1.150288845e-004
	,1.231793666e-004
	,1.309315663e-004
	,1.383065886e-004
	,1.453139774e-004
	,1.519571375e-004
	,1.582366954e-004
	,1.641540543e-004
	,1.697147647e-004
	,1.749292123e-004
	,1.798103761e-004
	,1.843714365e-004
	,1.886248552e-004
	,1.925824886e-004
	,1.962559601e-004
	,1.996568585e-004
	,2.027964538e-004
	,2.056842945e-004
	,2.083246887e-004
	,2.107192652e-004
	,2.128937520e-004
	,2.148852229e-004
	,2.167059835e-004
	,2.183275355e-004
	,2.197299567e-004
	,2.209902367e-004
	,2.221576590e-004
	,2.232483180e-004
	,2.242689605e-004
	,2.252254446e-004
	,2.261262010e-004
	,2.269798297e-004
	,2.277930589e-004
	,2.285710667e-004
	,2.293180886e-004
	,2.300377018e-004
	,2.307329301e-004
	,2.314063130e-004
	,2.320599836e-004
	,2.326957322e-004
	,2.333150773e-004
	,2.339194309e-004
	,2.345100277e-004
	,2.350879424e-004
	,2.356541313e-004
	,2.362094511e-004
	,2.367546686e-004
	,2.372904673e-004
	,2.378174488e-004
	,2.383361279e-004
	,2.388469168e-004
	,2.393500878e-004
	,2.398456930e-004
	,2.403333998e-004
	,2.408122336e-004
	,2.412805827e-004
	,2.417375030e-004
	,2.421843620e-004
	,2.426236690e-004
	,2.430572725e-004
	,2.434860731e-004
	,2.439100968e-004
	,2.443277052e-004
	,2.447315281e-004
	,2.451104810e-004
	,2.454748942e-004
	,2.458353498e-004
	,2.461946733e-004
	,2.465536068e-004
	,2.469123637e-004
	,2.472709877e-004
	,2.476294573e-004
	,2.479877224e-004
	,2.483457188e-004
	,2.487033744e-004
	,2.490606122e-004
	,2.494173496e-004
	,2.497734984e-004
	,2.501289611e-004
	,2.504836259e-004
	,2.508373576e-004
	,2.511899795e-004
	,2.515412391e-004
	,2.518907318e-004
	,2.522377182e-004
	,2.525806122e-004
	,2.529153252e-004
	,2.532301948e-004
	,2.535094092e-004
	,2.537727603e-004
	,2.540404597e-004
	,2.543138628e-004
	,2.545910568e-004
	,2.548703170e-004
	,2.551503472e-004
	,2.554303412e-004
	,2.557100594e-004
	,2.559895919e-004
	,2.562689956e-004
	,2.565481865e-004
	,2.568269964e-004
	,2.571052335e-004
	,2.573827138e-004
	,2.576592721e-004
	,2.579347643e-004
	,2.582090666e-004
	,2.584820725e-004
	,2.587536911e-004
	,2.590238446e-004
	,2.592924679e-004
	,2.595595082e-004
	,2.598249278e-004
	,2.600887079e-004
	,2.603508504e-004
	,2.606113734e-004
	,2.608702973e-004
	,2.611276300e-004
	,2.613833445e-004
	,2.616373251e-004
	,2.618891808e-004
	,2.621375723e-004
	,2.623796341e-004
	,2.626157209e-004
	,2.628489582e-004
	,2.630806816e-004
	,2.633112937e-004
	,2.635408902e-004
	,2.637693223e-004
	,2.639961740e-004
	,2.642209739e-004
	,2.644438907e-004
	,2.646657761e-004
	,2.648873146e-004
	,2.651087872e-004
	,2.653302543e-004
	,2.655516890e-004
	,2.657730287e-004
	,2.659941863e-004
	,2.662150377e-004
	,2.664353929e-004
	,2.666549737e-004
	,2.668734905e-004
	,2.670908522e-004
	,2.673072147e-004
	,2.675227803e-004
	,2.677376901e-004
	,2.679520304e-004
	,2.681658540e-004
	,2.683791953e-004
	,2.685920786e-004
	,-2.216808187e-006
	,-1.793520865e-006
	,-1.445747072e-006
	,-1.159532119e-006
	,-9.232797405e-007
	,-7.313618478e-007
	,-5.784363501e-007
	,-4.572825805e-007
	,-3.609333186e-007
	,-2.841408240e-007
	,-2.228397628e-007
	,-1.739242463e-007
	,-1.350644233e-007
	,-1.044976835e-007
	,-8.072409605e-008
	,-6.238316732e-008
	,-4.827080011e-008
	,-3.739058117e-008
	,-2.896370515e-008
	,-2.240787386e-008
	,-1.729643257e-008
	,-1.331870660e-008
	,-1.022798610e-008
	,-7.829477936e-009
	,-5.971595949e-009
	,-4.534781999e-009
	,-3.429896317e-009
	,-2.587580331e-009
	,-1.949557506e-009
	,-1.467497389e-009
	,-1.103079672e-009
	,-8.269361648e-010
	,-6.169763832e-010
	,-4.566419489e-010
	,-3.336486697e-010
	,-2.390341762e-010
	,-1.660024276e-010
	,-1.092300086e-010
	,-6.461797633e-011
	,-2.901781097e-011
	,-1.326312758e-017
	,2.427686502e-011
	,4.516165286e-011
	,6.362678286e-011
	,8.042352570e-011
	,9.615521731e-011
	,1.112701104e-010
	,1.260967000e-010
	,1.409482260e-010
	,1.561957942e-010
	,1.722207585e-010
	,1.893569615e-010
	,2.078776724e-010
	,2.279935507e-010
	,2.498615126e-010
	,2.736557776e-010
	,2.996359978e-010
	,3.281058527e-010
	,3.593879544e-010
	,3.938575107e-010
	,4.319460130e-010
	,4.741301441e-010
	,5.209363576e-010
	,5.729507805e-010
	,6.308259653e-010
	,6.952789561e-010
	,7.670617268e-010
	,8.468678359e-010
	,9.352755093e-010
	,1.032968782e-009
	,1.141323090e-009
	,1.262492934e-009
	,1.399231607e-009
	,1.554581010e-009
	,1.732238815e-009
	,1.936189580e-009
	,2.170236089e-009
	,2.437706343e-009
	,2.742323775e-009
	,3.090562191e-009
	,3.500298362e-009
	,3.989652560e-009
	,4.579298256e-009
	,5.289808284e-009
	,6.157087483e-009
	,7.222467859e-009
	,8.536971086e-009
	,1.016033952e-008
	,1.217227362e-008
	,1.467526106e-008
	,1.777736068e-008
	,2.164701662e-008
	,2.648254519e-008
	,3.253309789e-008
	,4.011569531e-008
	,4.956111972e-008
	,6.132062423e-008
	,7.607063070e-008
	,9.459043657e-008
	,1.178711010e-007
	,1.470943542e-007
	,1.825912471e-007
	,2.258790229e-007
	,2.780017787e-007
	,3.393693856e-007
	,4.125726870e-007
	,5.024205731e-007
	,6.129226625e-007
	,7.488911040e-007
	,9.162168867e-007
	,1.122148566e-006
	,1.375620637e-006
	,1.687644020e-006
	,2.071721157e-006
	,2.538441813e-006
	,3.102064519e-006
	,3.780415105e-006
	,4.605124716e-006
	,5.607254500e-006
	,6.823137376e-006
	,8.292385898e-006
	,9.994204814e-006
	,1.183054162e-005
	,1.389655389e-005
	,1.611164650e-005
	,1.868160703e-005
	,2.166277258e-005
	,2.511092176e-005
	,2.908713836e-005
	,3.365946215e-005
	,3.890331928e-005
	,4.490049577e-005
	,5.173349707e-005
	,5.933634378e-005
	,6.784819800e-005
	,7.732842279e-005
	,8.775171313e-005
	,9.927284263e-005
	,1.119114311e-004
	,1.255781729e-004
	,1.396267887e-004
	,1.545525005e-004
	,1.697205443e-004
	,1.842849345e-004
	,1.998452393e-004
	,2.166150009e-004
	,2.345598529e-004
	,2.535819484e-004
	,2.736711860e-004
	,2.947609226e-004
	,3.167839672e-004
	,3.396732691e-004
	,3.633624488e-004
	,3.877861741e-004
	,4.128801620e-004
	,4.385817932e-004
	,4.648302034e-004
	,4.915647156e-004
	,5.186826552e-004
	,5.461644171e-004
	,5.739601511e-004
	,6.018558248e-004
	,6.297852808e-004
	,6.578297178e-004
	,6.859390671e-004
	,7.140520687e-004
	,7.421194540e-004
	,7.700775551e-004
	,7.978598733e-004
	,8.253967590e-004
	,8.526212676e-004
	,8.794728798e-004
	,9.058951130e-004
	,9.318405416e-004
	,9.572716543e-004
	,9.812466628e-004
	,1.004589508e-003
	,1.027102045e-003
	,1.048977971e-003
	,1.070235759e-003
	,1.090903143e-003
	,1.110862722e-003
	,1.130322652e-003
	,1.149349804e-003
	,1.168014752e-003
	,1.186383049e-003
	,1.204466193e-003
	,1.222417258e-003
	,1.240312055e-003
	,1.258218828e-003
	,1.276198851e-003
	,1.294066165e-003
	,1.311043720e-003
	,1.328314346e-003
	,1.345909111e-003
	,1.363834096e-003
	,1.382088202e-003
	,1.400677091e-003
	,1.419618648e-003
	,1.438812792e-003
	,1.458330991e-003
	,-5.991961900e-006
	,-4.922419091e-006
	,-4.006945512e-006
	,-3.233485786e-006
	,-2.593057451e-006
	,-2.073322307e-006
	,-1.656460115e-006
	,-1.321258739e-006
	,-1.049001000e-006
	,-8.273347369e-007
	,-6.485868418e-007
	,-5.059296710e-007
	,-3.937115211e-007
	,-3.064246625e-007
	,-2.387330185e-007
	,-1.861232893e-007
	,-1.450009493e-007
	,-1.126528149e-007
	,-8.720248408e-008
	,-6.726526193e-008
	,-5.166018884e-008
	,-3.947171152e-008
	,-3.005979421e-008
	,-2.287300414e-008
	,-1.741304491e-008
	,-1.326891963e-008
	,-1.012035911e-008
	,-7.723250104e-009
	,-5.892578702e-009
	,-4.488214457e-009
	,-3.405875560e-009
	,-2.571227886e-009
	,-1.929240525e-009
	,-1.435315148e-009
	,-1.053615996e-009
	,-7.569142225e-010
	,-5.251700940e-010
	,-3.436942181e-010
	,-2.014490379e-010
	,-8.939816089e-011
	,1.247954257e-017
	,7.287133015e-011
	,1.340809744e-010
	,1.874079798e-010
	,2.357549787e-010
	,2.813557938e-010
	,3.259310890e-010
	,3.707822433e-010
	,4.168598678e-010
	,4.649248103e-010
	,5.157984373e-010
	,5.703655798e-010
	,6.294309727e-010
	,6.936908750e-010
	,7.638438361e-010
	,8.406653172e-010
	,9.249379104e-010
	,1.017389065e-009
	,1.118596169e-009
	,1.228806392e-009
	,1.347982213e-009
	,1.476448057e-009
	,1.615296233e-009
	,1.765811118e-009
	,1.928785345e-009
	,2.104074472e-009
	,2.290398302e-009
	,2.486114117e-009
	,2.691340351e-009
	,2.908958513e-009
	,3.143117047e-009
	,3.397836045e-009
	,3.676705542e-009
	,3.982997185e-009
	,4.319755177e-009
	,4.690039750e-009
	,5.097756072e-009
	,5.548480706e-009
	,6.049416887e-009
	,6.609272660e-009
	,7.238906575e-009
	,7.952157129e-009
	,8.766136365e-009
	,9.702310897e-009
	,1.078616797e-008
	,1.205214620e-008
	,1.354470148e-008
	,1.531902186e-008
	,1.744418590e-008
	,1.999960391e-008
	,2.307881074e-008
	,2.681211030e-008
	,3.132828433e-008
	,3.684200321e-008
	,4.358843741e-008
	,5.190393102e-008
	,6.218000306e-008
	,7.471078528e-008
	,9.014110608e-008
	,1.089658316e-007
	,1.314577670e-007
	,1.582734432e-007
	,1.902118112e-007
	,2.293526257e-007
	,2.776404062e-007
	,3.373473193e-007
	,4.112515093e-007
	,5.027571654e-007
	,6.161479507e-007
	,7.567608801e-007
	,9.312161408e-007
	,1.147693973e-006
	,1.413306124e-006
	,1.740957902e-006
	,2.140776384e-006
	,2.628753536e-006
	,3.228350873e-006
	,3.964940436e-006
	,4.868108247e-006
	,5.967108184e-006
	,7.212014134e-006
	,8.621722665e-006
	,1.018632527e-005
	,1.194085015e-005
	,1.399786002e-005
	,1.640754789e-005
	,1.922147496e-005
	,2.249634705e-005
	,2.629518681e-005
	,3.068770028e-005
	,3.574947192e-005
	,4.155714951e-005
	,4.808086619e-005
	,5.543287256e-005
	,6.360728583e-005
	,7.270439714e-005
	,8.281941551e-005
	,9.397921203e-005
	,1.061441747e-004
	,1.187152765e-004
	,1.319736711e-004
	,1.451953405e-004
	,1.583206948e-004
	,1.724401591e-004
	,1.877086282e-004
	,2.041238152e-004
	,2.216482464e-004
	,2.402352001e-004
	,2.598337553e-004
	,2.802447630e-004
	,3.015216745e-004
	,3.235759721e-004
	,3.463599328e-004
	,3.698409198e-004
	,3.939651999e-004
	,4.186772362e-004
	,4.439222079e-004
	,4.696455376e-004
	,4.957929957e-004
	,5.223114724e-004
	,5.490909967e-004
	,5.759466125e-004
	,6.029933592e-004
	,6.301904660e-004
	,6.574932129e-004
	,6.848511809e-004
	,7.122090665e-004
	,7.395079877e-004
	,7.666838989e-004
	,7.936772375e-004
	,8.204277864e-004
	,8.468781425e-004
	,8.729760560e-004
	,8.982946235e-004
	,9.227371602e-004
	,9.466493145e-004
	,9.699587009e-004
	,9.925482365e-004
	,1.014531970e-003
	,1.035915163e-003
	,1.056715429e-003
	,1.076962252e-003
	,1.096595180e-003
	,1.115681322e-003
	,1.134369846e-003
	,1.152714516e-003
	,1.170794132e-003
	,1.188680667e-003
	,1.205938097e-003
	,1.222627656e-003
	,1.239378197e-003
	,1.256261808e-003
	,1.273338097e-003
	,1.290629726e-003
	,1.308151241e-003
	,1.325915702e-003
	,1.343938130e-003
	,1.362237360e-003
	,1.380837669e-003
	,1.399771988e-003
	,1.419090488e-003
	,-1.487006871e-005
	,-1.243880955e-005
	,-1.036240413e-005
	,-8.557061156e-006
	,-6.989814579e-006
	,-5.664756292e-006
	,-4.569303020e-006
	,-3.675549094e-006
	,-2.952434173e-006
	,-2.364259215e-006
	,-1.880104616e-006
	,-1.485921290e-006
	,-1.171288463e-006
	,-9.214478010e-007
	,-7.221510759e-007
	,-5.631489327e-007
	,-4.375207204e-007
	,-3.392132136e-007
	,-2.624408874e-007
	,-2.023328913e-007
	,-1.555053643e-007
	,-1.194003416e-007
	,-9.172962647e-008
	,-7.054386916e-008
	,-5.428825259e-008
	,-4.175638345e-008
	,-3.204202237e-008
	,-2.450718695e-008
	,-1.869037743e-008
	,-1.420766524e-008
	,-1.073935110e-008
	,-8.046547358e-009
	,-5.966293004e-009
	,-4.376908144e-009
	,-3.171594209e-009
	,-2.257678678e-009
	,-1.560866819e-009
	,-1.024300324e-009
	,-6.052460872e-010
	,-2.717619558e-010
	,8.302233009e-018
	,2.278277034e-010
	,4.248896757e-010
	,6.007799998e-010
	,7.628304248e-010
	,9.172930038e-010
	,1.069493411e-009
	,1.223693652e-009
	,1.383006640e-009
	,1.549497107e-009
	,1.724503700e-009
	,1.908520703e-009
	,2.101449602e-009
	,2.304060181e-009
	,2.517912696e-009
	,2.743764438e-009
	,2.981312546e-009
	,3.230744257e-009
	,3.494478180e-009
	,3.776575399e-009
	,4.081168664e-009
	,4.411903400e-009
	,4.772072254e-009
	,5.164829167e-009
	,5.593269246e-009
	,6.060291587e-009
	,6.568284568e-009
	,7.119416030e-009
	,7.717130655e-009
	,8.366767020e-009
	,9.074463769e-009
	,9.846376406e-009
	,1.068876834e-008
	,1.160874072e-008
	,1.261469024e-008
	,1.371606269e-008
	,1.492320920e-008
	,1.624747792e-008
	,1.770125381e-008
	,1.929764372e-008
	,2.104956854e-008
	,2.296804556e-008
	,2.506082495e-008
	,2.733545465e-008
	,2.980883736e-008
	,3.251046237e-008
	,3.547672731e-008
	,3.875278549e-008
	,4.239051274e-008
	,4.645128863e-008
	,5.100449880e-008
	,5.611871708e-008
	,6.185194227e-008
	,6.825101209e-008
	,7.542758435e-008
	,8.352813815e-008
	,9.290951249e-008
	,1.039767341e-007
	,1.171863181e-007
	,1.330503718e-007
	,1.521507812e-007
	,1.752314054e-007
	,2.033986825e-007
	,2.379160987e-007
	,2.803614939e-007
	,3.326491585e-007
	,3.970070159e-007
	,4.766454665e-007
	,5.750353822e-007
	,6.966085522e-007
	,8.474201289e-007
	,1.034600451e-006
	,1.265002136e-006
	,1.547574685e-006
	,1.897325731e-006
	,2.330665527e-006
	,2.866341671e-006
	,3.522000242e-006
	,4.294984318e-006
	,5.178744824e-006
	,6.194263196e-006
	,7.333970772e-006
	,8.684483113e-006
	,1.028894902e-005
	,1.219042918e-005
	,1.443604085e-005
	,1.707833356e-005
	,2.017585782e-005
	,2.379323692e-005
	,2.799988186e-005
	,3.285797282e-005
	,3.836091180e-005
	,4.459505670e-005
	,5.156680435e-005
	,5.941243230e-005
	,6.818903571e-005
	,7.791992563e-005
	,8.851111416e-005
	,9.957004942e-005
	,1.109491471e-004
	,1.223017042e-004
	,1.340278263e-004
	,1.467385565e-004
	,1.605198201e-004
	,1.753604279e-004
	,1.912436415e-004
	,2.081003637e-004
	,2.259171793e-004
	,2.446691915e-004
	,2.643139990e-004
	,2.848064322e-004
	,3.059576725e-004
	,3.277563279e-004
	,3.502260496e-004
	,3.733174866e-004
	,3.969811649e-004
	,4.211675050e-004
	,4.458265146e-004
	,4.709087218e-004
	,4.963637071e-004
	,5.219667504e-004
	,5.478257507e-004
	,5.739072819e-004
	,6.001741911e-004
	,6.265840169e-004
	,6.530881947e-004
	,6.796359274e-004
	,7.061740793e-004
	,7.326474077e-004
	,7.590006508e-004
	,7.851801113e-004
	,8.111237763e-004
	,8.361635828e-004
	,8.608120049e-004
	,8.850415225e-004
	,9.088254134e-004
	,9.320489171e-004
	,9.546691464e-004
	,9.767386816e-004
	,9.982561981e-004
	,1.019233059e-003
	,1.039692275e-003
	,1.059667262e-003
	,1.079115692e-003
	,1.097374057e-003
	,1.115066845e-003
	,1.132539438e-003
	,1.149846638e-003
	,1.167029405e-003
	,1.184121375e-003
	,1.201155904e-003
	,1.218170118e-003
	,1.235206415e-003
	,1.252305682e-003
	,1.269505344e-003
	,1.286856374e-003
	,1.304401360e-003
	,1.322196046e-003
	,1.340280970e-003
	,1.358694572e-003
	,1.377479770e-003
	,-3.331564087e-005
	,-2.863967277e-005
	,-2.447031577e-005
	,-2.073191728e-005
	,-1.737287654e-005
	,-1.443112576e-005
	,-1.193540815e-005
	,-9.841094070e-006
	,-8.081552904e-006
	,-6.596105167e-006
	,-5.331819813e-006
	,-4.265799575e-006
	,-3.387873549e-006
	,-2.679877848e-006
	,-2.117740304e-006
	,-1.673759557e-006
	,-1.321965984e-006
	,-1.041609328e-006
	,-8.167933403e-007
	,-6.369535864e-007
	,-4.950147041e-007
	,-3.840358526e-007
	,-2.971378227e-007
	,-2.287753303e-007
	,-1.752193887e-007
	,-1.336935426e-007
	,-1.017765363e-007
	,-7.738105162e-008
	,-5.873837831e-008
	,-4.444546618e-008
	,-3.347952500e-008
	,-2.510708049e-008
	,-1.874040150e-008
	,-1.389675430e-008
	,-1.019763483e-008
	,-7.353882659e-009
	,-5.146799167e-009
	,-3.413099923e-009
	,-2.032759526e-009
	,-9.178496549e-010
	,-9.869063571e-018
	,7.751597512e-010
	,1.448209507e-009
	,2.046207794e-009
	,2.585241375e-009
	,3.077682848e-009
	,3.538682795e-009
	,3.985142837e-009
	,4.433035372e-009
	,4.895987209e-009
	,5.384930884e-009
	,5.908597619e-009
	,6.474141646e-009
	,7.087754626e-009
	,7.755442313e-009
	,8.483642984e-009
	,9.279004924e-009
	,1.014730352e-008
	,1.109221981e-008
	,1.211616185e-008
	,1.322445130e-008
	,1.442685568e-008
	,1.573510702e-008
	,1.716151074e-008
	,1.871803711e-008
	,2.041550427e-008
	,2.226417815e-008
	,2.427476360e-008
	,2.645692857e-008
	,2.881699628e-008
	,3.135582643e-008
	,3.407028951e-008
	,3.696440827e-008
	,4.005700495e-008
	,4.337205529e-008
	,4.692590755e-008
	,5.071891096e-008
	,5.472788337e-008
	,5.890478762e-008
	,6.320113794e-008
	,6.761618726e-008
	,7.221035219e-008
	,7.706813348e-008
	,8.226718433e-008
	,8.787229632e-008
	,9.393942704e-008
	,1.005198915e-007
	,1.076623158e-007
	,1.154129630e-007
	,1.238182787e-007
	,1.329350613e-007
	,1.428453211e-007
	,1.536549891e-007
	,1.654900171e-007
	,1.784999517e-007
	,1.928669481e-007
	,2.088129451e-007
	,2.266103629e-007
	,2.465961071e-007
	,2.692020660e-007
	,2.949746716e-007
	,3.246668257e-007
	,3.592200491e-007
	,3.998115566e-007
	,4.479010144e-007
	,5.052984261e-007
	,5.738637542e-007
	,6.563253758e-007
	,7.555307857e-007
	,8.751726194e-007
	,1.020827786e-006
	,1.198652488e-006
	,1.415616878e-006
	,1.680976478e-006
	,1.999253695e-006
	,2.381718177e-006
	,2.825916333e-006
	,3.343094390e-006
	,3.934219081e-006
	,4.637978752e-006
	,5.485529873e-006
	,6.506805985e-006
	,7.734782364e-006
	,9.206884076e-006
	,1.096569800e-005
	,1.305940239e-005
	,1.554190175e-005
	,1.847211170e-005
	,2.191051819e-005
	,2.587804975e-005
	,3.043845764e-005
	,3.559905862e-005
	,4.147972647e-005
	,4.814504623e-005
	,5.563967909e-005
	,6.396214596e-005
	,7.288766174e-005
	,8.210630332e-005
	,9.159189045e-005
	,1.011651552e-004
	,1.115150712e-004
	,1.228010476e-004
	,1.350146168e-004
	,1.481913130e-004
	,1.623274194e-004
	,1.774085905e-004
	,1.934149872e-004
	,2.103216408e-004
	,2.280994003e-004
	,2.467150401e-004
	,2.661327537e-004
	,2.863139551e-004
	,3.072181149e-004
	,3.286950833e-004
	,3.505913314e-004
	,3.730463421e-004
	,3.960151977e-004
	,4.194520994e-004
	,4.433127283e-004
	,4.674573961e-004
	,4.919018915e-004
	,5.166341043e-004
	,5.416228746e-004
	,5.668322259e-004
	,5.922205731e-004
	,6.177445742e-004
	,6.433578583e-004
	,6.690118843e-004
	,6.946578001e-004
	,7.202479602e-004
	,7.454757838e-004
	,7.702857974e-004
	,7.948371411e-004
	,8.191025810e-004
	,8.430502999e-004
	,8.666454134e-004
	,8.897544219e-004
	,9.123914237e-004
	,9.345651378e-004
	,9.562288242e-004
	,9.766569467e-004
	,9.966449525e-004
	,1.016242332e-003
	,1.035477785e-003
	,1.054334323e-003
	,1.072629936e-003
	,1.090640603e-003
	,1.108396443e-003
	,1.125932190e-003
	,1.143285739e-003
	,1.160496823e-003
	,1.177606035e-003
	,1.194654267e-003
	,1.211682542e-003
	,1.228732217e-003
	,1.245845567e-003
	,1.263066675e-003
	,1.280441010e-003
	,1.297995361e-003
	,1.315806379e-003
	,1.333925867e-003
	,-6.569040083e-005
	,-5.815126227e-005
	,-5.117943339e-005
	,-4.471160450e-005
	,-3.874941117e-005
	,-3.328565513e-005
	,-2.837636637e-005
	,-2.407839514e-005
	,-2.034118312e-005
	,-1.705897448e-005
	,-1.416018807e-005
	,-1.162780157e-005
	,-9.464501255e-006
	,-7.669539824e-006
	,-6.207827011e-006
	,-5.020961849e-006
	,-4.047915608e-006
	,-3.240555208e-006
	,-2.573435517e-006
	,-2.024172333e-006
	,-1.574831251e-006
	,-1.216793400e-006
	,-9.385595420e-007
	,-7.246033804e-007
	,-5.603335171e-007
	,-4.338578406e-007
	,-3.358609683e-007
	,-2.593710651e-007
	,-1.996529240e-007
	,-1.531618738e-007
	,-1.169257564e-007
	,-8.868024624e-008
	,-6.665958364e-008
	,-4.948258162e-008
	,-3.615130520e-008
	,-2.585648096e-008
	,-1.789415913e-008
	,-1.171220222e-008
	,-6.885877342e-009
	,-3.072569995e-009
	,4.177139817e-018
	,2.536248113e-009
	,4.687915309e-009
	,6.575181279e-009
	,8.295373026e-009
	,9.926252761e-009
	,1.153104722e-008
	,1.316156717e-008
	,1.485994515e-008
	,1.665930071e-008
	,1.858199315e-008
	,2.063997560e-008
	,2.284729830e-008
	,2.523217838e-008
	,2.782883322e-008
	,3.066653423e-008
	,3.376462208e-008
	,3.712765466e-008
	,4.073778268e-008
	,4.455076504e-008
	,4.851742501e-008
	,5.262832953e-008
	,5.691687727e-008
	,6.141659837e-008
	,6.614222618e-008
	,7.110495628e-008
	,7.633744785e-008
	,8.189726279e-008
	,8.785117683e-008
	,9.426369955e-008
	,1.011910945e-007
	,1.086805274e-007
	,1.167707006e-007
	,1.254935099e-007
	,1.348782228e-007
	,1.449561032e-007
	,1.557595675e-007
	,1.673189397e-007
	,1.796735476e-007
	,1.928909208e-007
	,2.070623143e-007
	,2.222863382e-007
	,2.386623467e-007
	,2.562918266e-007
	,2.752860907e-007
	,2.957731986e-007
	,3.178958397e-007
	,3.418073867e-007
	,3.676713018e-007
	,3.956611910e-007
	,4.259574616e-007
	,4.587388426e-007
	,4.941663104e-007
	,5.323574445e-007
	,5.733660805e-007
	,6.172206400e-007
	,6.640491164e-007
	,7.141565850e-007
	,7.679510095e-007
	,8.258523970e-007
	,8.882729320e-007
	,9.556449734e-007
	,1.028502404e-006
	,1.107465050e-006
	,1.193178677e-006
	,1.286184674e-006
	,1.386843317e-006
	,1.495487150e-006
	,1.613270846e-006
	,1.742630040e-006
	,1.886864199e-006
	,2.051024158e-006
	,2.241605421e-006
	,2.465733913e-006
	,2.731312751e-006
	,3.048237060e-006
	,3.428110621e-006
	,3.881846502e-006
	,4.428434200e-006
	,5.087797255e-006
	,5.883577127e-006
	,6.843630851e-006
	,8.000489916e-006
	,9.387411315e-006
	,1.104763321e-005
	,1.302776962e-005
	,1.536391611e-005
	,1.811056019e-005
	,2.128625310e-005
	,2.496109715e-005
	,2.920624633e-005
	,3.407916169e-005
	,3.961578408e-005
	,4.580893288e-005
	,5.247172269e-005
	,5.940930671e-005
	,6.663102457e-005
	,7.412379328e-005
	,8.226338009e-005
	,9.119072885e-005
	,1.009540045e-004
	,1.115711957e-004
	,1.230510423e-004
	,1.353944119e-004
	,1.486018211e-004
	,1.626663700e-004
	,1.775764131e-004
	,1.933159062e-004
	,2.098646934e-004
	,2.271988235e-004
	,2.452914090e-004
	,2.641127315e-004
	,2.836305943e-004
	,3.038104928e-004
	,3.246155520e-004
	,3.460063740e-004
	,3.675304131e-004
	,3.895144719e-004
	,4.118908692e-004
	,4.346310690e-004
	,4.577207003e-004
	,4.811335082e-004
	,5.048392970e-004
	,5.288037797e-004
	,5.529885977e-004
	,5.773525537e-004
	,6.018526077e-004
	,6.264448455e-004
	,6.510565417e-004
	,6.753814876e-004
	,6.996060205e-004
	,7.237114292e-004
	,7.476776573e-004
	,7.714766359e-004
	,7.950749632e-004
	,8.182759009e-004
	,8.406190679e-004
	,8.626157468e-004
	,8.842778951e-004
	,9.056005587e-004
	,9.265672225e-004
	,9.471595680e-004
	,9.673657277e-004
	,9.871839639e-004
	,1.006623247e-003
	,1.025582465e-003
	,1.043955271e-003
	,1.062042224e-003
	,1.079878319e-003
	,1.097501112e-003
	,1.114949494e-003
	,1.132262719e-003
	,1.149479723e-003
	,1.166638737e-003
	,1.183777042e-003
	,1.200907189e-003
	,1.217828896e-003
	,1.234847441e-003
	,1.251998565e-003
	,1.269319319e-003
	,1.286850323e-003
	,-1.172138353e-004
	,-1.058675720e-004
	,-9.540070771e-005
	,-8.578602358e-005
	,-7.680978006e-005
	,-6.825257448e-005
	,-6.014980485e-005
	,-5.264941475e-005
	,-4.584458102e-005
	,-3.976355942e-005
	,-3.433427400e-005
	,-2.944080582e-005
	,-2.496979315e-005
	,-2.089520185e-005
	,-1.730834150e-005
	,-1.422958943e-005
	,-1.161176999e-005
	,-9.422948485e-006
	,-7.625905669e-006
	,-6.156778369e-006
	,-4.946682145e-006
	,-3.952660308e-006
	,-3.143557297e-006
	,-2.491453367e-006
	,-1.966144112e-006
	,-1.539572548e-006
	,-1.195476376e-006
	,-9.228282619e-007
	,-7.080851701e-007
	,-5.391506386e-007
	,-4.076024902e-007
	,-3.066844711e-007
	,-2.296950845e-007
	,-1.707764633e-007
	,-1.255435456e-007
	,-9.065225905e-008
	,-6.347199548e-008
	,-4.205812749e-008
	,-2.502842701e-008
	,-1.130465768e-008
	,-2.579505627e-017
	,9.574639424e-009
	,1.792928550e-008
	,2.542544956e-008
	,3.230647506e-008
	,3.880167736e-008
	,4.511732022e-008
	,5.137895149e-008
	,5.769918131e-008
	,6.414262272e-008
	,7.072320069e-008
	,7.747674135e-008
	,8.446170091e-008
	,9.175360614e-008
	,9.946032077e-008
	,1.077019322e-007
	,1.165914975e-007
	,1.262378430e-007
	,1.367398144e-007
	,1.481908182e-007
	,1.606892908e-007
	,1.743393597e-007
	,1.892454128e-007
	,2.055083086e-007
	,2.232094788e-007
	,2.423870795e-007
	,2.630566489e-007
	,2.852963447e-007
	,3.092745230e-007
	,3.351758187e-007
	,3.631485165e-007
	,3.933178408e-007
	,4.258288140e-007
	,4.608620023e-007
	,4.986400074e-007
	,5.393863057e-007
	,5.832376301e-007
	,6.301659023e-007
	,6.799832865e-007
	,7.325329597e-007
	,7.879227169e-007
	,8.464876493e-007
	,9.085684737e-007
	,9.743205196e-007
	,1.043561608e-006
	,1.115629869e-006
	,1.189350635e-006
	,1.263394001e-006
	,1.337092755e-006
	,1.410963370e-006
	,1.486305171e-006
	,1.564494665e-006
	,1.646646514e-006
	,1.733605347e-006
	,1.826032128e-006
	,1.924468562e-006
	,2.029353398e-006
	,2.141027676e-006
	,2.259777024e-006
	,2.385945235e-006
	,2.520046519e-006
	,2.662758151e-006
	,2.814858431e-006
	,2.977186308e-006
	,3.150648799e-006
	,3.336243169e-006
	,3.535092015e-006
	,3.748491098e-006
	,3.977966685e-006
	,4.225348920e-006
	,4.492866699e-006
	,4.783268897e-006
	,5.100001382e-006
	,5.447439070e-006
	,5.831171838e-006
	,6.258269675e-006
	,6.738029414e-006
	,7.282065159e-006
	,7.905080774e-006
	,8.624732735e-006
	,9.461443308e-006
	,1.043752762e-005
	,1.157251111e-005
	,1.289962401e-005
	,1.445894064e-005
	,1.629397909e-005
	,1.844963289e-005
	,2.096898056e-005
	,2.388392712e-005
	,2.719943506e-005
	,3.086637466e-005
	,3.481473265e-005
	,3.908488274e-005
	,4.358980092e-005
	,4.850643322e-005
	,5.397490965e-005
	,6.006194768e-005
	,6.680332974e-005
	,7.423519551e-005
	,8.238062245e-005
	,9.125854483e-005
	,1.008841525e-004
	,1.112688686e-004
	,1.224202620e-004
	,1.343419782e-004
	,1.470332090e-004
	,1.604887789e-004
	,1.747030100e-004
	,1.896643158e-004
	,2.053577382e-004
	,2.217651237e-004
	,2.388652058e-004
	,2.566335552e-004
	,2.750428143e-004
	,2.940584683e-004
	,3.136438226e-004
	,3.337677901e-004
	,3.543998003e-004
	,3.753099226e-004
	,3.963153847e-004
	,4.177090224e-004
	,4.394658940e-004
	,4.615565796e-004
	,4.839475763e-004
	,5.066019766e-004
	,5.294772865e-004
	,5.525083729e-004
	,5.755915161e-004
	,5.986886239e-004
	,6.218089305e-004
	,6.449504666e-004
	,6.679161688e-004
	,6.905790685e-004
	,7.131444826e-004
	,7.356609148e-004
	,7.581379418e-004
	,7.804139973e-004
	,8.021919247e-004
	,8.238417684e-004
	,8.453147352e-004
	,8.665603383e-004
	,8.875324948e-004
	,9.081943923e-004
	,9.285210652e-004
	,9.485000926e-004
	,9.681310931e-004
	,9.871555390e-004
	,1.005614046e-003
	,1.023797671e-003
	,1.041733615e-003
	,1.059462223e-003
	,1.077018026e-003
	,1.094436535e-003
	,1.111753415e-003
	,1.129003905e-003
	,1.146222462e-003
	,1.163442593e-003
	,1.180696873e-003
	,1.198017128e-003
	,1.215434856e-003
	,1.232982034e-003
	,-1.867224939e-004
	,-1.729922127e-004
	,-1.597795834e-004
	,-1.471395324e-004
	,-1.350615212e-004
	,-1.234808505e-004
	,-1.122803668e-004
	,-1.014853852e-004
	,-9.127476949e-005
	,-8.173345223e-005
	,-7.283248874e-005
	,-6.451756483e-005
	,-5.675758755e-005
	,-4.956714801e-005
	,-4.294161010e-005
	,-3.679524748e-005
	,-3.118783577e-005
	,-2.627670804e-005
	,-2.207422790e-005
	,-1.847493125e-005
	,-1.533262733e-005
	,-1.258033082e-005
	,-1.022190430e-005
	,-8.229034013e-006
	,-6.559370377e-006
	,-5.183882201e-006
	,-4.082078612e-006
	,-3.212408382e-006
	,-2.525088871e-006
	,-1.976718159e-006
	,-1.538686421e-006
	,-1.189572721e-006
	,-9.115853422e-007
	,-6.896035160e-007
	,-5.122328655e-007
	,-3.712856912e-007
	,-2.595631806e-007
	,-1.712035688e-007
	,-1.011417798e-007
	,-4.517575713e-008
	,1.054753689e-017
	,3.707985103e-008
	,6.842723435e-008
	,9.599954829e-008
	,1.213123723e-007
	,1.454961002e-007
	,1.693592292e-007
	,1.935260851e-007
	,2.186163395e-007
	,2.451410283e-007
	,2.733665012e-007
	,3.029266359e-007
	,3.335543966e-007
	,3.655647387e-007
	,3.995352740e-007
	,4.358027178e-007
	,4.748947038e-007
	,5.176076165e-007
	,5.646745227e-007
	,6.165607914e-007
	,6.733240485e-007
	,7.344572261e-007
	,7.988581708e-007
	,8.651834676e-007
	,9.326521189e-007
	,1.001363437e-006
	,1.071612985e-006
	,1.143438141e-006
	,1.217008148e-006
	,1.293113320e-006
	,1.373012509e-006
	,1.457913099e-006
	,1.548700939e-006
	,1.645955717e-006
	,1.750091262e-006
	,1.861532863e-006
	,1.980787627e-006
	,2.108349113e-006
	,2.244552428e-006
	,2.389621883e-006
	,2.543811296e-006
	,2.707435939e-006
	,2.881060382e-006
	,3.065376913e-006
	,3.260919786e-006
	,3.468081644e-006
	,3.687427394e-006
	,3.919846815e-006
	,4.166348903e-006
	,4.427798100e-006
	,4.704779895e-006
	,4.997591685e-006
	,5.306386386e-006
	,5.631466697e-006
	,5.973473741e-006
	,6.333192442e-006
	,6.711135548e-006
	,7.107217988e-006
	,7.520701117e-006
	,7.950610568e-006
	,8.396645184e-006
	,8.859754534e-006
	,9.341731358e-006
	,9.844495951e-006
	,1.036970623e-005
	,1.091867036e-005
	,1.149232082e-005
	,1.209111646e-005
	,1.271484921e-005
	,1.336231233e-005
	,1.403103106e-005
	,1.471683891e-005
	,1.541398669e-005
	,1.611634376e-005
	,1.681986673e-005
	,1.752489560e-005
	,1.823562990e-005
	,1.895777288e-005
	,1.969707299e-005
	,2.045985385e-005
	,2.125547822e-005
	,2.209701669e-005
	,2.300044341e-005
	,2.398455928e-005
	,2.507070444e-005
	,2.628326749e-005
	,2.765018490e-005
	,2.920327300e-005
	,3.097761778e-005
	,3.301176865e-005
	,3.534765333e-005
	,3.802784439e-005
	,4.109482719e-005
	,4.458882766e-005
	,4.854876753e-005
	,5.300531485e-005
	,5.799677419e-005
	,6.355529453e-005
	,6.970820275e-005
	,7.647919129e-005
	,8.388827316e-005
	,9.195178029e-005
	,1.006823625e-004
	,1.100884568e-004
	,1.201778551e-004
	,1.309514233e-004
	,1.424052854e-004
	,1.545312355e-004
	,1.673185870e-004
	,1.807506552e-004
	,1.948237270e-004
	,2.095278440e-004
	,2.248498378e-004
	,2.407722513e-004
	,2.572742538e-004
	,2.743299463e-004
	,2.919612805e-004
	,3.101005926e-004
	,3.287303075e-004
	,3.478310666e-004
	,3.673779246e-004
	,3.871945587e-004
	,4.068825968e-004
	,4.268669613e-004
	,4.470591744e-004
	,4.673942627e-004
	,4.874556994e-004
	,5.071314742e-004
	,5.269183589e-004
	,5.472300739e-004
	,5.681115084e-004
	,5.894806661e-004
	,6.112395106e-004
	,6.332966517e-004
	,6.555686463e-004
	,6.779779664e-004
	,7.004467377e-004
	,7.229036681e-004
	,7.452849580e-004
	,7.675311313e-004
	,7.895897725e-004
	,8.114134331e-004
	,8.329617943e-004
	,8.542029429e-004
	,8.751143967e-004
	,8.956836878e-004
	,9.159084095e-004
	,9.354297722e-004
	,9.542317378e-004
	,9.727704387e-004
	,9.910705803e-004
	,1.009160532e-003
	,1.027071170e-003
	,1.044834845e-003
	,1.062484528e-003
	,1.080053164e-003
	,1.097573215e-003
	,1.115074498e-003
	,1.132588752e-003
	,1.150147237e-003
	,1.167779499e-003
	,-2.689851138e-004
	,-2.547039152e-004
	,-2.408498738e-004
	,-2.271562298e-004
	,-2.132990659e-004
	,-1.992190850e-004
	,-1.850395305e-004
	,-1.709772107e-004
	,-1.572466486e-004
	,-1.439744515e-004
	,-1.312071148e-004
	,-1.190218696e-004
	,-1.075976734e-004
	,-9.701124654e-005
	,-8.723518311e-005
	,-7.827435480e-005
	,-7.002006942e-005
	,-6.221986326e-005
	,-5.476367832e-005
	,-4.770018292e-005
	,-4.104817258e-005
	,-3.494319302e-005
	,-2.954694380e-005
	,-2.485282440e-005
	,-2.079093149e-005
	,-1.730188985e-005
	,-1.430751348e-005
	,-1.169771711e-005
	,-9.416843218e-006
	,-7.449635120e-006
	,-5.805232607e-006
	,-4.484333814e-006
	,-3.448418300e-006
	,-2.640826281e-006
	,-2.007628888e-006
	,-1.502564803e-006
	,-1.087229209e-006
	,-7.386755611e-007
	,-4.455294511e-007
	,-2.017343066e-007
	,2.506215990e-018
	,1.687810247e-007
	,3.127312663e-007
	,4.391828383e-007
	,5.540949137e-007
	,6.620281420e-007
	,7.668022285e-007
	,8.713862116e-007
	,9.776531881e-007
	,1.086416740e-006
	,1.197366110e-006
	,1.310146970e-006
	,1.426463453e-006
	,1.548929007e-006
	,1.678866296e-006
	,1.817176535e-006
	,1.965140760e-006
	,2.122007003e-006
	,2.284843575e-006
	,2.457353847e-006
	,2.644022709e-006
	,2.845283246e-006
	,3.060394928e-006
	,3.288459062e-006
	,3.529467806e-006
	,3.784981518e-006
	,4.058024927e-006
	,4.352203896e-006
	,4.669949850e-006
	,5.011904064e-006
	,5.377655073e-006
	,5.766481334e-006
	,6.177142150e-006
	,6.606979158e-006
	,7.051241981e-006
	,7.504296185e-006
	,7.963076389e-006
	,8.429214271e-006
	,8.907272011e-006
	,9.401859633e-006
	,9.915947429e-006
	,1.045038159e-005
	,1.100379639e-005
	,1.157225754e-005
	,1.214995689e-005
	,1.273218805e-005
	,1.331675690e-005
	,1.390415250e-005
	,1.449615877e-005
	,1.509453528e-005
	,1.570126173e-005
	,1.631920761e-005
	,1.695194248e-005
	,1.760309209e-005
	,1.827591816e-005
	,1.897298555e-005
	,1.969578390e-005
	,2.044443426e-005
	,2.121763589e-005
	,2.201320593e-005
	,2.282946789e-005
	,2.366649355e-005
	,2.452573559e-005
	,2.540863081e-005
	,2.631564850e-005
	,2.724640051e-005
	,2.820050149e-005
	,2.917810842e-005
	,3.018014495e-005
	,3.120793668e-005
	,3.226265246e-005
	,3.334513768e-005
	,3.445612954e-005
	,3.559651525e-005
	,3.676731106e-005
	,3.796960733e-005
	,3.920446055e-005
	,4.047278804e-005
	,4.177546171e-005
	,4.311336309e-005
	,4.448739190e-005
	,4.589847416e-005
	,4.734762191e-005
	,4.883607920e-005
	,5.036556402e-005
	,5.193842172e-005
	,5.355764615e-005
	,5.523032132e-005
	,5.696652806e-005
	,5.877883719e-005
	,6.068307684e-005
	,6.269874107e-005
	,6.484941901e-005
	,6.716321696e-005
	,6.967304020e-005
	,7.241658641e-005
	,7.543592142e-005
	,7.877655746e-005
	,8.248603358e-005
	,8.661209558e-005
	,9.120065515e-005
	,9.629381787e-005
	,1.019282925e-004
	,1.081332657e-004
	,1.149300901e-004
	,1.223315778e-004
	,1.303420679e-004
	,1.389614648e-004
	,1.481874990e-004
	,1.580451436e-004
	,1.684891052e-004
	,1.795098557e-004
	,1.911168160e-004
	,2.032987506e-004
	,2.160201004e-004
	,2.292537156e-004
	,2.429553240e-004
	,2.570856402e-004
	,2.715730174e-004
	,2.862886444e-004
	,3.012872040e-004
	,3.165996227e-004
	,3.324185876e-004
	,3.488889130e-004
	,3.660613810e-004
	,3.839285473e-004
	,4.017486597e-004
	,4.201456078e-004
	,4.390936604e-004
	,4.585532539e-004
	,4.784837236e-004
	,4.988429103e-004
	,5.195910867e-004
	,5.406799362e-004
	,5.620576026e-004
	,5.836732674e-004
	,6.054926554e-004
	,6.274454157e-004
	,6.494761970e-004
	,6.715322622e-004
	,6.935618523e-004
	,7.155142872e-004
	,7.373419237e-004
	,7.590023854e-004
	,7.804582432e-004
	,8.016784201e-004
	,8.226409345e-004
	,8.433327773e-004
	,8.637495107e-004
	,8.833759039e-004
	,9.021490480e-004
	,9.207259733e-004
	,9.391262328e-004
	,9.573726085e-004
	,9.754901606e-004
	,9.934770561e-004
	,1.011347828e-003
	,1.029166727e-003
	,1.046961021e-003
	,1.064757522e-003
	,1.082582502e-003
	,-3.498493125e-004
	,-3.336916498e-004
	,-3.180752494e-004
	,-3.030434093e-004
	,-2.885866944e-004
	,-2.745790474e-004
	,-2.607333874e-004
	,-2.467522043e-004
	,-2.325846538e-004
	,-2.184086452e-004
	,-2.044421775e-004
	,-1.908562750e-004
	,-1.777567786e-004
	,-1.651555415e-004
	,-1.530587966e-004
	,-1.414625535e-004
	,-1.302267096e-004
	,-1.191772024e-004
	,-1.082438172e-004
	,-9.761037836e-005
	,-8.751799641e-005
	,-7.802455480e-005
	,-6.913417408e-005
	,-6.089825632e-005
	,-5.326994617e-005
	,-4.611331627e-005
	,-3.951830325e-005
	,-3.358128023e-005
	,-2.825234444e-005
	,-2.345842074e-005
	,-1.923121504e-005
	,-1.562662594e-005
	,-1.260867013e-005
	,-1.008081608e-005
	,-7.940136018e-006
	,-6.100654126e-006
	,-4.500444630e-006
	,-3.108901986e-006
	,-1.915946161e-006
	,-8.912171528e-007
	,-1.070452549e-017
	,7.713047744e-007
	,1.436881420e-006
	,2.028459509e-006
	,2.576620964e-006
	,3.102186437e-006
	,3.614599082e-006
	,4.118434293e-006
	,4.623217786e-006
	,5.143482083e-006
	,5.691395895e-006
	,6.269717922e-006
	,6.864658774e-006
	,7.452614214e-006
	,8.032186799e-006
	,8.620176929e-006
	,9.225118698e-006
	,9.844353555e-006
	,1.047471683e-005
	,1.112148482e-005
	,1.179530187e-005
	,1.250328965e-005
	,1.323907329e-005
	,1.399255934e-005
	,1.476509796e-005
	,1.554114221e-005
	,1.631262415e-005
	,1.708961010e-005
	,1.787710265e-005
	,1.868321597e-005
	,1.951520169e-005
	,2.037837478e-005
	,2.127748469e-005
	,2.221668714e-005
	,2.319917241e-005
	,2.422740972e-005
	,2.530293736e-005
	,2.642525632e-005
	,2.759051767e-005
	,2.879137739e-005
	,3.001904481e-005
	,3.126610959e-005
	,3.252763782e-005
	,3.380038581e-005
	,3.508230646e-005
	,3.637233337e-005
	,3.767018966e-005
	,3.897697081e-005
	,4.029471769e-005
	,4.162633211e-005
	,4.297801086e-005
	,4.435397524e-005
	,4.575590413e-005
	,4.718533585e-005
	,4.864401452e-005
	,5.013322034e-005
	,5.165358482e-005
	,5.320544187e-005
	,5.478905763e-005
	,5.640437518e-005
	,5.805055928e-005
	,5.972576750e-005
	,6.142726410e-005
	,6.315176996e-005
	,6.489589909e-005
	,6.665653615e-005
	,6.843095689e-005
	,7.021647378e-005
	,7.200957761e-005
	,7.380517298e-005
	,7.559808476e-005
	,7.738620939e-005
	,7.917069121e-005
	,8.095488077e-005
	,8.274241298e-005
	,8.453531650e-005
	,8.633312367e-005
	,8.813301898e-005
	,8.993102073e-005
	,9.172387611e-005
	,9.351042835e-005
	,9.529088503e-005
	,9.706488132e-005
	,9.883050245e-005
	,1.005847011e-004
	,1.023245413e-004
	,1.040482193e-004
	,1.057553162e-004
	,1.074467546e-004
	,1.091250294e-004
	,1.107945128e-004
	,1.124610881e-004
	,1.141300446e-004
	,1.158064349e-004
	,1.175015797e-004
	,1.192254952e-004
	,1.209876758e-004
	,1.227984564e-004
	,1.246696181e-004
	,1.266150296e-004
	,1.286513869e-004
	,1.307991288e-004
	,1.330840550e-004
	,1.355366819e-004
	,1.381932331e-004
	,1.410953983e-004
	,1.442890258e-004
	,1.478225426e-004
	,1.517452014e-004
	,1.561053492e-004
	,1.609488411e-004
	,1.663176939e-004
	,1.722490816e-004
	,1.787747132e-004
	,1.859206031e-004
	,1.937071766e-004
	,2.021496525e-004
	,2.112585588e-004
	,2.210403267e-004
	,2.314978573e-004
	,2.426310580e-004
	,2.544372405e-004
	,2.669114263e-004
	,2.800493148e-004
	,2.938411930e-004
	,3.082751414e-004
	,3.233403954e-004
	,3.390868519e-004
	,3.554452557e-004
	,3.723987198e-004
	,3.899285922e-004
	,4.074311587e-004
	,4.252093932e-004
	,4.434634264e-004
	,4.621437496e-004
	,4.812243744e-004
	,5.006639933e-004
	,5.204160456e-004
	,5.404394427e-004
	,5.606921087e-004
	,5.811368470e-004
	,6.017363866e-004
	,6.224327061e-004
	,6.431823546e-004
	,6.639435801e-004
	,6.846775864e-004
	,7.053496413e-004
	,7.259300896e-004
	,7.463949698e-004
	,7.667260596e-004
	,7.869138301e-004
	,8.069543240e-004
	,8.268497388e-004
	,8.453800619e-004
	,8.635487202e-004
	,8.816404712e-004
	,8.996706346e-004
	,9.176529791e-004
	,9.356065495e-004
	,9.535509791e-004
	,9.715052641e-004
	,-4.280756466e-004
	,-4.114104592e-004
	,-3.950770848e-004
	,-3.790550980e-004
	,-3.633067239e-004
	,-3.478206396e-004
	,-3.326026655e-004
	,-3.176265204e-004
	,-3.028106825e-004
	,-2.880333845e-004
	,-2.731950319e-004
	,-2.583942636e-004
	,-2.437846986e-004
	,-2.294293727e-004
	,-2.153592361e-004
	,-2.016097836e-004
	,-1.882094141e-004
	,-1.751695424e-004
	,-1.625144670e-004
	,-1.503055366e-004
	,-1.386326717e-004
	,-1.275813261e-004
	,-1.172058571e-004
	,-1.075224667e-004
	,-9.850994964e-005
	,-9.011418651e-005
	,-8.223558977e-005
	,-7.461913804e-005
	,-6.678294766e-005
	,-5.857766924e-005
	,-5.036039336e-005
	,-4.254492932e-005
	,-3.538492015e-005
	,-2.894267548e-005
	,-2.316704274e-005
	,-1.801009460e-005
	,-1.346434037e-005
	,-9.477778286e-006
	,-5.966007599e-006
	,-2.836628769e-006
	,3.393894269e-018
	,2.619382136e-006
	,5.069072707e-006
	,7.380326374e-006
	,9.578652220e-006
	,1.165994516e-005
	,1.359571352e-005
	,1.546181502e-005
	,1.733287425e-005
	,1.923355000e-005
	,2.115899996e-005
	,2.309330978e-005
	,2.502484111e-005
	,2.693420745e-005
	,2.879911561e-005
	,3.063379619e-005
	,3.247426730e-005
	,3.433429979e-005
	,3.619847920e-005
	,3.802861506e-005
	,3.981170423e-005
	,4.159951307e-005
	,4.343364633e-005
	,4.533131281e-005
	,4.729542371e-005
	,4.930714381e-005
	,5.129391046e-005
	,5.314996876e-005
	,5.490040965e-005
	,5.661600722e-005
	,5.832031836e-005
	,5.999185367e-005
	,6.158125230e-005
	,6.314625179e-005
	,6.472624545e-005
	,6.633034266e-005
	,6.796644405e-005
	,6.964608409e-005
	,7.137378406e-005
	,7.314737980e-005
	,7.496542212e-005
	,7.682863098e-005
	,7.873579624e-005
	,8.067753491e-005
	,8.263073490e-005
	,8.455945240e-005
	,8.643259454e-005
	,8.824290328e-005
	,9.000518850e-005
	,9.174263835e-005
	,9.347665589e-005
	,9.522255128e-005
	,9.698738475e-005
	,9.876933223e-005
	,1.005708728e-004
	,1.024010575e-004
	,1.042615850e-004
	,1.061471271e-004
	,1.080486751e-004
	,1.099581565e-004
	,1.118709515e-004
	,1.137832612e-004
	,1.156890003e-004
	,1.175802817e-004
	,1.194512493e-004
	,1.213006290e-004
	,1.231297074e-004
	,1.249400295e-004
	,1.267342517e-004
	,1.285173238e-004
	,1.302952353e-004
	,1.320734474e-004
	,1.338568201e-004
	,1.356494262e-004
	,1.374536998e-004
	,1.392725545e-004
	,1.411111379e-004
	,1.429737928e-004
	,1.448632786e-004
	,1.467812106e-004
	,1.487283363e-004
	,1.507046264e-004
	,1.527091520e-004
	,1.547398142e-004
	,1.567932664e-004
	,1.588653660e-004
	,1.609514131e-004
	,1.630465186e-004
	,1.651465594e-004
	,1.672487192e-004
	,1.693510297e-004
	,1.714513330e-004
	,1.735463596e-004
	,1.756313830e-004
	,1.777007831e-004
	,1.797495623e-004
	,1.817748987e-004
	,1.837761815e-004
	,1.857523238e-004
	,1.876963331e-004
	,1.896100243e-004
	,1.915028673e-004
	,1.933817203e-004
	,1.952547372e-004
	,1.971315702e-004
	,1.990237441e-004
	,2.009453903e-004
	,2.029138012e-004
	,2.049492286e-004
	,2.070750516e-004
	,2.093179458e-004
	,2.117084724e-004
	,2.142810800e-004
	,2.170738735e-004
	,2.201281300e-004
	,2.234878159e-004
	,2.271985761e-004
	,2.313061374e-004
	,2.358550622e-004
	,2.408873401e-004
	,2.464410622e-004
	,2.525494742e-004
	,2.592404550e-004
	,2.665362621e-004
	,2.744536604e-004
	,2.830042421e-004
	,2.921948987e-004
	,3.020283462e-004
	,3.125036467e-004
	,3.236194529e-004
	,3.353691720e-004
	,3.477420488e-004
	,3.607266516e-004
	,3.743092776e-004
	,3.884738186e-004
	,4.032015447e-004
	,4.184711698e-004
	,4.340371882e-004
	,4.494846724e-004
	,4.653485763e-004
	,4.815859951e-004
	,4.981630350e-004
	,5.150320479e-004
	,5.322848803e-004
	,5.497903372e-004
	,5.675794980e-004
	,5.855419490e-004
	,6.036426109e-004
	,6.218456445e-004
	,6.401242300e-004
	,6.585325909e-004
	,6.770173369e-004
	,6.955606783e-004
	,7.141611586e-004
	,7.327718507e-004
	,7.514354130e-004
	,7.701547191e-004
	,7.889330776e-004
	,8.071328264e-004
	,8.243024287e-004
	,8.415420963e-004
	,-4.895618536e-004
	,-4.730064484e-004
	,-4.564526485e-004
	,-4.400244759e-004
	,-4.238158369e-004
	,-4.078544136e-004
	,-3.921099030e-004
	,-3.765321739e-004
	,-3.610310317e-004
	,-3.454985659e-004
	,-3.298233734e-004
	,-3.139717906e-004
	,-2.980826385e-004
	,-2.823505912e-004
	,-2.669143100e-004
	,-2.518409981e-004
	,-2.371577534e-004
	,-2.228777659e-004
	,-2.090065898e-004
	,-1.955338017e-004
	,-1.824121455e-004
	,-1.696179302e-004
	,-1.572451069e-004
	,-1.453599236e-004
	,-1.340024792e-004
	,-1.231874646e-004
	,-1.129011603e-004
	,-1.030873181e-004
	,-9.360291857e-005
	,-8.421995966e-005
	,-7.480238958e-005
	,-6.548668860e-005
	,-5.647864355e-005
	,-4.784215318e-005
	,-3.964460631e-005
	,-3.197279325e-005
	,-2.481433723e-005
	,-1.810357425e-005
	,-1.176413990e-005
	,-5.735977218e-006
	,2.767297835e-018
	,5.415387348e-006
	,1.048494341e-005
	,1.524880535e-005
	,1.978793031e-005
	,2.415730696e-005
	,2.834391656e-005
	,3.232674468e-005
	,3.606019978e-005
	,3.941711968e-005
	,4.250548774e-005
	,4.549292273e-005
	,4.844199244e-005
	,5.136829557e-005
	,5.427133814e-005
	,5.715508317e-005
	,6.001263343e-005
	,6.280214325e-005
	,6.553313945e-005
	,6.825211319e-005
	,7.097696453e-005
	,7.370807478e-005
	,7.643845827e-005
	,7.915709447e-005
	,8.185171523e-005
	,8.451372954e-005
	,8.714293409e-005
	,8.974267599e-005
	,9.230963803e-005
	,9.482892593e-005
	,9.726661057e-005
	,9.956467415e-005
	,1.017374953e-004
	,1.038286068e-004
	,1.058698774e-004
	,1.078992085e-004
	,1.099212431e-004
	,1.119025491e-004
	,1.137667369e-004
	,1.155897233e-004
	,1.174361013e-004
	,1.193112060e-004
	,1.212150364e-004
	,1.231452368e-004
	,1.250957593e-004
	,1.270578096e-004
	,1.290222053e-004
	,1.309846051e-004
	,1.329465640e-004
	,1.349087116e-004
	,1.368751496e-004
	,1.388544669e-004
	,1.408497093e-004
	,1.428610110e-004
	,1.448889089e-004
	,1.469338557e-004
	,1.489923771e-004
	,1.510526263e-004
	,1.531049359e-004
	,1.551610092e-004
	,1.572319627e-004
	,1.593216379e-004
	,1.614306218e-004
	,1.635577668e-004
	,1.657007542e-004
	,1.678562020e-004
	,1.700196775e-004
	,1.721860517e-004
	,1.743503003e-004
	,1.765087035e-004
	,1.786603155e-004
	,1.808077050e-004
	,1.829554097e-004
	,1.851076826e-004
	,1.872683880e-004
	,1.894414496e-004
	,1.916296194e-004
	,1.938333539e-004
	,1.960503597e-004
	,1.982766833e-004
	,2.005121030e-004
	,2.027591479e-004
	,2.050183577e-004
	,2.072883667e-004
	,2.095665406e-004
	,2.118489505e-004
	,2.141299061e-004
	,2.164012428e-004
	,2.186519642e-004
	,2.208698534e-004
	,2.230459415e-004
	,2.251786792e-004
	,2.272744792e-004
	,2.293442898e-004
	,2.313996466e-004
	,2.334506483e-004
	,2.355053753e-004
	,2.375699771e-004
	,2.396489516e-004
	,2.417454855e-004
	,2.438618158e-004
	,2.459995260e-004
	,2.481597287e-004
	,2.503430776e-004
	,2.525491131e-004
	,2.547715848e-004
	,2.569976431e-004
	,2.592372961e-004
	,2.614975873e-004
	,2.637791553e-004
	,2.660813501e-004
	,2.684032475e-004
	,2.707441269e-004
	,2.731038489e-004
	,2.754831760e-004
	,2.778841174e-004
	,2.803108395e-004
	,2.827706124e-004
	,2.852750437e-004
	,2.878403414e-004
	,2.904879086e-004
	,2.932439669e-004
	,2.961410835e-004
	,2.992179588e-004
	,3.025172475e-004
	,3.060836927e-004
	,3.099636861e-004
	,3.142022244e-004
	,3.188364922e-004
	,3.238987944e-004
	,3.294163891e-004
	,3.354099306e-004
	,3.419021726e-004
	,3.489035139e-004
	,3.564127930e-004
	,3.644079286e-004
	,3.728452917e-004
	,3.817369863e-004
	,3.911077373e-004
	,4.009852626e-004
	,4.113905483e-004
	,4.223311822e-004
	,4.338071245e-004
	,4.458142386e-004
	,4.583328579e-004
	,4.706613886e-004
	,4.834561935e-004
	,4.966947036e-004
	,5.103541028e-004
	,5.244113365e-004
	,5.388433226e-004
	,5.536272116e-004
	,5.687407073e-004
	,5.841624077e-004
	,5.998721377e-004
	,6.158514216e-004
	,6.320904937e-004
	,6.485654010e-004
	,6.652645094e-004
	,6.821810737e-004
	,6.993160316e-004
	,-5.345840236e-004
	,-5.185617409e-004
	,-5.026560883e-004
	,-4.869356967e-004
	,-4.713202045e-004
	,-4.556489076e-004
	,-4.398047838e-004
	,-4.236701866e-004
	,-4.071216356e-004
	,-3.901384678e-004
	,-3.729236242e-004
	,-3.557584449e-004
	,-3.388375106e-004
	,-3.222462602e-004
	,-3.060051786e-004
	,-2.901022188e-004
	,-2.745232288e-004
	,-2.592742230e-004
	,-2.443668934e-004
	,-2.297987589e-004
	,-2.155530383e-004
	,-2.016289906e-004
	,-1.880742095e-004
	,-1.749390154e-004
	,-1.622290546e-004
	,-1.499088722e-004
	,-1.379186561e-004
	,-1.261787921e-004
	,-1.145990312e-004
	,-1.031382588e-004
	,-9.185375909e-005
	,-8.088498984e-005
	,-7.034108496e-005
	,-6.025340664e-005
	,-5.060275218e-005
	,-4.132677394e-005
	,-3.234763346e-005
	,-2.368632546e-005
	,-1.540844274e-005
	,-7.520226191e-006
	,-1.477740231e-017
	,7.182417266e-006
	,1.406783200e-005
	,2.070361533e-005
	,2.713632670e-005
	,3.340642951e-005
	,3.954389422e-005
	,4.556220187e-005
	,5.144518431e-005
	,5.711380122e-005
	,6.243812051e-005
	,6.742347393e-005
	,7.216748330e-005
	,7.670638258e-005
	,8.103605441e-005
	,8.516145401e-005
	,8.907966791e-005
	,9.276154730e-005
	,9.625888043e-005
	,9.969268663e-005
	,1.031288549e-004
	,1.065836634e-004
	,1.100535894e-004
	,1.135277873e-004
	,1.169930159e-004
	,1.204360021e-004
	,1.238423045e-004
	,1.271958074e-004
	,1.304866265e-004
	,1.336934624e-004
	,1.367750471e-004
	,1.396888221e-004
	,1.424754958e-004
	,1.451818148e-004
	,1.477582864e-004
	,1.501878793e-004
	,1.525658018e-004
	,1.549456504e-004
	,1.573349404e-004
	,1.597276004e-004
	,1.621152876e-004
	,1.644911874e-004
	,1.668429508e-004
	,1.690985530e-004
	,1.711518779e-004
	,1.731458620e-004
	,1.751503202e-004
	,1.771654152e-004
	,1.791804302e-004
	,1.811750813e-004
	,1.831391809e-004
	,1.850952500e-004
	,1.870591890e-004
	,1.890341260e-004
	,1.910189177e-004
	,1.930118217e-004
	,1.950124907e-004
	,1.970210832e-004
	,1.990365552e-004
	,2.010560337e-004
	,2.030729152e-004
	,2.050713210e-004
	,2.070306612e-004
	,2.089607472e-004
	,2.108837056e-004
	,2.128084407e-004
	,2.147362261e-004
	,2.166655366e-004
	,2.185978079e-004
	,2.205355117e-004
	,2.224791937e-004
	,2.244286708e-004
	,2.263835925e-004
	,2.283436347e-004
	,2.303085905e-004
	,2.322783323e-004
	,2.342525988e-004
	,2.362308955e-004
	,2.382126275e-004
	,2.401970737e-004
	,2.421832853e-004
	,2.441699574e-004
	,2.461547824e-004
	,2.481334602e-004
	,2.501023440e-004
	,2.520641252e-004
	,2.540225539e-004
	,2.559787131e-004
	,2.579326631e-004
	,2.598844734e-004
	,2.618344098e-004
	,2.637827564e-004
	,2.657295069e-004
	,2.676742050e-004
	,2.696165381e-004
	,2.715571529e-004
	,2.734969471e-004
	,2.754363765e-004
	,2.773755000e-004
	,2.793141624e-004
	,2.812521316e-004
	,2.831891855e-004
	,2.851250942e-004
	,2.870594118e-004
	,2.889913051e-004
	,2.909197050e-004
	,2.928434937e-004
	,2.947615286e-004
	,2.966725932e-004
	,2.985753313e-004
	,3.004680962e-004
	,3.023480766e-004
	,3.042058626e-004
	,3.060293934e-004
	,3.078313762e-004
	,3.096198916e-004
	,3.113986466e-004
	,3.131711951e-004
	,3.149413430e-004
	,3.167133394e-004
	,3.184920155e-004
	,3.202827393e-004
	,3.220915007e-004
	,3.239253016e-004
	,3.257926787e-004
	,3.277042260e-004
	,3.296730749e-004
	,3.317152820e-004
	,3.338500723e-004
	,3.361000348e-004
	,3.384911995e-004
	,3.410528143e-004
	,3.438167930e-004
	,3.468168497e-004
	,3.500873498e-004
	,3.536619443e-004
	,3.575720864e-004
	,3.618455407e-004
	,3.665050263e-004
	,3.715673155e-004
	,3.770451970e-004
	,3.829486817e-004
	,3.892848700e-004
	,3.960640533e-004
	,4.032972569e-004
	,4.109886874e-004
	,4.191458236e-004
	,4.277709627e-004
	,4.368647667e-004
	,4.464290447e-004
	,4.564618948e-004
	,4.669613632e-004
	,4.778224321e-004
	,4.885845326e-004
	,4.997749249e-004
	,5.113827837e-004
	,5.233982016e-004
	,5.358133583e-004
	,5.486225534e-004
	,5.618227533e-004
	,5.754142090e-004
	,-5.663412491e-004
	,-5.504772876e-004
	,-5.348498892e-004
	,-5.192629209e-004
	,-5.034855317e-004
	,-4.874147769e-004
	,-4.709885493e-004
	,-4.541648273e-004
	,-4.370150877e-004
	,-4.197635430e-004
	,-4.026203206e-004
	,-3.857103793e-004
	,-3.690684338e-004
	,-3.526693073e-004
	,-3.364765220e-004
	,-3.204492953e-004
	,-3.045446718e-004
	,-2.887681607e-004
	,-2.731592226e-004
	,-2.577234274e-004
	,-2.424878700e-004
	,-2.275369384e-004
	,-2.129083881e-004
	,-1.985916634e-004
	,-1.845724025e-004
	,-1.708116639e-004
	,-1.572558233e-004
	,-1.438983320e-004
	,-1.307916256e-004
	,-1.179987169e-004
	,-1.055625516e-004
	,-9.350232713e-005
	,-8.181877852e-005
	,-7.050914616e-005
	,-5.956543869e-005
	,-4.895682299e-005
	,-3.862620622e-005
	,-2.851605340e-005
	,-1.865170387e-005
	,-9.129905523e-006
	,4.386005287e-018
	,8.751906862e-006
	,1.716392341e-005
	,2.527992306e-005
	,3.314192413e-005
	,4.078436446e-005
	,4.822738056e-005
	,5.546512886e-005
	,6.244174719e-005
	,6.905225080e-005
	,7.527747429e-005
	,8.122354512e-005
	,8.697868290e-005
	,9.258931191e-005
	,9.807886535e-005
	,1.034561868e-004
	,1.087208719e-004
	,1.138668842e-004
	,1.188857113e-004
	,1.237749473e-004
	,1.285465893e-004
	,1.332201260e-004
	,1.378108168e-004
	,1.423255866e-004
	,1.467627867e-004
	,1.511111859e-004
	,1.553474066e-004
	,1.594379868e-004
	,1.633668199e-004
	,1.671703431e-004
	,1.709046704e-004
	,1.746033962e-004
	,1.782781493e-004
	,1.819266829e-004
	,1.855316215e-004
	,1.890518446e-004
	,1.924379628e-004
	,1.956926520e-004
	,1.988559251e-004
	,2.019476077e-004
	,2.049626026e-004
	,2.079084605e-004
	,2.107903762e-004
	,2.135954204e-004
	,2.162949090e-004
	,2.188861485e-004
	,2.214174625e-004
	,2.239148763e-004
	,2.263232958e-004
	,2.284653649e-004
	,2.304604823e-004
	,2.324721997e-004
	,2.345120485e-004
	,2.365697394e-004
	,2.386364712e-004
	,2.407066346e-004
	,2.427767662e-004
	,2.448444797e-004
	,2.469079394e-004
	,2.489656265e-004
	,2.510162223e-004
	,2.530586268e-004
	,2.550917474e-004
	,2.571128818e-004
	,2.591136121e-004
	,2.610701162e-004
	,2.629364343e-004
	,2.647067222e-004
	,2.664369682e-004
	,2.681605535e-004
	,2.698859208e-004
	,2.716136723e-004
	,2.733425420e-004
	,2.750710391e-004
	,2.767977826e-004
	,2.785214350e-004
	,2.802407133e-004
	,2.819542979e-004
	,2.836606666e-004
	,2.853597037e-004
	,2.870514224e-004
	,2.887353599e-004
	,2.904108891e-004
	,2.920771076e-004
	,2.937322197e-004
	,2.953741513e-004
	,2.970032159e-004
	,2.986179177e-004
	,3.002128386e-004
	,3.017835025e-004
	,3.033333540e-004
	,3.048665108e-004
	,3.063840584e-004
	,3.078857358e-004
	,3.093710702e-004
	,3.108397949e-004
	,3.122918253e-004
	,3.137267768e-004
	,3.151436032e-004
	,3.165416631e-004
	,3.179221290e-004
	,3.192867974e-004
	,3.206371724e-004
	,3.219745544e-004
	,3.233000934e-004
	,3.246148436e-004
	,3.259198341e-004
	,3.272161740e-004
	,3.285050931e-004
	,3.297875123e-004
	,3.310633453e-004
	,3.323319010e-004
	,3.335926622e-004
	,3.348454467e-004
	,3.360903440e-004
	,3.373276553e-004
	,3.385577930e-004
	,3.397809828e-004
	,3.409963921e-004
	,3.421982096e-004
	,3.433756509e-004
	,3.445379539e-004
	,3.456920510e-004
	,3.468393493e-004
	,3.479805808e-004
	,3.491166855e-004
	,3.502490480e-004
	,3.513796521e-004
	,3.525111435e-004
	,3.536466945e-004
	,3.547899989e-004
	,3.559458012e-004
	,3.571204236e-004
	,3.583220962e-004
	,3.595612054e-004
	,3.608506018e-004
	,3.622058701e-004
	,3.636454599e-004
	,3.651909399e-004
	,3.668671872e-004
	,3.687022637e-004
	,3.707268357e-004
	,3.729736671e-004
	,3.754769744e-004
	,3.782712376e-004
	,3.813896170e-004
	,3.848626004e-004
	,3.887174692e-004
	,3.929779278e-004
	,3.976637864e-004
	,4.027908674e-004
	,4.083712060e-004
	,4.144135219e-004
	,4.209231076e-004
	,4.279017905e-004
	,4.353492320e-004
	,4.432633356e-004
	,4.516405361e-004
	,4.604816736e-004
	,4.697881366e-004
	,4.794270132e-004
	,-5.916807707e-004
	,-5.752994469e-004
	,-5.589188527e-004
	,-5.423600240e-004
	,-5.255980180e-004
	,-5.086771422e-004
	,-4.916183971e-004
	,-4.744875006e-004
	,-4.574548664e-004
	,-4.406360995e-004
	,-4.240556414e-004
	,-4.076882003e-004
	,-3.914730848e-004
	,-3.753521813e-004
	,-3.593130110e-004
	,-3.433840863e-004
	,-3.275794504e-004
	,-3.118659202e-004
	,-2.961908278e-004
	,-2.805493083e-004
	,-2.649759720e-004
	,-2.494621193e-004
	,-2.339761152e-004
	,-2.185563221e-004
	,-2.032833063e-004
	,-1.882309129e-004
	,-1.734555353e-004
	,-1.589874346e-004
	,-1.448301713e-004
	,-1.309793785e-004
	,-1.174564963e-004
	,-1.042971822e-004
	,-9.151333779e-005
	,-7.909161359e-005
	,-6.700428453e-005
	,-5.521411344e-005
	,-4.367341779e-005
	,-3.234069452e-005
	,-2.124006075e-005
	,-1.044575753e-005
	,1.274062440e-017
	,1.008906520e-005
	,1.982822425e-005
	,2.923304167e-005
	,3.832270612e-005
	,4.710519509e-005
	,5.556144421e-005
	,6.365796049e-005
	,7.134355171e-005
	,7.862124165e-005
	,8.557855287e-005
	,9.229885473e-005
	,9.883188094e-005
	,1.052056190e-004
	,1.114391308e-004
	,1.175487098e-004
	,1.235478088e-004
	,1.294461266e-004
	,1.352497871e-004
	,1.409618677e-004
	,1.465828127e-004
	,1.521107228e-004
	,1.575416917e-004
	,1.628703765e-004
	,1.680907996e-004
	,1.731971742e-004
	,1.781849406e-004
	,1.830529860e-004
	,1.878064494e-004
	,1.924562192e-004
	,1.970144568e-004
	,2.014906259e-004
	,2.058898483e-004
	,2.102118409e-004
	,2.144484112e-004
	,2.185799721e-004
	,2.225816138e-004
	,2.264444451e-004
	,2.301767261e-004
	,2.337936712e-004
	,2.373172276e-004
	,2.407676217e-004
	,2.441570555e-004
	,2.474910085e-004
	,2.507708372e-004
	,2.539952717e-004
	,2.571610118e-004
	,2.602628554e-004
	,2.632936678e-004
	,2.662444289e-004
	,2.691039601e-004
	,2.718538120e-004
	,2.744540109e-004
	,2.768519050e-004
	,2.789098030e-004
	,2.807450948e-004
	,2.825512107e-004
	,2.843444150e-004
	,2.861105770e-004
	,2.878506345e-004
	,2.895765614e-004
	,2.912955676e-004
	,2.930093284e-004
	,2.947172448e-004
	,2.964180931e-004
	,2.981105108e-004
	,2.997928397e-004
	,3.014623831e-004
	,3.031135742e-004
	,3.047348489e-004
	,3.063122676e-004
	,3.078470893e-004
	,3.093518489e-004
	,3.108347901e-004
	,3.122993496e-004
	,3.137468903e-004
	,3.151780295e-004
	,3.165931290e-004
	,3.179923760e-004
	,3.193756405e-004
	,3.207421579e-004
	,3.220896956e-004
	,3.234145226e-004
	,3.247185546e-004
	,3.260090560e-004
	,3.272896015e-004
	,3.285609996e-004
	,3.298232324e-004
	,3.310761031e-004
	,3.323194394e-004
	,3.335530647e-004
	,3.347761275e-004
	,3.359863381e-004
	,3.371803511e-004
	,3.383546888e-004
	,3.395115669e-004
	,3.406554085e-004
	,3.417885727e-004
	,3.429119089e-004
	,3.440256543e-004
	,3.451298325e-004
	,3.462244831e-004
	,3.473092739e-004
	,3.483827766e-004
	,3.494433346e-004
	,3.504911260e-004
	,3.515283778e-004
	,3.525566743e-004
	,3.535758807e-004
	,3.545854789e-004
	,3.555851914e-004
	,3.565749171e-004
	,3.575546599e-004
	,3.585245158e-004
	,3.594846897e-004
	,3.604355137e-004
	,3.613773763e-004
	,3.623105107e-004
	,3.632349271e-004
	,3.641506411e-004
	,3.650574554e-004
	,3.659550337e-004
	,3.668433037e-004
	,3.677223337e-004
	,3.685921676e-004
	,3.694524843e-004
	,3.703007957e-004
	,3.711275391e-004
	,3.719340491e-004
	,3.727308235e-004
	,3.735205848e-004
	,3.743034820e-004
	,3.750790660e-004
	,3.758471617e-004
	,3.766080721e-004
	,3.773625904e-004
	,3.781120782e-004
	,3.788586078e-004
	,3.796051014e-004
	,3.803554684e-004
	,3.811148052e-004
	,3.818896951e-004
	,3.826884053e-004
	,3.835208644e-004
	,3.843990617e-004
	,3.853375608e-004
	,3.863537873e-004
	,3.874681748e-004
	,3.887043078e-004
	,3.900889251e-004
	,3.916516416e-004
	,3.934243025e-004
	,3.954399036e-004
	,3.977315701e-004
	,4.003318865e-004
	,4.032720604e-004
	,4.065810822e-004
	,4.102846150e-004
	,4.144045356e-004
	,4.189590302e-004
	,4.239628519e-004
	,-6.151156382e-004
	,-5.980394149e-004
	,-5.807952252e-004
	,-5.633074506e-004
	,-5.456428973e-004
	,-5.278346035e-004
	,-5.099361150e-004
	,-4.921185731e-004
	,-4.745187942e-004
	,-4.571975110e-004
	,-4.402174791e-004
	,-4.236155156e-004
	,-4.073941789e-004
	,-3.915292042e-004
	,-3.759652228e-004
	,-3.605992951e-004
	,-3.452721288e-004
	,-3.298153746e-004
	,-3.141174211e-004
	,-2.981768250e-004
	,-2.820688806e-004
	,-2.658917312e-004
	,-2.497811245e-004
	,-2.338520818e-004
	,-2.181645185e-004
	,-2.027262160e-004
	,-1.874983020e-004
	,-1.724205659e-004
	,-1.574919407e-004
	,-1.427905816e-004
	,-1.283873297e-004
	,-1.143088807e-004
	,-1.005532911e-004
	,-8.710283703e-005
	,-7.392573274e-005
	,-6.097550112e-005
	,-4.821238772e-005
	,-3.566151668e-005
	,-2.340704044e-005
	,-1.151191303e-005
	,-5.378455806e-018
	,1.112604583e-005
	,2.187510504e-005
	,3.225814740e-005
	,4.227966403e-005
	,5.193144800e-005
	,6.118656358e-005
	,7.002191570e-005
	,7.846473922e-005
	,8.657759515e-005
	,9.441518039e-005
	,1.020091791e-004
	,1.093589681e-004
	,1.164456344e-004
	,1.233042878e-004
	,1.299873584e-004
	,1.365256261e-004
	,1.429377098e-004
	,1.492363759e-004
	,1.554307455e-004
	,1.615272698e-004
	,1.675303805e-004
	,1.734430716e-004
	,1.792674007e-004
	,1.850047902e-004
	,1.906560760e-004
	,1.962213947e-004
	,2.017000395e-004
	,2.070903538e-004
	,2.123896697e-004
	,2.175942362e-004
	,2.226989621e-004
	,2.276965907e-004
	,2.325758610e-004
	,2.373191703e-004
	,2.419039906e-004
	,2.463123633e-004
	,2.505357372e-004
	,2.545711706e-004
	,2.584278964e-004
	,2.621313494e-004
	,2.657112374e-004
	,2.691906445e-004
	,2.725844196e-004
	,2.759013808e-004
	,2.791464236e-004
	,2.823217717e-004
	,2.854275870e-004
	,2.884624713e-004
	,2.914249300e-004
	,2.943164850e-004
	,2.971432717e-004
	,2.999126751e-004
	,3.026293119e-004
	,3.052938957e-004
	,3.079028886e-004
	,3.104454803e-004
	,3.128893159e-004
	,3.151266078e-004
	,3.170310909e-004
	,3.188004990e-004
	,3.205655060e-004
	,3.223300741e-004
	,3.240772145e-004
	,3.257807301e-004
	,3.274297362e-004
	,3.290441446e-004
	,3.306330993e-004
	,3.321969427e-004
	,3.337335849e-004
	,3.352393900e-004
	,3.367091523e-004
	,3.381395076e-004
	,3.395329461e-004
	,3.408934991e-004
	,3.422247749e-004
	,3.435296922e-004
	,3.448099659e-004
	,3.460665296e-004
	,3.472999733e-004
	,3.485107521e-004
	,3.496992706e-004
	,3.508659380e-004
	,3.520112062e-004
	,3.531355560e-004
	,3.542394488e-004
	,3.553233027e-004
	,3.563874994e-004
	,3.574323996e-004
	,3.584583582e-004
	,3.594657415e-004
	,3.604549441e-004
	,3.614263775e-004
	,3.623803761e-004
	,3.633170562e-004
	,3.642362134e-004
	,3.651371077e-004
	,3.660183913e-004
	,3.668795193e-004
	,3.677206592e-004
	,3.685430473e-004
	,3.693491839e-004
	,3.701407974e-004
	,3.709186271e-004
	,3.716822336e-004
	,3.724294045e-004
	,3.731621037e-004
	,3.738824648e-004
	,3.745908410e-004
	,3.752863353e-004
	,3.759678060e-004
	,3.766360292e-004
	,3.772937357e-004
	,3.779432041e-004
	,3.785855835e-004
	,3.792214349e-004
	,3.798511560e-004
	,3.804748118e-004
	,3.810923559e-004
	,3.817039469e-004
	,3.823098465e-004
	,3.829103790e-004
	,3.835059503e-004
	,3.840970934e-004
	,3.846840886e-004
	,3.852664918e-004
	,3.858438022e-004
	,3.864158402e-004
	,3.869826247e-004
	,3.875442703e-004
	,3.881009449e-004
	,3.886528422e-004
	,3.892001058e-004
	,3.897424225e-004
	,3.902766631e-004
	,3.907955262e-004
	,3.913047838e-004
	,3.918103482e-004
	,3.923130668e-004
	,3.928129958e-004
	,3.933102995e-004
	,3.938053206e-004
	,3.942986114e-004
	,3.947909816e-004
	,3.952835608e-004
	,3.957778734e-004
	,3.962759361e-004
	,3.967804018e-004
	,3.972947726e-004
	,3.978235699e-004
	,3.983722627e-004
	,3.989474088e-004
	,3.995572936e-004
	,4.002123987e-004
	,4.009256721e-004
	,4.017127842e-004
	,4.025923504e-004
	,4.035860385e-004
	,4.047184882e-004
	,4.060169791e-004
	,4.075110431e-004
	,-6.366206374e-004
	,-6.188746872e-004
	,-6.008416499e-004
	,-5.825627849e-004
	,-5.641130933e-004
	,-5.455548287e-004
	,-5.270575959e-004
	,-5.087865147e-004
	,-4.908013379e-004
	,-4.731498007e-004
	,-4.558784811e-004
	,-4.389931920e-004
	,-4.224691908e-004
	,-4.062541559e-004
	,-3.902600012e-004
	,-3.743805947e-004
	,-3.585437303e-004
	,-3.426778855e-004
	,-3.266990734e-004
	,-3.105710941e-004
	,-2.943433551e-004
	,-2.781293754e-004
	,-2.620048735e-004
	,-2.459885279e-004
	,-2.300721332e-004
	,-2.142512566e-004
	,-1.985642067e-004
	,-1.830681474e-004
	,-1.677966023e-004
	,-1.527600031e-004
	,-1.379454738e-004
	,-1.233150683e-004
	,-1.088109590e-004
	,-9.439448345e-005
	,-8.008157201e-005
	,-6.592665451e-005
	,-5.201371600e-005
	,-3.842348006e-005
	,-2.520766476e-005
	,-1.239552308e-005
	,-2.558771855e-018
	,1.198014789e-005
	,2.355011403e-005
	,3.470963376e-005
	,4.544939029e-005
	,5.575659715e-005
	,6.563564528e-005
	,7.511803445e-005
	,8.424692897e-005
	,9.306310690e-005
	,1.016013898e-004
	,1.098911847e-004
	,1.179574915e-004
	,1.258215903e-004
	,1.335013683e-004
	,1.410112624e-004
	,1.483615192e-004
	,1.555556373e-004
	,1.625826792e-004
	,1.694062018e-004
	,1.760028055e-004
	,1.824165471e-004
	,1.886941006e-004
	,1.948578110e-004
	,2.009176764e-004
	,2.068779785e-004
	,2.127393973e-004
	,2.184993687e-004
	,2.241512480e-004
	,2.296818006e-004
	,2.350667115e-004
	,2.402686913e-004
	,2.452540249e-004
	,2.500232690e-004
	,2.546066158e-004
	,2.590374549e-004
	,2.633432907e-004
	,2.675438880e-004
	,2.716513261e-004
	,2.756722199e-004
	,2.796099679e-004
	,2.834661720e-004
	,2.872414063e-004
	,2.909356402e-004
	,2.945485361e-004
	,2.980797580e-004
	,3.015293021e-004
	,3.048977147e-004
	,3.081860350e-004
	,3.113954929e-004
	,3.145271734e-004
	,3.175818154e-004
	,3.205597586e-004
	,3.234609743e-004
	,3.262851164e-004
	,3.290315498e-004
	,3.316993257e-004
	,3.342870578e-004
	,3.367926058e-004
	,3.392123131e-004
	,3.415389932e-004
	,3.437553059e-004
	,3.458079529e-004
	,3.475708537e-004
	,3.490938980e-004
	,3.505742071e-004
	,3.520521197e-004
	,3.535200043e-004
	,3.549679924e-004
	,3.563886876e-004
	,3.577767758e-004
	,3.591283349e-004
	,3.604403529e-004
	,3.617104222e-004
	,3.629363059e-004
	,3.641141321e-004
	,3.652338452e-004
	,3.662928391e-004
	,3.673104008e-004
	,3.682980331e-004
	,3.692594689e-004
	,3.701962809e-004
	,3.711092316e-004
	,3.719984293e-004
	,3.728631965e-004
	,3.737026643e-004
	,3.745181720e-004
	,3.753134681e-004
	,3.760916559e-004
	,3.768543716e-004
	,3.776024483e-004
	,3.783363959e-004
	,3.790566104e-004
	,3.797634545e-004
	,3.804572834e-004
	,3.811384541e-004
	,3.818073303e-004
	,3.824642770e-004
	,3.831096378e-004
	,3.837437118e-004
	,3.843667414e-004
	,3.849788920e-004
	,3.855801910e-004
	,3.861703890e-004
	,3.867487942e-004
	,3.873147423e-004
	,3.878691472e-004
	,3.884140998e-004
	,3.889509945e-004
	,3.894803141e-004
	,3.900020544e-004
	,3.905159992e-004
	,3.910221698e-004
	,3.915208165e-004
	,3.920116629e-004
	,3.924936318e-004
	,3.929645649e-004
	,3.934207115e-004
	,3.938623736e-004
	,3.942951950e-004
	,3.947213038e-004
	,3.951411654e-004
	,3.955547204e-004
	,3.959615542e-004
	,3.963608288e-004
	,3.967515533e-004
	,3.971329934e-004
	,3.975049234e-004
	,3.978677221e-004
	,3.982222930e-004
	,3.985698744e-004
	,3.989116893e-004
	,3.992486862e-004
	,3.995817268e-004
	,3.999115647e-004
	,4.002388428e-004
	,4.005641296e-004
	,4.008879584e-004
	,4.012108686e-004
	,4.015334388e-004
	,4.018559616e-004
	,4.021776188e-004
	,4.024949184e-004
	,4.028031748e-004
	,4.031074360e-004
	,4.034110359e-004
	,4.037146726e-004
	,4.040186342e-004
	,4.043232209e-004
	,4.046288456e-004
	,4.049360862e-004
	,4.052457305e-004
	,4.055587971e-004
	,4.058765319e-004
	,4.062003764e-004
	,4.065319290e-004
	,4.068733088e-004
	,4.072274415e-004
	,4.075981825e-004
	,4.079905023e-004
	,4.084107288e-004
	,-6.559042525e-004
	,-6.374811685e-004
	,-6.187598862e-004
	,-5.998612917e-004
	,-5.808510129e-004
	,-5.618611480e-004
	,-5.430793550e-004
	,-5.245930115e-004
	,-5.064208994e-004
	,-4.886054311e-004
	,-4.711648353e-004
	,-4.540724621e-004
	,-4.372639426e-004
	,-4.206336327e-004
	,-4.040689761e-004
	,-3.875108851e-004
	,-3.708996410e-004
	,-3.541676137e-004
	,-3.373428740e-004
	,-3.205421000e-004
	,-3.038977866e-004
	,-2.874731140e-004
	,-2.712545968e-004
	,-2.551899070e-004
	,-2.392497265e-004
	,-2.234325714e-004
	,-2.077190919e-004
	,-1.920774383e-004
	,-1.764913258e-004
	,-1.609593906e-004
	,-1.454850252e-004
	,-1.300708908e-004
	,-1.147146004e-004
	,-9.944821327e-005
	,-8.434745239e-005
	,-6.948156433e-005
	,-5.489142997e-005
	,-4.060714236e-005
	,-2.667164832e-005
	,-1.312812262e-005
	,4.789285239e-015
	,1.270113776e-005
	,2.496444141e-005
	,3.678099615e-005
	,4.815156088e-005
	,5.909098689e-005
	,6.962458730e-005
	,7.978150458e-005
	,8.959067500e-005
	,9.907937004e-005
	,1.082728282e-004
	,1.171944632e-004
	,1.258658729e-004
	,1.343067485e-004
	,1.425349108e-004
	,1.505663029e-004
	,1.584149775e-004
	,1.660930877e-004
	,1.736108605e-004
	,1.809765052e-004
	,1.881959727e-004
	,1.952724338e-004
	,2.022052006e-004
	,2.089874079e-004
	,2.156006715e-004
	,2.220037042e-004
	,2.281243513e-004
	,2.339110983e-004
	,2.394026398e-004
	,2.446758931e-004
	,2.497869690e-004
	,2.547654209e-004
	,2.596241219e-004
	,2.643679411e-004
	,2.690009640e-004
	,2.735301127e-004
	,2.779631651e-004
	,2.823059184e-004
	,2.865616796e-004
	,2.907319342e-004
	,2.948170301e-004
	,2.988166213e-004
	,3.027299299e-004
	,3.065559029e-004
	,3.102933137e-004
	,3.139408334e-004
	,3.174970876e-004
	,3.209607045e-004
	,3.243303574e-004
	,3.276048029e-004
	,3.307829129e-004
	,3.338636968e-004
	,3.368463135e-004
	,3.397300677e-004
	,3.425143901e-004
	,3.451987933e-004
	,3.477827830e-004
	,3.502656794e-004
	,3.526462836e-004
	,3.549224353e-004
	,3.570910521e-004
	,3.591502155e-004
	,3.611032209e-004
	,3.629586963e-004
	,3.647243705e-004
	,3.664001968e-004
	,3.679680966e-004
	,3.693659442e-004
	,3.705469437e-004
	,3.716458031e-004
	,3.727391397e-004
	,3.738268268e-004
	,3.748996100e-004
	,3.759503091e-004
	,3.769745024e-004
	,3.779703219e-004
	,3.789377126e-004
	,3.798772912e-004
	,3.807895961e-004
	,3.816748813e-004
	,3.825331280e-004
	,3.833640579e-004
	,3.841670624e-004
	,3.849409762e-004
	,3.856838033e-004
	,3.863926995e-004
	,3.870643335e-004
	,3.876947484e-004
	,3.882795326e-004
	,3.888260923e-004
	,3.893481683e-004
	,3.898527328e-004
	,3.903432167e-004
	,3.908217044e-004
	,3.912895945e-004
	,3.917478468e-004
	,3.921970751e-004
	,3.926375507e-004
	,3.930692740e-004
	,3.934925425e-004
	,3.939084870e-004
	,3.943183463e-004
	,3.947228843e-004
	,3.951225163e-004
	,3.955174959e-004
	,3.959080045e-004
	,3.962941801e-004
	,3.966761110e-004
	,3.970538015e-004
	,3.974271005e-004
	,3.977955979e-004
	,3.981587454e-004
	,3.985166803e-004
	,3.988705214e-004
	,3.992212845e-004
	,3.995694501e-004
	,3.999151923e-004
	,4.002585618e-004
	,4.005995530e-004
	,4.009381052e-004
	,4.012740563e-004
	,4.016070369e-004
	,4.019363624e-004
	,4.022612864e-004
	,4.025817791e-004
	,4.028986441e-004
	,4.032127157e-004
	,4.035244056e-004
	,4.038338313e-004
	,4.041405293e-004
	,4.044438908e-004
	,4.047454783e-004
	,4.050459457e-004
	,4.053454055e-004
	,4.056439169e-004
	,4.059415629e-004
	,4.062384863e-004
	,4.065349211e-004
	,4.068311565e-004
	,4.071273404e-004
	,4.074233777e-004
	,4.077191246e-004
	,4.080145272e-004
	,4.083096247e-004
	,4.086045521e-004
	,4.088994620e-004
	,4.091942585e-004
	,4.094888172e-004
	,4.097829190e-004
	,4.100755667e-004
	,4.103623539e-004
	,4.106405476e-004
	,4.109164990e-004
	,4.111928104e-004
	,4.114700755e-004
	,4.117486735e-004
	,4.120290033e-004
	,4.123111750e-004
	,4.125950453e-004
	,4.128806977e-004
	,4.131685479e-004
	,-6.726945260e-004
	,-6.537153381e-004
	,-6.345220012e-004
	,-6.151983239e-004
	,-5.958412655e-004
	,-5.766417797e-004
	,-5.577382691e-004
	,-5.391498487e-004
	,-5.208839911e-004
	,-5.029723061e-004
	,-4.853992911e-004
	,-4.680962371e-004
	,-4.509450255e-004
	,-4.338237838e-004
	,-4.166772714e-004
	,-3.994611314e-004
	,-3.821182166e-004
	,-3.646828614e-004
	,-3.472897597e-004
	,-3.300754905e-004
	,-3.130931821e-004
	,-2.963174581e-004
	,-2.797165424e-004
	,-2.632905508e-004
	,-2.470307787e-004
	,-2.309060144e-004
	,-2.148722419e-004
	,-1.988851690e-004
	,-1.829075903e-004
	,-1.668917489e-004
	,-1.508086017e-004
	,-1.347094201e-004
	,-1.186981118e-004
	,-1.028637789e-004
	,-8.726120542e-005
	,-7.191943082e-005
	,-5.686015601e-005
	,-4.211449087e-005
	,-2.771095874e-005
	,-1.366729949e-005
	,9.180158221e-016
	,1.326983708e-005
	,2.612101799e-005
	,3.854092175e-005
	,5.053180894e-005
	,6.210837036e-005
	,7.329066291e-005
	,8.409998838e-005
	,9.455745415e-005
	,1.046835580e-004
	,1.144980704e-004
	,1.240199757e-004
	,1.332673999e-004
	,1.422575072e-004
	,1.510063653e-004
	,1.595287781e-004
	,1.678380685e-004
	,1.759457686e-004
	,1.838611176e-004
	,1.915901548e-004
	,1.991338653e-004
	,2.064847154e-004
	,2.136204687e-004
	,2.204992777e-004
	,2.270880192e-004
	,2.334095812e-004
	,2.395163484e-004
	,2.454470576e-004
	,2.512231768e-004
	,2.568556536e-004
	,2.623487538e-004
	,2.677008898e-004
	,2.729028543e-004
	,2.779346357e-004
	,2.827753990e-004
	,2.874359511e-004
	,2.919510693e-004
	,2.963462174e-004
	,3.006336391e-004
	,3.048184613e-004
	,3.089024533e-004
	,3.128857393e-004
	,3.167675900e-004
	,3.205468232e-004
	,3.242220278e-004
	,3.277917021e-004
	,3.312543422e-004
	,3.346084967e-004
	,3.378527851e-004
	,3.409858681e-004
	,3.440063360e-004
	,3.469124494e-004
	,3.497016222e-004
	,3.523696171e-004
	,3.549103095e-004
	,3.573194171e-004
	,3.596027669e-004
	,3.617758063e-004
	,3.638531165e-004
	,3.658438930e-004
	,3.677533893e-004
	,3.695847923e-004
	,3.713402188e-004
	,3.730210603e-004
	,3.746278692e-004
	,3.761597184e-004
	,3.776125969e-004
	,3.789761121e-004
	,3.802308277e-004
	,3.813613866e-004
	,3.823780047e-004
	,3.832884529e-004
	,3.840634802e-004
	,3.847359175e-004
	,3.853947104e-004
	,3.860567254e-004
	,3.867171746e-004
	,3.873715677e-004
	,3.880172234e-004
	,3.886526751e-004
	,3.892771464e-004
	,3.898902339e-004
	,3.904917295e-004
	,3.910815232e-004
	,3.916595518e-004
	,3.922257904e-004
	,3.927802989e-004
	,3.933232952e-004
	,3.938551958e-004
	,3.943766064e-004
	,3.948882217e-004
	,3.953906754e-004
	,3.958844639e-004
	,3.963699529e-004
	,3.968474053e-004
	,3.973169904e-004
	,3.977787417e-004
	,3.982323747e-004
	,3.986766059e-004
	,3.991072873e-004
	,3.995204030e-004
	,3.999214328e-004
	,4.003156531e-004
	,4.007048151e-004
	,4.010894880e-004
	,4.014699060e-004
	,4.018461931e-004
	,4.022184285e-004
	,4.025866637e-004
	,4.029509153e-004
	,4.033111375e-004
	,4.036671817e-004
	,4.040188624e-004
	,4.043663034e-004
	,4.047099683e-004
	,4.050501066e-004
	,4.053865027e-004
	,4.057186180e-004
	,4.060462913e-004
	,4.063703663e-004
	,4.066919270e-004
	,4.070115955e-004
	,4.073296210e-004
	,4.076460786e-004
	,4.079609691e-004
	,4.082742483e-004
	,4.085857998e-004
	,4.088953488e-004
	,4.092023637e-004
	,4.095061471e-004
	,4.098063150e-004
	,4.101031305e-004
	,4.103971567e-004
	,4.106888776e-004
	,4.109786391e-004
	,4.112667112e-004
	,4.115533486e-004
	,4.118388206e-004
	,4.121233942e-004
	,4.124072944e-004
	,4.126904799e-004
	,4.129724695e-004
	,4.132524439e-004
	,4.135311790e-004
	,4.138092817e-004
	,4.140868548e-004
	,4.143639353e-004
	,4.146405587e-004
	,4.149167715e-004
	,4.151926385e-004
	,4.154682545e-004
	,4.157437657e-004
	,4.160194051e-004
	,4.162955064e-004
	,4.165723530e-004
	,4.168498842e-004
	,4.171275777e-004
	,4.174036965e-004
	,4.176724372e-004
	,4.179334189e-004
	,4.181932630e-004
	,-6.876430281e-004
	,-6.682348123e-004
	,-6.486546772e-004
	,-6.289945008e-004
	,-6.094217167e-004
	,-5.901172631e-004
	,-5.711422650e-004
	,-5.524730426e-004
	,-5.341224561e-004
	,-5.160984722e-004
	,-4.983420125e-004
	,-4.807324710e-004
	,-4.631417221e-004
	,-4.455159554e-004
	,-4.278251689e-004
	,-4.100178631e-004
	,-3.920924552e-004
	,-3.741631752e-004
	,-3.563643902e-004
	,-3.387510714e-004
	,-3.213283562e-004
	,-3.041167228e-004
	,-2.871335477e-004
	,-2.703589607e-004
	,-2.537433679e-004
	,-2.372331740e-004
	,-2.207685752e-004
	,-2.042637096e-004
	,-1.876426983e-004
	,-1.709351926e-004
	,-1.542633368e-004
	,-1.377351446e-004
	,-1.214065584e-004
	,-1.052959326e-004
	,-8.940392189e-005
	,-7.373690158e-005
	,-5.832862386e-005
	,-4.322207191e-005
	,-2.844949111e-005
	,-1.403557984e-005
	,2.813416290e-016
	,1.364768566e-005
	,2.691236157e-005
	,3.980760742e-005
	,5.234722815e-005
	,6.453815762e-005
	,7.637544439e-005
	,8.784705164e-005
	,9.895086307e-005
	,1.097003476e-004
	,1.201149224e-004
	,1.302134271e-004
	,1.400129135e-004
	,1.495288507e-004
	,1.587752663e-004
	,1.677645548e-004
	,1.765068241e-004
	,1.850084275e-004
	,1.932687648e-004
	,2.012736256e-004
	,2.089871084e-004
	,2.163694589e-004
	,2.234337677e-004
	,2.302363825e-004
	,2.368241471e-004
	,2.432250401e-004
	,2.494555980e-004
	,2.555260087e-004
	,2.614425046e-004
	,2.672085709e-004
	,2.728259230e-004
	,2.782962091e-004
	,2.836241102e-004
	,2.888166886e-004
	,2.938804768e-004
	,2.988189358e-004
	,3.036319369e-004
	,3.083163998e-004
	,3.128666543e-004
	,3.172737680e-004
	,3.215234857e-004
	,3.255948280e-004
	,3.294700754e-004
	,3.331561768e-004
	,3.366779611e-004
	,3.400547872e-004
	,3.432959233e-004
	,3.464041478e-004
	,3.493778788e-004
	,3.522116085e-004
	,3.548985040e-004
	,3.574405212e-004
	,3.598537708e-004
	,3.621563028e-004
	,3.643595189e-004
	,3.664693435e-004
	,3.684886319e-004
	,3.704180632e-004
	,3.722553013e-004
	,3.739912726e-004
	,3.756018852e-004
	,3.770534823e-004
	,3.783586497e-004
	,3.795697449e-004
	,3.807198989e-004
	,3.818226528e-004
	,3.828833900e-004
	,3.839046135e-004
	,3.848883635e-004
	,3.858371750e-004
	,3.867538281e-004
	,3.876406435e-004
	,3.884989386e-004
	,3.893284441e-004
	,3.901257300e-004
	,3.908787056e-004
	,3.915508991e-004
	,3.921169703e-004
	,3.926610859e-004
	,3.932200718e-004
	,3.937886121e-004
	,3.943600627e-004
	,3.949301074e-004
	,3.954960405e-004
	,3.960561437e-004
	,3.966093201e-004
	,3.971548769e-004
	,3.976923848e-004
	,3.982215933e-004
	,3.987424096e-004
	,3.992549355e-004
	,3.997594688e-004
	,4.002563778e-004
	,4.007459601e-004
	,4.012284084e-004
	,4.017038430e-004
	,4.021723464e-004
	,4.026339817e-004
	,4.030887967e-004
	,4.035368221e-004
	,4.039780725e-004
	,4.044125710e-004
	,4.048404154e-004
	,4.052618519e-004
	,4.056772548e-004
	,4.060870112e-004
	,4.064914195e-004
	,4.068906391e-004
	,4.072846136e-004
	,4.076727867e-004
	,4.080530723e-004
	,4.084206680e-004
	,4.087753071e-004
	,4.091228986e-004
	,4.094665258e-004
	,4.098071517e-004
	,4.101451022e-004
	,4.104805005e-004
	,4.108133863e-004
	,4.111437448e-004
	,4.114714963e-004
	,4.117964493e-004
	,4.121182130e-004
	,4.124361456e-004
	,4.127497225e-004
	,4.130593388e-004
	,4.133660773e-004
	,4.136708805e-004
	,4.139743413e-004
	,4.142767159e-004
	,4.145780520e-004
	,4.148782940e-004
	,4.151773148e-004
	,4.154748990e-004
	,4.157706976e-004
	,4.160642297e-004
	,4.163550843e-004
	,4.166432290e-004
	,4.169289780e-004
	,4.172127126e-004
	,4.174947441e-004
	,4.177753108e-004
	,4.180545836e-004
	,4.183326643e-004
	,4.186096057e-004
	,4.188854443e-004
	,4.191602190e-004
	,4.194339770e-004
	,4.197067765e-004
	,4.199786908e-004
	,4.202498369e-004
	,4.205204026e-004
	,4.207907007e-004
	,4.210609386e-004
	,4.213304735e-004
	,4.215995170e-004
	,4.218684152e-004
	,4.221371013e-004
	,4.224054566e-004
	,4.226733241e-004
	,4.229404617e-004
	,-7.013750009e-004
	,-6.815803223e-004
	,-6.616594988e-004
	,-6.417550623e-004
	,-6.220606144e-004
	,-6.026953919e-004
	,-5.836512693e-004
	,-5.648908863e-004
	,-5.464283274e-004
	,-5.282303344e-004
	,-5.101841761e-004
	,-4.921547226e-004
	,-4.740761943e-004
	,-4.559109691e-004
	,-4.376039402e-004
	,-4.191401452e-004
	,-4.006230445e-004
	,-3.822202547e-004
	,-3.640324316e-004
	,-3.460849997e-004
	,-3.283882483e-004
	,-3.109336754e-004
	,-2.936928269e-004
	,-2.766369250e-004
	,-2.597167826e-004
	,-2.428260583e-004
	,-2.258138298e-004
	,-2.086045423e-004
	,-1.912929055e-004
	,-1.740382641e-004
	,-1.569522963e-004
	,-1.400887892e-004
	,-1.234641106e-004
	,-1.070733548e-004
	,-9.090962508e-005
	,-7.499033403e-005
	,-5.934646758e-005
	,-4.400300211e-005
	,-2.898277974e-005
	,-1.430886118e-005
	,1.974821396e-016
	,1.393802314e-005
	,2.751284246e-005
	,4.073912920e-005
	,5.363365823e-005
	,6.621251321e-005
	,7.848934482e-005
	,9.047383288e-005
	,1.021695764e-004
	,1.135708365e-004
	,1.246597428e-004
	,1.354120281e-004
	,1.458158591e-004
	,1.558808359e-004
	,1.656252415e-004
	,1.750631495e-004
	,1.841978599e-004
	,1.930140033e-004
	,2.014710868e-004
	,2.095383948e-004
	,2.172516697e-004
	,2.246737004e-004
	,2.318490333e-004
	,2.388048994e-004
	,2.455588796e-004
	,2.521229660e-004
	,2.585053689e-004
	,2.647113187e-004
	,2.707435269e-004
	,2.766028922e-004
	,2.822902177e-004
	,2.878091300e-004
	,2.931679042e-004
	,2.983770318e-004
	,3.034445842e-004
	,3.083740724e-004
	,3.131651842e-004
	,3.178153093e-004
	,3.223207166e-004
	,3.266772296e-004
	,3.308804310e-004
	,3.349259679e-004
	,3.388103551e-004
	,3.425295589e-004
	,3.460780004e-004
	,3.494467940e-004
	,3.526229357e-004
	,3.555996721e-004
	,3.583913235e-004
	,3.610170701e-004
	,3.634842317e-004
	,3.657964625e-004
	,3.679635224e-004
	,3.699919803e-004
	,3.718657769e-004
	,3.735454779e-004
	,3.750444560e-004
	,3.764310958e-004
	,3.777468787e-004
	,3.790080920e-004
	,3.802212820e-004
	,3.813891894e-004
	,3.825131930e-004
	,3.835950086e-004
	,3.846376108e-004
	,3.856447728e-004
	,3.866200797e-004
	,3.875664560e-004
	,3.884861856e-004
	,3.893810775e-004
	,3.902526090e-004
	,3.911020177e-004
	,3.919303510e-004
	,3.927384833e-004
	,3.935271015e-004
	,3.942966466e-004
	,3.950471696e-004
	,3.957779811e-004
	,3.964867003e-004
	,3.971662011e-004
	,3.977931260e-004
	,3.983117355e-004
	,3.987699376e-004
	,3.992513065e-004
	,3.997527920e-004
	,4.002644191e-004
	,4.007801561e-004
	,4.012964093e-004
	,4.018109152e-004
	,4.023221633e-004
	,4.028290887e-004
	,4.033309110e-004
	,4.038270768e-004
	,4.043172916e-004
	,4.048015594e-004
	,4.052800996e-004
	,4.057531602e-004
	,4.062209008e-004
	,4.066833890e-004
	,4.071406462e-004
	,4.075926866e-004
	,4.080395381e-004
	,4.084812477e-004
	,4.089178775e-004
	,4.093495000e-004
	,4.097761932e-004
	,4.101980380e-004
	,4.106151158e-004
	,4.110275076e-004
	,4.114352924e-004
	,4.118385461e-004
	,4.122373399e-004
	,4.126317377e-004
	,4.130217928e-004
	,4.134075446e-004
	,4.137890196e-004
	,4.141662494e-004
	,4.145393067e-004
	,4.149083181e-004
	,4.152733789e-004
	,4.156343428e-004
	,4.159903153e-004
	,4.163382950e-004
	,4.166740145e-004
	,4.170001696e-004
	,4.173215894e-004
	,4.176400689e-004
	,4.179559782e-004
	,4.182690970e-004
	,4.185787765e-004
	,4.188841285e-004
	,4.191847468e-004
	,4.194810276e-004
	,4.197729817e-004
	,4.200593792e-004
	,4.203383854e-004
	,4.206094320e-004
	,4.208740676e-004
	,4.211344576e-004
	,4.213921106e-004
	,4.216477914e-004
	,4.219017965e-004
	,4.221541751e-004
	,4.224049637e-004
	,4.226543346e-004
	,4.229025219e-004
	,4.231497209e-004
	,4.233960684e-004
	,4.236416607e-004
	,4.238865735e-004
	,4.241308758e-004
	,4.243746354e-004
	,4.246179174e-004
	,4.248607821e-004
	,4.251032882e-004
	,4.253455033e-004
	,4.255875075e-004
	,4.258293785e-004
	,4.260711634e-004
	,4.263128720e-004
	,4.265544981e-004
	,-7.142165849e-004
	,-6.940730996e-004
	,-6.738796437e-004
	,-6.538167613e-004
	,-6.340507333e-004
	,-6.146260997e-004
	,-5.954812528e-004
	,-5.765759503e-004
	,-5.578877309e-004
	,-5.393068417e-004
	,-5.207055930e-004
	,-5.020539626e-004
	,-4.833659843e-004
	,-4.646313960e-004
	,-4.458212419e-004
	,-4.269406771e-004
	,-4.081048678e-004
	,-3.894388667e-004
	,-3.709997484e-004
	,-3.528087372e-004
	,-3.348731927e-004
	,-3.171960664e-004
	,-2.997562115e-004
	,-2.824787977e-004
	,-2.652082645e-004
	,-2.477409745e-004
	,-2.300049333e-004
	,-2.121410768e-004
	,-1.943330640e-004
	,-1.766983878e-004
	,-1.592932808e-004
	,-1.421363226e-004
	,-1.252233251e-004
	,-1.085436492e-004
	,-9.211035598e-005
	,-7.595609853e-005
	,-6.010485815e-005
	,-4.457235375e-005
	,-2.937099990e-005
	,-1.451161514e-005
	,1.334126543e-016
	,1.416671300e-005
	,2.799643819e-005
	,4.149902807e-005
	,5.468564823e-005
	,6.756837015e-005
	,8.015926462e-005
	,9.246941392e-005
	,1.045081255e-004
	,1.162822675e-004
	,1.277954669e-004
	,1.390467817e-004
	,1.500282725e-004
	,1.607208231e-004
	,1.710886352e-004
	,1.810761681e-004
	,1.906138865e-004
	,1.996570162e-004
	,2.082478108e-004
	,2.164679352e-004
	,2.243765521e-004
	,2.320106058e-004
	,2.393946671e-004
	,2.465461945e-004
	,2.534780036e-004
	,2.601994247e-004
	,2.667168178e-004
	,2.730338008e-004
	,2.791515407e-004
	,2.850697351e-004
	,2.907891618e-004
	,2.963154736e-004
	,3.016605319e-004
	,3.068380875e-004
	,3.118579615e-004
	,3.167241179e-004
	,3.214360222e-004
	,3.259906030e-004
	,3.303836394e-004
	,3.346104921e-004
	,3.386662965e-004
	,3.425455628e-004
	,3.462408154e-004
	,3.497402712e-004
	,3.530306707e-004
	,3.561169758e-004
	,3.590259445e-004
	,3.617788312e-004
	,3.643823280e-004
	,3.668275049e-004
	,3.690733521e-004
	,3.710529783e-004
	,3.728099423e-004
	,3.744400456e-004
	,3.759848678e-004
	,3.774588581e-004
	,3.788674674e-004
	,3.802121691e-004
	,3.814924379e-004
	,3.827078333e-004
	,3.838601033e-004
	,3.849546929e-004
	,3.860003950e-004
	,3.870060351e-004
	,3.879781240e-004
	,3.889209868e-004
	,3.898375731e-004
	,3.907300468e-004
	,3.916001149e-004
	,3.924492013e-004
	,3.932785401e-004
	,3.940892272e-004
	,3.948822500e-004
	,3.956585040e-004
	,3.964188016e-004
	,3.971638762e-004
	,3.978943792e-004
	,3.986108717e-004
	,3.993138045e-004
	,4.000034784e-004
	,4.006799623e-004
	,4.013429145e-004
	,4.019911463e-004
	,4.026213773e-004
	,4.032237734e-004
	,4.037618957e-004
	,4.041702725e-004
	,4.045695540e-004
	,4.050079678e-004
	,4.054678831e-004
	,4.059387673e-004
	,4.064149795e-004
	,4.068931832e-004
	,4.073712105e-004
	,4.078475498e-004
	,4.083211398e-004
	,4.087913488e-004
	,4.092580004e-004
	,4.097212549e-004
	,4.101813558e-004
	,4.106384464e-004
	,4.110925382e-004
	,4.115435541e-004
	,4.119913752e-004
	,4.124358694e-004
	,4.128769057e-004
	,4.133143578e-004
	,4.137481014e-004
	,4.141780063e-004
	,4.146039211e-004
	,4.150256433e-004
	,4.154428571e-004
	,4.158549888e-004
	,4.162608408e-004
	,4.166576615e-004
	,4.170397556e-004
	,4.174018074e-004
	,4.177477083e-004
	,4.180849263e-004
	,4.184175509e-004
	,4.187472772e-004
	,4.190748226e-004
	,4.194005133e-004
	,4.197245059e-004
	,4.200468759e-004
	,4.203676571e-004
	,4.206868589e-004
	,4.210044724e-004
	,4.213204701e-004
	,4.216347970e-004
	,4.219473489e-004
	,4.222579185e-004
	,4.225660350e-004
	,4.228704123e-004
	,4.231676225e-004
	,4.234542165e-004
	,4.237327654e-004
	,4.240065040e-004
	,4.242775541e-004
	,4.245476198e-004
	,4.248176299e-004
	,4.250879007e-004
	,4.253584577e-004
	,4.256292116e-004
	,4.259000231e-004
	,4.261707154e-004
	,4.264410594e-004
	,4.267107589e-004
	,4.269794841e-004
	,4.272469938e-004
	,4.275132399e-004
	,4.277783179e-004
	,4.280423597e-004
	,4.283054944e-004
	,4.285678613e-004
	,4.288295834e-004
	,4.290907154e-004
	,4.293512672e-004
	,4.296112409e-004
	,4.298706399e-004
	,4.301294707e-004
	,-2.606513946e-006
	,-2.119615552e-006
	,-1.714940221e-006
	,-1.382434649e-006
	,-1.110258523e-006
	,-8.859936058e-007
	,-7.022642536e-007
	,-5.548894779e-007
	,-4.381931809e-007
	,-3.457571291e-007
	,-2.723025223e-007
	,-2.138402221e-007
	,-1.672293336e-007
	,-1.301269738e-007
	,-1.007871963e-007
	,-7.783538962e-008
	,-6.006499305e-008
	,-4.639010385e-008
	,-3.587604851e-008
	,-2.776762992e-008
	,-2.148586578e-008
	,-1.659948945e-008
	,-1.279371733e-008
	,-9.836494844e-009
	,-7.541244000e-009
	,-5.762389656e-009
	,-4.385826976e-009
	,-3.322248168e-009
	,-2.505529147e-009
	,-1.883630248e-009
	,-1.412728473e-009
	,-1.056712381e-009
	,-7.871283296e-010
	,-5.822598992e-010
	,-4.258042436e-010
	,-3.055443466e-010
	,-2.124232093e-010
	,-1.398223786e-010
	,-8.270590305e-011
	,-3.711863107e-011
	,1.185294614e-017
	,3.101927647e-011
	,5.777509181e-011
	,8.165101386e-011
	,1.036320762e-010
	,1.243991740e-010
	,1.444999552e-010
	,1.644120419e-010
	,1.844853960e-010
	,2.049541814e-010
	,2.260672666e-010
	,2.482155558e-010
	,2.718691703e-010
	,2.974641970e-010
	,3.253691147e-010
	,3.558801708e-010
	,3.892154812e-010
	,4.255783034e-010
	,4.652985079e-010
	,5.088263415e-010
	,5.566485238e-010
	,6.093179207e-010
	,6.674917545e-010
	,7.319146617e-010
	,8.034200192e-010
	,8.829487227e-010
	,9.715647831e-010
	,1.070457243e-009
	,1.180912218e-009
	,1.304209311e-009
	,1.441504876e-009
	,1.593888883e-009
	,1.763189903e-009
	,1.952867214e-009
	,2.167657594e-009
	,2.413024090e-009
	,2.695048974e-009
	,3.019698802e-009
	,3.392982625e-009
	,3.819061843e-009
	,4.300934801e-009
	,4.849160721e-009
	,5.487291318e-009
	,6.241254353e-009
	,7.140924486e-009
	,8.224002169e-009
	,9.537698258e-009
	,1.112717405e-008
	,1.306884249e-008
	,1.545176613e-008
	,1.838566865e-008
	,2.199031220e-008
	,2.643137585e-008
	,3.193450616e-008
	,3.877350159e-008
	,4.728928332e-008
	,5.789858398e-008
	,7.099372062e-008
	,8.725828623e-008
	,1.075317072e-007
	,1.328987428e-007
	,1.646510051e-007
	,2.033224310e-007
	,2.508916149e-007
	,3.074431820e-007
	,3.749521672e-007
	,4.534043857e-007
	,5.492833021e-007
	,6.670060556e-007
	,8.117405655e-007
	,9.897706633e-007
	,1.208832869e-006
	,1.478479034e-006
	,1.810498989e-006
	,2.219339964e-006
	,2.715679994e-006
	,3.322055206e-006
	,4.048264986e-006
	,4.932178263e-006
	,6.008265865e-006
	,7.316981043e-006
	,8.899205599e-006
	,1.074831948e-005
	,1.276544730e-005
	,1.503700169e-005
	,1.745036330e-005
	,2.025385837e-005
	,2.351748291e-005
	,2.730688069e-005
	,3.169316335e-005
	,3.675528147e-005
	,4.258021337e-005
	,4.926078415e-005
	,5.688678469e-005
	,6.537589308e-005
	,7.492755953e-005
	,8.559231799e-005
	,9.731062597e-005
	,1.102523509e-004
	,1.244284622e-004
	,1.397572461e-004
	,1.555691818e-004
	,1.723261218e-004
	,1.895767480e-004
	,2.060370182e-004
	,2.234278359e-004
	,2.421152946e-004
	,2.620682447e-004
	,2.832910428e-004
	,3.057140608e-004
	,3.292672569e-004
	,3.538824299e-004
	,3.794937089e-004
	,4.060376987e-004
	,4.334534594e-004
	,4.616830628e-004
	,4.906719728e-004
	,5.203676370e-004
	,5.507217208e-004
	,5.816440986e-004
	,6.131205480e-004
	,6.451183542e-004
	,6.775941959e-004
	,7.105053718e-004
	,7.438096485e-004
	,7.774102686e-004
	,8.111144088e-004
	,8.450445523e-004
	,8.791588912e-004
	,9.134118264e-004
	,9.477522027e-004
	,9.821224319e-004
	,1.016458728e-003
	,1.050691824e-003
	,1.084747967e-003
	,1.118550207e-003
	,1.152020036e-003
	,1.184725488e-003
	,1.216921951e-003
	,1.248568328e-003
	,1.279293709e-003
	,1.308866911e-003
	,1.337683708e-003
	,1.365731556e-003
	,1.392822297e-003
	,1.419002277e-003
	,1.444359784e-003
	,1.468918606e-003
	,1.492716463e-003
	,1.515803841e-003
	,1.538242894e-003
	,1.560106271e-003
	,1.581470237e-003
	,1.602389953e-003
	,1.622985571e-003
	,1.643343592e-003
	,1.663518570e-003
	,1.683607990e-003
	,1.703678678e-003
	,1.723100628e-003
	,1.742112970e-003
	,-6.912786089e-006
	,-5.704441682e-006
	,-4.685825490e-006
	,-3.818497249e-006
	,-3.083732548e-006
	,-2.472711415e-006
	,-1.974466419e-006
	,-1.574967832e-006
	,-1.255581570e-006
	,-9.980219330e-007
	,-7.884968781e-007
	,-6.189627104e-007
	,-4.832054486e-007
	,-3.757832836e-007
	,-2.919781123e-007
	,-2.270540492e-007
	,-1.767672555e-007
	,-1.376707224e-007
	,-1.070711411e-007
	,-8.299863402e-008
	,-6.410806203e-008
	,-4.934660244e-008
	,-3.780530114e-008
	,-2.881786952e-008
	,-2.190641832e-008
	,-1.664325969e-008
	,-1.265029846e-008
	,-9.621680317e-009
	,-7.321061428e-009
	,-5.568999992e-009
	,-4.229842854e-009
	,-3.201020990e-009
	,-2.406523190e-009
	,-1.792312790e-009
	,-1.317967199e-009
	,-9.506011562e-010
	,-6.639829026e-010
	,-4.383234231e-010
	,-2.591058703e-010
	,-1.156916963e-010
	,-5.378455792e-018
	,9.468979733e-011
	,1.740518233e-010
	,2.427655987e-010
	,3.046047984e-010
	,3.625404058e-010
	,4.188992728e-010
	,4.755262069e-010
	,5.338956107e-010
	,5.951606041e-010
	,6.601658622e-010
	,7.295577437e-010
	,8.041365191e-010
	,8.849585773e-010
	,9.730827860e-010
	,1.069440548e-009
	,1.174942782e-009
	,1.290648161e-009
	,1.417705027e-009
	,1.557250286e-009
	,1.710305290e-009
	,1.877508487e-009
	,2.058897019e-009
	,2.254479692e-009
	,2.465386972e-009
	,2.693660890e-009
	,2.941053025e-009
	,3.208152195e-009
	,3.493813732e-009
	,3.795389065e-009
	,4.111109291e-009
	,4.443369884e-009
	,4.798197665e-009
	,5.182445094e-009
	,5.602451808e-009
	,6.064077690e-009
	,6.572954663e-009
	,7.134647012e-009
	,7.755261565e-009
	,8.443148535e-009
	,9.209633274e-009
	,1.006868640e-008
	,1.103834444e-008
	,1.214169708e-008
	,1.340737440e-008
	,1.487047600e-008
	,1.657399873e-008
	,1.857053891e-008
	,2.092070895e-008
	,2.370962527e-008
	,2.703942068e-008
	,3.103574131e-008
	,3.584944835e-008
	,4.162280628e-008
	,4.853790150e-008
	,5.690377882e-008
	,6.710677180e-008
	,7.960260302e-008
	,9.473541289e-008
	,1.131100010e-007
	,1.355056969e-007
	,1.623012073e-007
	,1.941219934e-007
	,2.310562556e-007
	,2.756126486e-007
	,3.300743412e-007
	,3.970484681e-007
	,4.795835955e-007
	,5.814279098e-007
	,7.072327998e-007
	,8.627892647e-007
	,1.055291902e-006
	,1.293559439e-006
	,1.585346664e-006
	,1.945453352e-006
	,2.388183507e-006
	,2.924735872e-006
	,3.583495090e-006
	,4.392823803e-006
	,5.384629492e-006
	,6.593227231e-006
	,7.988198634e-006
	,9.549199373e-006
	,1.129719621e-005
	,1.323254179e-005
	,1.550321383e-005
	,1.817034999e-005
	,2.129403980e-005
	,2.493985991e-005
	,2.918054379e-005
	,3.409618101e-005
	,3.977249394e-005
	,4.629339964e-005
	,5.362131440e-005
	,6.190964200e-005
	,7.115135458e-005
	,8.141689990e-005
	,9.281893760e-005
	,1.053782899e-004
	,1.190420343e-004
	,1.332482966e-004
	,1.482461527e-004
	,1.633203009e-004
	,1.780966565e-004
	,1.938720044e-004
	,2.109145863e-004
	,2.292403957e-004
	,2.488085376e-004
	,2.695671432e-004
	,2.913062136e-004
	,3.140827706e-004
	,3.378511399e-004
	,3.625200290e-004
	,3.880335805e-004
	,4.143694117e-004
	,4.414824786e-004
	,4.693252397e-004
	,4.978517594e-004
	,5.270176623e-004
	,5.567807473e-004
	,5.871008284e-004
	,6.179376937e-004
	,6.492517406e-004
	,6.810043150e-004
	,7.131564726e-004
	,7.455068558e-004
	,7.781374893e-004
	,8.110256564e-004
	,8.441349317e-004
	,8.774246796e-004
	,9.108486493e-004
	,9.443548592e-004
	,9.778859897e-004
	,1.011379976e-003
	,1.044770773e-003
	,1.077989338e-003
	,1.110964855e-003
	,1.143626145e-003
	,1.175481979e-003
	,1.206203244e-003
	,1.236347907e-003
	,1.265874309e-003
	,1.294748059e-003
	,1.322939245e-003
	,1.350251800e-003
	,1.376732805e-003
	,1.402426991e-003
	,1.427342757e-003
	,1.451502933e-003
	,1.474942939e-003
	,1.497709135e-003
	,1.519857216e-003
	,1.541450608e-003
	,1.562558974e-003
	,1.583257033e-003
	,1.603375467e-003
	,1.622567712e-003
	,1.641623199e-003
	,1.660627861e-003
	,1.679671210e-003
	,1.698786087e-003
	,-1.692086474e-005
	,-1.417600741e-005
	,-1.182988100e-005
	,-9.840089701e-006
	,-8.127119276e-006
	,-6.639295051e-006
	,-5.375824056e-006
	,-4.331016506e-006
	,-3.478359630e-006
	,-2.788819470e-006
	,-2.231528076e-006
	,-1.775733190e-006
	,-1.403262395e-006
	,-1.104824202e-006
	,-8.684803682e-007
	,-6.810864477e-007
	,-5.318843163e-007
	,-4.134694556e-007
	,-3.204546679e-007
	,-2.478684857e-007
	,-1.911929717e-007
	,-1.469414964e-007
	,-1.126787305e-007
	,-8.638930729e-008
	,-6.628850446e-008
	,-5.091222824e-008
	,-3.911417413e-008
	,-3.001565908e-008
	,-2.296393265e-008
	,-1.749929811e-008
	,-1.328253890e-008
	,-1.002968540e-008
	,-7.508633530e-009
	,-5.548063531e-009
	,-4.030028115e-009
	,-2.865308925e-009
	,-1.975127571e-009
	,-1.291561992e-009
	,-7.604318616e-010
	,-3.403090290e-010
	,-1.509070052e-017
	,2.838949524e-010
	,5.289462004e-010
	,7.483613915e-010
	,9.518949175e-010
	,1.146478567e-009
	,1.337493713e-009
	,1.530119349e-009
	,1.729218347e-009
	,1.938825747e-009
	,2.161886069e-009
	,2.400300845e-009
	,2.655355262e-009
	,2.927481667e-009
	,3.215854369e-009
	,3.520230834e-009
	,3.842225452e-009
	,4.183163650e-009
	,4.542654924e-009
	,4.919913910e-009
	,5.316873473e-009
	,5.738985681e-009
	,6.192755700e-009
	,6.684060679e-009
	,7.218093395e-009
	,7.799740613e-009
	,8.433822128e-009
	,9.125052251e-009
	,9.877599958e-009
	,1.069473635e-008
	,1.158012442e-008
	,1.254021117e-008
	,1.358391763e-008
	,1.472079287e-008
	,1.596035297e-008
	,1.731271312e-008
	,1.878982064e-008
	,2.040567888e-008
	,2.217592572e-008
	,2.411778515e-008
	,2.625023533e-008
	,2.859405609e-008
	,3.117146081e-008
	,3.400470664e-008
	,3.711323891e-008
	,4.051198862e-008
	,4.421830785e-008
	,4.827014932e-008
	,5.272819979e-008
	,5.767159522e-008
	,6.319617632e-008
	,6.941304886e-008
	,7.644357764e-008
	,8.441971164e-008
	,9.345193940e-008
	,1.036048057e-007
	,1.149465008e-007
	,1.277025404e-007
	,1.423729244e-007
	,1.595374004e-007
	,1.799046063e-007
	,2.042075631e-007
	,2.333990157e-007
	,2.686950950e-007
	,3.112166409e-007
	,3.629129955e-007
	,4.260533444e-007
	,5.034076335e-007
	,5.984030335e-007
	,7.149615077e-007
	,8.576952025e-007
	,1.033602830e-006
	,1.250935655e-006
	,1.519279977e-006
	,1.845813805e-006
	,2.247590158e-006
	,2.743416096e-006
	,3.354491504e-006
	,4.103468656e-006
	,4.986053868e-006
	,6.005407819e-006
	,7.173752687e-006
	,8.461278894e-006
	,9.981045324e-006
	,1.178728712e-005
	,1.393057746e-005
	,1.646524684e-005
	,1.945170194e-005
	,2.295713612e-005
	,2.705536826e-005
	,3.182459342e-005
	,3.732542462e-005
	,4.357604317e-005
	,5.067649003e-005
	,5.860076444e-005
	,6.750639898e-005
	,7.745274161e-005
	,8.845817780e-005
	,1.004461323e-004
	,1.129707963e-004
	,1.259270541e-004
	,1.389242803e-004
	,1.520977917e-004
	,1.663063565e-004
	,1.817043828e-004
	,1.982902620e-004
	,2.160364148e-004
	,2.348784482e-004
	,2.547836342e-004
	,2.757358362e-004
	,2.976930867e-004
	,3.204395073e-004
	,3.440007835e-004
	,3.683966423e-004
	,3.935832859e-004
	,4.195179919e-004
	,4.461592229e-004
	,4.734664817e-004
	,5.014003965e-004
	,5.299229816e-004
	,5.589959533e-004
	,5.885810482e-004
	,6.186436282e-004
	,6.491488556e-004
	,6.799796016e-004
	,7.111256111e-004
	,7.425894030e-004
	,7.743416068e-004
	,8.063500807e-004
	,8.385780376e-004
	,8.709836841e-004
	,9.035204630e-004
	,9.361374710e-004
	,9.687799764e-004
	,1.001390060e-003
	,1.033907381e-003
	,1.066268991e-003
	,1.098057784e-003
	,1.129328195e-003
	,1.159732482e-003
	,1.189605040e-003
	,1.218980468e-003
	,1.247814133e-003
	,1.276063113e-003
	,1.303534810e-003
	,1.330281489e-003
	,1.356311548e-003
	,1.381621162e-003
	,1.406220101e-003
	,1.430130092e-003
	,1.453195378e-003
	,1.475056056e-003
	,1.496381095e-003
	,1.517238466e-003
	,1.537692776e-003
	,1.557802033e-003
	,1.577618058e-003
	,1.597189396e-003
	,1.616557265e-003
	,1.635776907e-003
	,1.654907490e-003
	,-3.691868112e-005
	,-3.186982623e-005
	,-2.731660922e-005
	,-2.328901181e-005
	,-1.971521124e-005
	,-1.651091884e-005
	,-1.368593626e-005
	,-1.128108385e-005
	,-9.269746977e-006
	,-7.592469065e-006
	,-6.192108843e-006
	,-5.009263766e-006
	,-4.010302668e-006
	,-3.184658724e-006
	,-2.516250929e-006
	,-1.983358842e-006
	,-1.562578926e-006
	,-1.230869745e-006
	,-9.685831446e-007
	,-7.598722396e-007
	,-5.929152424e-007
	,-4.605607239e-007
	,-3.570565948e-007
	,-2.764249079e-007
	,-2.133054272e-007
	,-1.637147801e-007
	,-1.250090270e-007
	,-9.509178834e-008
	,-7.213711404e-008
	,-5.459898608e-008
	,-4.120171766e-008
	,-3.093399890e-008
	,-2.306398951e-008
	,-1.705671487e-008
	,-1.247526475e-008
	,-8.967322775e-009
	,-6.260131383e-009
	,-4.146815558e-009
	,-2.471743350e-009
	,-1.118067791e-009
	,2.830110252e-017
	,9.459818477e-010
	,1.770386415e-009
	,2.513282785e-009
	,3.203436220e-009
	,3.857735412e-009
	,4.482605493e-009
	,5.082423194e-009
	,5.668750880e-009
	,6.258188769e-009
	,6.867731437e-009
	,7.512722954e-009
	,8.205726947e-009
	,8.956728952e-009
	,9.773935503e-009
	,1.066480284e-008
	,1.163726036e-008
	,1.270033434e-008
	,1.386355699e-008
	,1.513556500e-008
	,1.652234482e-008
	,1.802657720e-008
	,1.965202939e-008
	,2.140993071e-008
	,2.331763669e-008
	,2.539419530e-008
	,2.765805823e-008
	,3.012570348e-008
	,3.281176215e-008
	,3.573145026e-008
	,3.890081189e-008
	,4.233400511e-008
	,4.603982507e-008
	,5.001752913e-008
	,5.426195375e-008
	,5.878367941e-008
	,6.361522917e-008
	,6.879229702e-008
	,7.433584739e-008
	,8.024001306e-008
	,8.646060289e-008
	,9.291729368e-008
	,9.954092812e-008
	,1.063481738e-007
	,1.134456352e-007
	,1.209663584e-007
	,1.290286363e-007
	,1.377318288e-007
	,1.471641169e-007
	,1.574092408e-007
	,1.685496606e-007
	,1.806671715e-007
	,1.938471726e-007
	,2.081964953e-007
	,2.238675510e-007
	,2.410605059e-007
	,2.600209387e-007
	,2.810519204e-007
	,3.045316367e-007
	,3.309299533e-007
	,3.608239202e-007
	,3.949481100e-007
	,4.342244825e-007
	,4.797511005e-007
	,5.330019942e-007
	,5.957850835e-007
	,6.703188416e-007
	,7.593129425e-007
	,8.660360031e-007
	,9.936854001e-007
	,1.146190340e-006
	,1.328970964e-006
	,1.550081125e-006
	,1.819015198e-006
	,2.146162278e-006
	,2.537103248e-006
	,3.003116638e-006
	,3.548750653e-006
	,4.175936087e-006
	,4.882915581e-006
	,5.710679515e-006
	,6.702068982e-006
	,7.893548756e-006
	,9.322152276e-006
	,1.103071164e-005
	,1.306921163e-005
	,1.549284946e-005
	,1.836317843e-005
	,2.174693341e-005
	,2.571140386e-005
	,3.028316806e-005
	,3.555012281e-005
	,4.149438199e-005
	,4.824683045e-005
	,5.588145022e-005
	,6.444430713e-005
	,7.392935212e-005
	,8.413763053e-005
	,9.473217223e-005
	,1.056625155e-004
	,1.165205136e-004
	,1.281363601e-004
	,1.407774010e-004
	,1.544655267e-004
	,1.692181154e-004
	,1.850383843e-004
	,2.019086535e-004
	,2.198068125e-004
	,2.387072066e-004
	,2.585810458e-004
	,2.793969221e-004
	,3.011214846e-004
	,3.237200418e-004
	,3.469830839e-004
	,3.708499547e-004
	,3.954389653e-004
	,4.207145652e-004
	,4.466416466e-004
	,4.731853822e-004
	,5.003107852e-004
	,5.279836514e-004
	,5.561697231e-004
	,5.848358727e-004
	,6.139193909e-004
	,6.433724117e-004
	,6.731953169e-004
	,7.033638099e-004
	,7.338522121e-004
	,7.646311380e-004
	,7.956669246e-004
	,8.269218153e-004
	,8.583543601e-004
	,8.899199081e-004
	,9.215682947e-004
	,9.532525512e-004
	,9.848096511e-004
	,1.016000616e-003
	,1.046991448e-003
	,1.077740684e-003
	,1.108207353e-003
	,1.137728482e-003
	,1.166831724e-003
	,1.195515084e-003
	,1.223731119e-003
	,1.251307944e-003
	,1.278073685e-003
	,1.303783476e-003
	,1.328868844e-003
	,1.353345335e-003
	,1.377231106e-003
	,1.400543045e-003
	,1.423298036e-003
	,1.445516479e-003
	,1.467224866e-003
	,1.488456403e-003
	,1.509248804e-003
	,1.529637644e-003
	,1.549679524e-003
	,1.569423074e-003
	,1.588917846e-003
	,1.608213740e-003
	,-7.114315877e-005
	,-6.313848205e-005
	,-5.576723939e-005
	,-4.897927076e-005
	,-4.269094667e-005
	,-3.690445869e-005
	,-3.161415851e-005
	,-2.686533609e-005
	,-2.272380355e-005
	,-1.915314068e-005
	,-1.604125476e-005
	,-1.329432613e-005
	,-1.089440672e-005
	,-8.843982056e-006
	,-7.141168357e-006
	,-5.758306595e-006
	,-4.642756408e-006
	,-3.738029697e-006
	,-2.994007423e-006
	,-2.379067143e-006
	,-1.873453492e-006
	,-1.459293326e-006
	,-1.126813898e-006
	,-8.670436260e-007
	,-6.671772027e-007
	,-5.141089002e-007
	,-3.967621500e-007
	,-3.063957005e-007
	,-2.362701122e-007
	,-1.815188389e-007
	,-1.388263733e-007
	,-1.055691016e-007
	,-7.967424328e-008
	,-5.953809798e-008
	,-4.382808218e-008
	,-3.152778509e-008
	,-2.191300541e-008
	,-1.440033802e-008
	,-8.491314760e-009
	,-3.791859787e-009
	,1.028645505e-017
	,3.126886325e-009
	,5.779010030e-009
	,8.098847493e-009
	,1.019879798e-008
	,1.217212588e-008
	,1.409660305e-008
	,1.603754130e-008
	,1.805004139e-008
	,2.018099701e-008
	,2.247106086e-008
	,2.495417730e-008
	,2.765385235e-008
	,3.057972495e-008
	,3.373916394e-008
	,3.716000766e-008
	,4.088615634e-008
	,4.495885072e-008
	,4.940910438e-008
	,5.425467989e-008
	,5.949116399e-008
	,6.507805577e-008
	,7.094290135e-008
	,7.703158612e-008
	,8.335998090e-008
	,8.998074234e-008
	,9.692424835e-008
	,1.041933723e-007
	,1.118012812e-007
	,1.198135406e-007
	,1.283356637e-007
	,1.374724281e-007
	,1.473092337e-007
	,1.579114840e-007
	,1.693293043e-007
	,1.816057869e-007
	,1.947884150e-007
	,2.089354362e-007
	,2.241094364e-007
	,2.403635408e-007
	,2.577386302e-007
	,2.762919944e-007
	,2.961285437e-007
	,3.173883625e-007
	,3.402202263e-007
	,3.647707637e-007
	,3.911885272e-007
	,4.196386502e-007
	,4.503109823e-007
	,4.834160125e-007
	,5.191812372e-007
	,5.578501336e-007
	,5.996814524e-007
	,6.449458718e-007
	,6.939166471e-007
	,7.468489560e-007
	,8.039432637e-007
	,8.653088932e-007
	,9.310054845e-007
	,1.001232383e-006
	,1.076488905e-006
	,1.157480329e-006
	,1.244982466e-006
	,1.339822926e-006
	,1.442962772e-006
	,1.555628892e-006
	,1.679241634e-006
	,1.815312180e-006
	,1.965149160e-006
	,2.129571451e-006
	,2.309091278e-006
	,2.506319586e-006
	,2.725526666e-006
	,2.974603570e-006
	,3.262948060e-006
	,3.601646398e-006
	,4.002077010e-006
	,4.478378553e-006
	,5.047617626e-006
	,5.728506975e-006
	,6.540075728e-006
	,7.513025857e-006
	,8.679497802e-006
	,1.007696847e-005
	,1.174852207e-005
	,1.374245686e-005
	,1.611033132e-005
	,1.888846731e-005
	,2.214132801e-005
	,2.590346230e-005
	,3.022066345e-005
	,3.518394179e-005
	,4.085818263e-005
	,4.728772234e-005
	,5.446697908e-005
	,6.225169085e-005
	,7.033646006e-005
	,7.877697794e-005
	,8.734876337e-005
	,9.655732576e-005
	,1.066155064e-004
	,1.176053768e-004
	,1.295473960e-004
	,1.424484931e-004
	,1.563093649e-004
	,1.711261864e-004
	,1.868910122e-004
	,2.035921529e-004
	,2.212143319e-004
	,2.397389501e-004
	,2.591448938e-004
	,2.794087635e-004
	,3.005053037e-004
	,3.224078379e-004
	,3.450885872e-004
	,3.684079833e-004
	,3.920732847e-004
	,4.163801490e-004
	,4.412978125e-004
	,4.667948078e-004
	,4.928391158e-004
	,5.193986914e-004
	,5.464432103e-004
	,5.739342628e-004
	,6.018444034e-004
	,6.301527250e-004
	,6.588366732e-004
	,6.878731397e-004
	,7.172335526e-004
	,7.468876861e-004
	,7.768011359e-004
	,8.069370483e-004
	,8.372570091e-004
	,8.677220947e-004
	,8.980749416e-004
	,9.284002692e-004
	,9.586765690e-004
	,9.888803901e-004
	,1.018984263e-003
	,1.048951133e-003
	,1.078604561e-003
	,1.106778941e-003
	,1.134625545e-003
	,1.162121845e-003
	,1.189173440e-003
	,1.215815104e-003
	,1.242011354e-003
	,1.267724174e-003
	,1.292919655e-003
	,1.317572269e-003
	,1.341667030e-003
	,1.365200229e-003
	,1.388179203e-003
	,1.410617932e-003
	,1.432540183e-003
	,1.453985155e-003
	,1.474991845e-003
	,1.495603112e-003
	,1.515864245e-003
	,1.535821761e-003
	,1.555522487e-003
	,-1.250724812e-004
	,-1.130809350e-004
	,-1.018840470e-004
	,-9.160522593e-005
	,-8.222211483e-005
	,-7.353392202e-005
	,-6.527515894e-005
	,-5.741314215e-005
	,-5.010395087e-005
	,-4.346069110e-005
	,-3.751060302e-005
	,-3.221433329e-005
	,-2.750574674e-005
	,-2.326571992e-005
	,-1.942012558e-005
	,-1.604805227e-005
	,-1.317675253e-005
	,-1.074329975e-005
	,-8.697610187e-006
	,-7.012740091e-006
	,-5.641345666e-006
	,-4.519257621e-006
	,-3.598935068e-006
	,-2.851497477e-006
	,-2.252677521e-006
	,-1.774875983e-006
	,-1.389648692e-006
	,-1.078668427e-006
	,-8.324392341e-007
	,-6.392335630e-007
	,-4.870452297e-007
	,-3.673757140e-007
	,-2.746290505e-007
	,-2.035308415e-007
	,-1.490568181e-007
	,-1.072129248e-007
	,-7.488274270e-008
	,-4.960941732e-008
	,-2.953903797e-008
	,-1.333137971e-008
	,-1.415080587e-017
	,1.125432249e-008
	,2.107465817e-008
	,2.994349451e-008
	,3.820773688e-008
	,4.612077854e-008
	,5.383632360e-008
	,6.147316916e-008
	,6.920204699e-008
	,7.724995867e-008
	,8.574953339e-008
	,9.468319894e-008
	,1.039489511e-007
	,1.134879651e-007
	,1.233217352e-007
	,1.335357839e-007
	,1.442906926e-007
	,1.557738461e-007
	,1.681544608e-007
	,1.815807029e-007
	,1.961857540e-007
	,2.121028183e-007
	,2.294710920e-007
	,2.484342735e-007
	,2.691438427e-007
	,2.917529513e-007
	,3.163918216e-007
	,3.431359860e-007
	,3.719913691e-007
	,4.029660164e-007
	,4.361843040e-007
	,4.718573891e-007
	,5.102015657e-007
	,5.514518562e-007
	,5.959081383e-007
	,6.439103405e-007
	,6.957721722e-007
	,7.517861058e-007
	,8.121868309e-007
	,8.770349891e-007
	,9.461215480e-007
	,1.019046706e-006
	,1.095588489e-006
	,1.176022670e-006
	,1.260927268e-006
	,1.350766745e-006
	,1.445643280e-006
	,1.545173577e-006
	,1.648387090e-006
	,1.753689522e-006
	,1.859238422e-006
	,1.964017931e-006
	,2.068693371e-006
	,2.175136531e-006
	,2.285387685e-006
	,2.401126342e-006
	,2.523624005e-006
	,2.653843513e-006
	,2.792536487e-006
	,2.940299191e-006
	,3.097597853e-006
	,3.264822055e-006
	,3.442437591e-006
	,3.631167358e-006
	,3.832002653e-006
	,4.046118005e-006
	,4.274812164e-006
	,4.519527739e-006
	,4.781913382e-006
	,5.063913558e-006
	,5.367878134e-006
	,5.696700145e-006
	,6.054003757e-006
	,6.444386596e-006
	,6.873688945e-006
	,7.349339688e-006
	,7.880754302e-006
	,8.479782892e-006
	,9.160910055e-006
	,9.942031431e-006
	,1.084529900e-005
	,1.189645339e-005
	,1.312410635e-005
	,1.455760924e-005
	,1.622227541e-005
	,1.815264233e-005
	,2.040345426e-005
	,2.302840680e-005
	,2.607932774e-005
	,2.959946763e-005
	,3.361275274e-005
	,3.809136756e-005
	,4.289747693e-005
	,4.802381151e-005
	,5.344078494e-005
	,5.917751783e-005
	,6.547340753e-005
	,7.245045035e-005
	,8.016443940e-005
	,8.864752596e-005
	,9.792261185e-005
	,1.080019928e-004
	,1.189030332e-004
	,1.306404558e-004
	,1.432217495e-004
	,1.566509357e-004
	,1.709286204e-004
	,1.860521047e-004
	,2.020155156e-004
	,2.188100750e-004
	,2.364243528e-004
	,2.548444374e-004
	,2.740541317e-004
	,2.940355688e-004
	,3.147689969e-004
	,3.362330939e-004
	,3.583972451e-004
	,3.812398767e-004
	,4.042720299e-004
	,4.277472506e-004
	,4.517705820e-004
	,4.763254447e-004
	,5.014128329e-004
	,5.269679600e-004
	,5.529725902e-004
	,5.794095802e-004
	,6.062592035e-004
	,6.334981506e-004
	,6.610946783e-004
	,6.890072306e-004
	,7.172156160e-004
	,7.456879351e-004
	,7.743674226e-004
	,8.031625830e-004
	,8.320466441e-004
	,8.610126031e-004
	,8.898733503e-004
	,9.185363544e-004
	,9.471226305e-004
	,9.757056008e-004
	,1.004340355e-003
	,1.032948413e-003
	,1.060042785e-003
	,1.087048132e-003
	,1.113937823e-003
	,1.140647685e-003
	,1.167108261e-003
	,1.193253796e-003
	,1.219025523e-003
	,1.244370275e-003
	,1.269249604e-003
	,1.293636592e-003
	,1.317514434e-003
	,1.340877908e-003
	,1.363732833e-003
	,1.386095055e-003
	,1.407989076e-003
	,1.429446447e-003
	,1.450487522e-003
	,1.471163359e-003
	,1.491523299e-003
	,-1.957255618e-004
	,-1.816952015e-004
	,-1.680976023e-004
	,-1.550564296e-004
	,-1.426381289e-004
	,-1.307930025e-004
	,-1.193764172e-004
	,-1.082951703e-004
	,-9.761748403e-005
	,-8.745844895e-005
	,-7.789453551e-005
	,-6.899770361e-005
	,-6.083395078e-005
	,-5.337510349e-005
	,-4.650707683e-005
	,-4.014748514e-005
	,-3.423417170e-005
	,-2.886901028e-005
	,-2.420345655e-005
	,-2.023842025e-005
	,-1.687116989e-005
	,-1.395996443e-005
	,-1.142240315e-005
	,-9.261427833e-006
	,-7.445434626e-006
	,-5.918368146e-006
	,-4.656170659e-006
	,-3.647351304e-006
	,-2.855097078e-006
	,-2.233134034e-006
	,-1.739624767e-006
	,-1.344709531e-006
	,-1.030211051e-006
	,-7.819992973e-007
	,-5.851068179e-007
	,-4.272528943e-007
	,-3.005566860e-007
	,-1.993962734e-007
	,-1.185988064e-007
	,-5.337108215e-008
	,6.056929116e-018
	,4.425812137e-008
	,8.157001891e-008
	,1.139612143e-007
	,1.432718041e-007
	,1.710047800e-007
	,1.983448434e-007
	,2.261907065e-007
	,2.551474127e-007
	,2.856124844e-007
	,3.178688844e-007
	,3.517709699e-007
	,3.872354171e-007
	,4.245454949e-007
	,4.644433919e-007
	,5.075630630e-007
	,5.542200448e-007
	,6.045127388e-007
	,6.587768883e-007
	,7.178513322e-007
	,7.826320975e-007
	,8.536837135e-007
	,9.312212077e-007
	,1.015065449e-006
	,1.104301431e-006
	,1.197102628e-006
	,1.291605317e-006
	,1.387205310e-006
	,1.484407235e-006
	,1.583755084e-006
	,1.685435595e-006
	,1.789743295e-006
	,1.897694488e-006
	,2.010830791e-006
	,2.130569139e-006
	,2.257989266e-006
	,2.394010751e-006
	,2.539501756e-006
	,2.695212496e-006
	,2.861770243e-006
	,3.039868747e-006
	,3.230063397e-006
	,3.432574949e-006
	,3.647352581e-006
	,3.874352680e-006
	,4.113842940e-006
	,4.366437395e-006
	,4.633053053e-006
	,4.914815126e-006
	,5.212872840e-006
	,5.528217390e-006
	,5.861511314e-006
	,6.213022740e-006
	,6.582823078e-006
	,6.971241297e-006
	,7.379155131e-006
	,7.807780870e-006
	,8.258249677e-006
	,8.731329354e-006
	,9.227335233e-006
	,9.746154721e-006
	,1.028723493e-005
	,1.084956352e-005
	,1.143228538e-005
	,1.203574491e-005
	,1.266172625e-005
	,1.331271026e-005
	,1.399112111e-005
	,1.469899252e-005
	,1.543785659e-005
	,1.620876172e-005
	,1.701217586e-005
	,1.784778701e-005
	,1.871420027e-005
	,1.960852551e-005
	,2.052605026e-005
	,2.146055236e-005
	,2.240601777e-005
	,2.335981170e-005
	,2.432567581e-005
	,2.531293990e-005
	,2.633326615e-005
	,2.739913438e-005
	,2.852489683e-005
	,2.973184047e-005
	,3.104826148e-005
	,3.250921236e-005
	,3.415379198e-005
	,3.602398586e-005
	,3.816396723e-005
	,4.061947011e-005
	,4.343698416e-005
	,4.666138214e-005
	,5.033768346e-005
	,5.450961217e-005
	,5.921629795e-005
	,6.449279490e-005
	,7.037345288e-005
	,7.688736477e-005
	,8.405394196e-005
	,9.190201119e-005
	,1.004522468e-004
	,1.097209758e-004
	,1.197212100e-004
	,1.304625898e-004
	,1.419512466e-004
	,1.541895583e-004
	,1.671758205e-004
	,1.809072729e-004
	,1.953757985e-004
	,2.105699772e-004
	,2.264820766e-004
	,2.431055987e-004
	,2.604357279e-004
	,2.784661417e-004
	,2.971873807e-004
	,3.165864207e-004
	,3.366467875e-004
	,3.573483987e-004
	,3.786685815e-004
	,4.006187588e-004
	,4.225989486e-004
	,4.449523837e-004
	,4.677974442e-004
	,4.911131570e-004
	,5.148754339e-004
	,5.390592792e-004
	,5.636442895e-004
	,5.885287847e-004
	,6.136442862e-004
	,6.389521077e-004
	,6.637181729e-004
	,6.879121960e-004
	,7.124867677e-004
	,7.379250519e-004
	,7.641717366e-004
	,7.910878183e-004
	,8.185506173e-004
	,8.464578003e-004
	,8.747218459e-004
	,9.032615986e-004
	,9.319996071e-004
	,9.608600867e-004
	,9.888195074e-004
	,1.016050502e-003
	,1.043208264e-003
	,1.070220388e-003
	,1.097030903e-003
	,1.123587009e-003
	,1.149839679e-003
	,1.175744441e-003
	,1.201262385e-003
	,1.226361287e-003
	,1.251016667e-003
	,1.275212585e-003
	,1.298942075e-003
	,1.322207137e-003
	,1.345018298e-003
	,1.367393791e-003
	,1.389358447e-003
	,1.410942436e-003
	,-2.794089122e-004
	,-2.646316205e-004
	,-2.502819165e-004
	,-2.362126080e-004
	,-2.221418504e-004
	,-2.078623398e-004
	,-1.934418062e-004
	,-1.791624169e-004
	,-1.652162663e-004
	,-1.516632039e-004
	,-1.385248276e-004
	,-1.258949738e-004
	,-1.139278013e-004
	,-1.027018804e-004
	,-9.224167064e-005
	,-8.261982088e-005
	,-7.389232900e-005
	,-6.591990824e-005
	,-5.841468239e-005
	,-5.127056304e-005
	,-4.450959799e-005
	,-3.811230875e-005
	,-3.223411680e-005
	,-2.702347553e-005
	,-2.250202160e-005
	,-1.864319377e-005
	,-1.539597917e-005
	,-1.265422655e-005
	,-1.029477995e-005
	,-8.271206790e-006
	,-6.544372011e-006
	,-5.093509883e-006
	,-3.912874770e-006
	,-2.977366825e-006
	,-2.243390176e-006
	,-1.663741595e-006
	,-1.197003004e-006
	,-8.124931705e-007
	,-4.927601809e-007
	,-2.247598147e-007
	,-8.302572492e-018
	,1.901304824e-007
	,3.542607755e-007
	,4.990437044e-007
	,6.306264234e-007
	,7.549488937e-007
	,8.765160492e-007
	,9.985238933e-007
	,1.123854997e-006
	,1.254706033e-006
	,1.391236017e-006
	,1.530945388e-006
	,1.671292912e-006
	,1.814184159e-006
	,1.963603716e-006
	,2.122136873e-006
	,2.290633858e-006
	,2.467748464e-006
	,2.648729964e-006
	,2.836186150e-006
	,3.038899808e-006
	,3.259917746e-006
	,3.500306312e-006
	,3.760182863e-006
	,4.038922740e-006
	,4.335361302e-006
	,4.648189798e-006
	,4.978242917e-006
	,5.329173175e-006
	,5.704711534e-006
	,6.107372534e-006
	,6.538831571e-006
	,6.999974408e-006
	,7.490625526e-006
	,8.009455749e-006
	,8.553803587e-006
	,9.119307193e-006
	,9.700027643e-006
	,1.028984278e-005
	,1.088575280e-005
	,1.149022883e-005
	,1.210920016e-005
	,1.274861392e-005
	,1.341249886e-005
	,1.410238649e-005
	,1.481857615e-005
	,1.555919578e-005
	,1.631873801e-005
	,1.708940329e-005
	,1.786425697e-005
	,1.864019685e-005
	,1.941778601e-005
	,2.019885546e-005
	,2.098524291e-005
	,2.177941323e-005
	,2.258502801e-005
	,2.340623116e-005
	,2.424650618e-005
	,2.510782572e-005
	,2.599024632e-005
	,2.689259637e-005
	,2.781438008e-005
	,2.875706417e-005
	,2.972319531e-005
	,3.071467083e-005
	,3.173203228e-005
	,3.277505891e-005
	,3.384338430e-005
	,3.493726013e-005
	,3.605790679e-005
	,3.720693463e-005
	,3.838568524e-005
	,3.959511734e-005
	,4.083612016e-005
	,4.210979164e-005
	,4.341749175e-005
	,4.476074744e-005
	,4.614096521e-005
	,4.755949903e-005
	,4.901777868e-005
	,5.051740754e-005
	,5.206021155e-005
	,5.364829377e-005
	,5.528413214e-005
	,5.697068868e-005
	,5.871122810e-005
	,6.050887345e-005
	,6.237033607e-005
	,6.430434232e-005
	,6.632133157e-005
	,6.843496216e-005
	,7.066348879e-005
	,7.303049590e-005
	,7.556569290e-005
	,7.830497440e-005
	,8.128996474e-005
	,8.456721118e-005
	,8.818701700e-005
	,9.220188998e-005
	,9.666465842e-005
	,1.016264143e-004
	,1.071345203e-004
	,1.132309142e-004
	,1.199508587e-004
	,1.273221863e-004
	,1.353649803e-004
	,1.440915669e-004
	,1.535066842e-004
	,1.636084229e-004
	,1.743880892e-004
	,1.858316805e-004
	,1.979279357e-004
	,2.107254214e-004
	,2.241578671e-004
	,2.382374252e-004
	,2.529483210e-004
	,2.682823949e-004
	,2.842267384e-004
	,3.008213892e-004
	,3.179730808e-004
	,3.356386570e-004
	,3.538388282e-004
	,3.724683039e-004
	,3.913960072e-004
	,4.106209038e-004
	,4.296237309e-004
	,4.488794863e-004
	,4.687328831e-004
	,4.893120800e-004
	,5.106469791e-004
	,5.327309060e-004
	,5.555313865e-004
	,5.790083424e-004
	,6.031237367e-004
	,6.278399244e-004
	,6.531195113e-004
	,6.789243868e-004
	,7.052153324e-004
	,7.319515042e-004
	,7.590899743e-004
	,7.865841339e-004
	,8.143861962e-004
	,8.424456129e-004
	,8.707082992e-004
	,8.991158382e-004
	,9.271688440e-004
	,9.535163381e-004
	,9.798415520e-004
	,1.006100038e-003
	,1.032247074e-003
	,1.058239077e-003
	,1.084034018e-003
	,1.109592271e-003
	,1.134877648e-003
	,1.159858511e-003
	,1.184508833e-003
	,1.208809116e-003
	,1.232747047e-003
	,1.256317844e-003
	,1.279524231e-003
	,1.302376048e-003
	,-3.641422234e-004
	,-3.471850793e-004
	,-3.307046182e-004
	,-3.147855203e-004
	,-2.994879524e-004
	,-2.848418776e-004
	,-2.707915943e-004
	,-2.570759368e-004
	,-2.432556224e-004
	,-2.291010500e-004
	,-2.147139135e-004
	,-2.003482160e-004
	,-1.863586595e-004
	,-1.729339233e-004
	,-1.601379329e-004
	,-1.479349636e-004
	,-1.362054921e-004
	,-1.248217611e-004
	,-1.136982336e-004
	,-1.028401132e-004
	,-9.234856263e-005
	,-8.234267517e-005
	,-7.289048404e-005
	,-6.415939285e-005
	,-5.621080710e-005
	,-4.886695236e-005
	,-4.203275069e-005
	,-3.583429210e-005
	,-3.029699358e-005
	,-2.531854936e-005
	,-2.082991019e-005
	,-1.691350329e-005
	,-1.362072772e-005
	,-1.088381250e-005
	,-8.594390896e-006
	,-6.642230085e-006
	,-4.933981433e-006
	,-3.424460653e-006
	,-2.109074141e-006
	,-9.775077321e-007
	,2.140854174e-017
	,8.480085674e-007
	,1.575581541e-006
	,2.213397563e-006
	,2.801987021e-006
	,3.372660286e-006
	,3.944720217e-006
	,4.524649697e-006
	,5.110717900e-006
	,5.706757072e-006
	,6.323294783e-006
	,6.964290100e-006
	,7.619143481e-006
	,8.271684136e-006
	,8.923216733e-006
	,9.591385683e-006
	,1.029012811e-005
	,1.102428258e-005
	,1.179023427e-005
	,1.258029903e-005
	,1.339350794e-005
	,1.423585868e-005
	,1.510513276e-005
	,1.598764979e-005
	,1.688809195e-005
	,1.779974779e-005
	,1.871097811e-005
	,1.962983342e-005
	,2.055018573e-005
	,2.147188238e-005
	,2.240116078e-005
	,2.334717631e-005
	,2.432005938e-005
	,2.532858071e-005
	,2.637950969e-005
	,2.747836890e-005
	,2.862964082e-005
	,2.983591984e-005
	,3.109668639e-005
	,3.240789629e-005
	,3.376435370e-005
	,3.516280808e-005
	,3.660139428e-005
	,3.807717590e-005
	,3.958445778e-005
	,4.111419782e-005
	,4.265488675e-005
	,4.419552664e-005
	,4.572851924e-005
	,4.725173019e-005
	,4.877291702e-005
	,5.030191873e-005
	,5.184581822e-005
	,5.341077727e-005
	,5.500263672e-005
	,5.662609716e-005
	,5.828426191e-005
	,5.997911212e-005
	,6.171227941e-005
	,6.348541524e-005
	,6.530009054e-005
	,6.715757534e-005
	,6.905868932e-005
	,7.100370726e-005
	,7.299221604e-005
	,7.502284651e-005
	,7.709289397e-005
	,7.919784278e-005
	,8.133072179e-005
	,8.348146197e-005
	,8.563833507e-005
	,8.779093834e-005
	,8.993042765e-005
	,9.205134799e-005
	,9.415309697e-005
	,9.623867031e-005
	,9.831210811e-005
	,1.003763262e-004
	,1.024320959e-004
	,1.044785463e-004
	,1.065152379e-004
	,1.085438675e-004
	,1.105679389e-004
	,1.125910628e-004
	,1.146155444e-004
	,1.166423588e-004
	,1.186722355e-004
	,1.207066594e-004
	,1.227478381e-004
	,1.247979205e-004
	,1.268584581e-004
	,1.289300820e-004
	,1.310101527e-004
	,1.330988747e-004
	,1.352042106e-004
	,1.373323574e-004
	,1.394908758e-004
	,1.416902471e-004
	,1.439448718e-004
	,1.462732019e-004
	,1.486977564e-004
	,1.512450420e-004
	,1.539455658e-004
	,1.568338278e-004
	,1.599486260e-004
	,1.633326344e-004
	,1.670298140e-004
	,1.710861583e-004
	,1.755474064e-004
	,1.804573098e-004
	,1.858562665e-004
	,1.917836725e-004
	,1.982819924e-004
	,2.053772946e-004
	,2.131033071e-004
	,2.214928034e-004
	,2.305751593e-004
	,2.403744858e-004
	,2.509091845e-004
	,2.621925343e-004
	,2.742337241e-004
	,2.870388234e-004
	,3.006116151e-004
	,3.149542102e-004
	,3.300674641e-004
	,3.459512207e-004
	,3.626043462e-004
	,3.800249147e-004
	,3.982100198e-004
	,4.171572534e-004
	,4.363449859e-004
	,4.558041194e-004
	,4.759292248e-004
	,4.967501867e-004
	,5.182601414e-004
	,5.403833151e-004
	,5.630950354e-004
	,5.863689459e-004
	,6.101767810e-004
	,6.345407300e-004
	,6.593872631e-004
	,6.846772559e-004
	,7.103732679e-004
	,7.364350024e-004
	,7.628195027e-004
	,7.895070683e-004
	,8.164411244e-004
	,8.435579977e-004
	,8.708069507e-004
	,8.972565600e-004
	,9.220504860e-004
	,9.468301723e-004
	,9.715605849e-004
	,9.962081085e-004
	,1.020739947e-003
	,1.045125560e-003
	,1.069337422e-003
	,1.093351754e-003
	,1.117149149e-003
	,1.140715078e-003
	,1.164040198e-003
	,-4.465989497e-004
	,-4.291116491e-004
	,-4.119576193e-004
	,-3.951648997e-004
	,-3.787469507e-004
	,-3.626817826e-004
	,-3.469194218e-004
	,-3.314257514e-004
	,-3.161824929e-004
	,-3.011094968e-004
	,-2.860241587e-004
	,-2.708906626e-004
	,-2.558090272e-004
	,-2.408954764e-004
	,-2.262531902e-004
	,-2.119481839e-004
	,-1.980150572e-004
	,-1.844833825e-004
	,-1.713766504e-004
	,-1.586942791e-004
	,-1.464474241e-004
	,-1.347103914e-004
	,-1.235942863e-004
	,-1.131831344e-004
	,-1.035057075e-004
	,-9.453270185e-005
	,-8.617065338e-005
	,-7.822523878e-005
	,-7.029123285e-005
	,-6.199086461e-005
	,-5.351711957e-005
	,-4.533331564e-005
	,-3.775509578e-005
	,-3.090768767e-005
	,-2.476654639e-005
	,-1.928997959e-005
	,-1.445422557e-005
	,-1.019569950e-005
	,-6.429090196e-006
	,-3.061518335e-006
	,-1.091339097e-017
	,2.840252558e-006
	,5.518214335e-006
	,8.062494287e-006
	,1.050526792e-005
	,1.285431561e-005
	,1.505509455e-005
	,1.715681596e-005
	,1.925902200e-005
	,2.139708797e-005
	,2.356767427e-005
	,2.575833815e-005
	,2.796152223e-005
	,3.015408882e-005
	,3.230910560e-005
	,3.443421927e-005
	,3.655610005e-005
	,3.869294531e-005
	,4.083229411e-005
	,4.293541644e-005
	,4.500845957e-005
	,4.711808358e-005
	,4.930187722e-005
	,5.156978545e-005
	,5.392025317e-005
	,5.632884272e-005
	,5.870814974e-005
	,6.092709362e-005
	,6.299968768e-005
	,6.500379951e-005
	,6.696482759e-005
	,6.885833603e-005
	,7.062972429e-005
	,7.236529159e-005
	,7.411411519e-005
	,7.588783149e-005
	,7.769858359e-005
	,7.956289066e-005
	,8.148873037e-005
	,8.347532967e-005
	,8.552142467e-005
	,8.762848873e-005
	,8.979826823e-005
	,9.202461917e-005
	,9.428578473e-005
	,9.654311664e-005
	,9.875606770e-005
	,1.009041280e-004
	,1.029920628e-004
	,1.050384818e-004
	,1.070635391e-004
	,1.090827119e-004
	,1.111037476e-004
	,1.131263006e-004
	,1.151598006e-004
	,1.172214704e-004
	,1.193190068e-004
	,1.214523849e-004
	,1.236162727e-004
	,1.258025537e-004
	,1.280045235e-004
	,1.302183688e-004
	,1.324402424e-004
	,1.346635699e-004
	,1.368799014e-004
	,1.390827729e-004
	,1.412699170e-004
	,1.434409681e-004
	,1.455951049e-004
	,1.477320890e-004
	,1.498538242e-004
	,1.519633859e-004
	,1.540633986e-004
	,1.561555598e-004
	,1.582412317e-004
	,1.603252852e-004
	,1.624153307e-004
	,1.645178213e-004
	,1.666382534e-004
	,1.687815637e-004
	,1.709520169e-004
	,1.731530612e-004
	,1.753871730e-004
	,1.776557095e-004
	,1.799592013e-004
	,1.822978833e-004
	,1.846710949e-004
	,1.870767484e-004
	,1.895113898e-004
	,1.919706130e-004
	,1.944497631e-004
	,1.969446592e-004
	,1.994518812e-004
	,2.019683920e-004
	,2.044907866e-004
	,2.070146338e-004
	,2.095342329e-004
	,2.120424596e-004
	,2.145268668e-004
	,2.169752090e-004
	,2.193979608e-004
	,2.218002352e-004
	,2.241831762e-004
	,2.265486616e-004
	,2.289014506e-004
	,2.312503417e-004
	,2.336079271e-004
	,2.359906951e-004
	,2.384194723e-004
	,2.409207891e-004
	,2.435267927e-004
	,2.462751514e-004
	,2.492080355e-004
	,2.523724376e-004
	,2.558192526e-004
	,2.596016720e-004
	,2.637738566e-004
	,2.683898565e-004
	,2.735017679e-004
	,2.791582874e-004
	,2.854038380e-004
	,2.922775519e-004
	,2.998130716e-004
	,3.080384941e-004
	,3.169766757e-004
	,3.266457403e-004
	,3.370597077e-004
	,3.482291418e-004
	,3.601617921e-004
	,3.728631311e-004
	,3.863367919e-004
	,4.005848970e-004
	,4.156082700e-004
	,4.314065501e-004
	,4.479782453e-004
	,4.653213566e-004
	,4.829880711e-004
	,5.008423410e-004
	,5.193737795e-004
	,5.385555587e-004
	,5.583580317e-004
	,5.787481669e-004
	,5.997024999e-004
	,6.211775259e-004
	,6.431224399e-004
	,6.654930628e-004
	,6.883364227e-004
	,7.116765265e-004
	,7.353707502e-004
	,7.593673386e-004
	,7.836131607e-004
	,8.080534654e-004
	,8.327714548e-004
	,8.575627481e-004
	,8.823340590e-004
	,9.050668682e-004
	,9.273615182e-004
	,9.495966093e-004
	,9.718000908e-004
	,9.939431322e-004
	,1.016001199e-003
	,-5.132860712e-004
	,-4.961268777e-004
	,-4.789570916e-004
	,-4.618390594e-004
	,-4.448390359e-004
	,-4.280297479e-004
	,-4.114683251e-004
	,-3.951811266e-004
	,-3.791752036e-004
	,-3.633896394e-004
	,-3.476969463e-004
	,-3.319701876e-004
	,-3.160960492e-004
	,-3.000600200e-004
	,-2.839991919e-004
	,-2.680953439e-004
	,-2.524909879e-004
	,-2.372603045e-004
	,-2.224351254e-004
	,-2.080276829e-004
	,-1.940141908e-004
	,-1.803801784e-004
	,-1.672119696e-004
	,-1.545530967e-004
	,-1.424258704e-004
	,-1.308617809e-004
	,-1.198866340e-004
	,-1.094899214e-004
	,-9.959638131e-005
	,-9.001379780e-005
	,-8.043692104e-005
	,-7.073597676e-005
	,-6.114207292e-005
	,-5.186588981e-005
	,-4.300239828e-005
	,-3.468098904e-005
	,-2.692053168e-005
	,-1.965152211e-005
	,-1.278281089e-005
	,-6.240679380e-006
	,1.984052293e-018
	,5.911485341e-006
	,1.146904056e-005
	,1.670841683e-005
	,2.171785930e-005
	,2.655908732e-005
	,3.122021227e-005
	,3.569822911e-005
	,3.993932717e-005
	,4.376772491e-005
	,4.729860845e-005
	,5.073903790e-005
	,5.416477952e-005
	,5.759269683e-005
	,6.101716553e-005
	,6.443349844e-005
	,6.782583435e-005
	,7.114323618e-005
	,7.439488742e-005
	,7.763242807e-005
	,8.087602809e-005
	,8.412586430e-005
	,8.737352314e-005
	,9.060620472e-005
	,9.381059716e-005
	,9.697911760e-005
	,1.001144720e-004
	,1.032223334e-004
	,1.062988175e-004
	,1.093217262e-004
	,1.122343916e-004
	,1.149652073e-004
	,1.175690385e-004
	,1.201048511e-004
	,1.225758086e-004
	,1.250197440e-004
	,1.274436857e-004
	,1.297648463e-004
	,1.319094562e-004
	,1.340288840e-004
	,1.361708524e-004
	,1.383348299e-004
	,1.405203028e-004
	,1.427251411e-004
	,1.449432263e-004
	,1.471660194e-004
	,1.493852254e-004
	,1.515956547e-004
	,1.537984809e-004
	,1.559990080e-004
	,1.581999965e-004
	,1.604086144e-004
	,1.626345927e-004
	,1.648808261e-004
	,1.671471825e-004
	,1.694324003e-004
	,1.717291672e-004
	,1.740194503e-004
	,1.763027387e-004
	,1.785993975e-004
	,1.809194886e-004
	,1.832653266e-004
	,1.856372744e-004
	,1.880348820e-004
	,1.904566472e-004
	,1.929000464e-004
	,1.953615977e-004
	,1.978369077e-004
	,2.003209965e-004
	,2.028091719e-004
	,2.052981161e-004
	,2.077868594e-004
	,2.102776769e-004
	,2.127757077e-004
	,2.152866243e-004
	,2.178147468e-004
	,2.203630897e-004
	,2.229332441e-004
	,2.255236436e-004
	,2.281335416e-004
	,2.307677896e-004
	,2.334302683e-004
	,2.361221387e-004
	,2.388433138e-004
	,2.415928992e-004
	,2.443691184e-004
	,2.471691187e-004
	,2.499885863e-004
	,2.528215899e-004
	,2.556612125e-004
	,2.584991344e-004
	,2.613242069e-004
	,2.641231130e-004
	,2.668839320e-004
	,2.696010234e-004
	,2.722777911e-004
	,2.749256395e-004
	,2.775598222e-004
	,2.801950081e-004
	,2.828431390e-004
	,2.855131472e-004
	,2.882113872e-004
	,2.909421208e-004
	,2.937071107e-004
	,2.964994243e-004
	,2.992988173e-004
	,3.021200732e-004
	,3.049773141e-004
	,3.078742258e-004
	,3.108130916e-004
	,3.137965406e-004
	,3.168280155e-004
	,3.199120389e-004
	,3.230544384e-004
	,3.262625517e-004
	,3.295453980e-004
	,3.329137916e-004
	,3.363803855e-004
	,3.399596681e-004
	,3.436680165e-004
	,3.475237945e-004
	,3.515471756e-004
	,3.557608402e-004
	,3.601894755e-004
	,3.648597539e-004
	,3.698031171e-004
	,3.750531976e-004
	,3.806459013e-004
	,3.866246595e-004
	,3.930337146e-004
	,3.999176688e-004
	,4.073319083e-004
	,4.153200823e-004
	,4.239228418e-004
	,4.331812310e-004
	,4.431194230e-004
	,4.537610151e-004
	,4.651178469e-004
	,4.771905036e-004
	,4.899578459e-004
	,5.033543016e-004
	,5.172576625e-004
	,5.316802088e-004
	,5.459508679e-004
	,5.606423013e-004
	,5.759252555e-004
	,5.918049582e-004
	,6.082751522e-004
	,6.253229753e-004
	,6.429312932e-004
	,6.610797536e-004
	,6.797452950e-004
	,6.989024226e-004
	,7.185234015e-004
	,7.385783368e-004
	,7.590355810e-004
	,7.798618847e-004
	,8.010228883e-004
	,8.224833285e-004
	,8.442076354e-004
	,8.661605038e-004
	,-5.596540344e-004
	,-5.433418902e-004
	,-5.269205438e-004
	,-5.105118051e-004
	,-4.942491555e-004
	,-4.781795900e-004
	,-4.622206555e-004
	,-4.462374433e-004
	,-4.300615900e-004
	,-4.135035918e-004
	,-3.964507421e-004
	,-3.789919229e-004
	,-3.613984206e-004
	,-3.439337861e-004
	,-3.267432531e-004
	,-3.098793662e-004
	,-2.933520624e-004
	,-2.771547020e-004
	,-2.612821656e-004
	,-2.457511646e-004
	,-2.305907409e-004
	,-2.158148702e-004
	,-2.014183109e-004
	,-1.874095644e-004
	,-1.738229947e-004
	,-1.606806681e-004
	,-1.479549327e-004
	,-1.355652237e-004
	,-1.234056368e-004
	,-1.113529388e-004
	,-9.934511216e-005
	,-8.753017941e-005
	,-7.610444354e-005
	,-6.516099499e-005
	,-5.471058459e-005
	,-4.470171186e-005
	,-3.503528919e-005
	,-2.568646342e-005
	,-1.673026344e-005
	,-8.178001303e-006
	,-4.751859371e-018
	,7.834914177e-006
	,1.536573066e-005
	,2.264330840e-005
	,2.972106468e-005
	,3.664596029e-005
	,4.345173080e-005
	,5.015099102e-005
	,5.671626560e-005
	,6.303213898e-005
	,6.894879056e-005
	,7.452396357e-005
	,7.987672120e-005
	,8.503325295e-005
	,8.997577044e-005
	,9.469943090e-005
	,9.918528212e-005
	,1.034131206e-004
	,1.074860779e-004
	,1.115344891e-004
	,1.156133654e-004
	,1.197341969e-004
	,1.238940862e-004
	,1.280857453e-004
	,1.323000223e-004
	,1.365256360e-004
	,1.407462748e-004
	,1.449356282e-004
	,1.490693580e-004
	,1.531208068e-004
	,1.570389394e-004
	,1.607486267e-004
	,1.642400273e-004
	,1.675176266e-004
	,1.705352068e-004
	,1.734040524e-004
	,1.762432580e-004
	,1.790831861e-004
	,1.819218156e-004
	,1.847497994e-004
	,1.875575983e-004
	,1.903335587e-004
	,1.930202150e-004
	,1.954439348e-004
	,1.977205622e-004
	,2.000069830e-004
	,2.023142264e-004
	,2.046355859e-004
	,2.069648156e-004
	,2.092922298e-004
	,2.115978477e-004
	,2.138669010e-004
	,2.161218961e-004
	,2.183842099e-004
	,2.206597216e-004
	,2.229484238e-004
	,2.252490224e-004
	,2.275606514e-004
	,2.298815650e-004
	,2.322056252e-004
	,2.345155920e-004
	,2.367811429e-004
	,2.390036532e-004
	,2.412162667e-004
	,2.434354227e-004
	,2.456649983e-004
	,2.479058404e-004
	,2.501575621e-004
	,2.524185982e-004
	,2.546871566e-004
	,2.569654828e-004
	,2.592557534e-004
	,2.615582910e-004
	,2.638729115e-004
	,2.661993891e-004
	,2.685376091e-004
	,2.708876266e-004
	,2.732495426e-004
	,2.756231221e-004
	,2.780074969e-004
	,2.804010331e-004
	,2.828004914e-004
	,2.851991720e-004
	,2.875910297e-004
	,2.899802327e-004
	,2.923734081e-004
	,2.947735483e-004
	,2.971818120e-004
	,2.995988316e-004
	,3.020246602e-004
	,3.044585011e-004
	,3.068989899e-004
	,3.093444103e-004
	,3.117938673e-004
	,3.142486931e-004
	,3.167110097e-004
	,3.191823722e-004
	,3.216638175e-004
	,3.241560887e-004
	,3.266596525e-004
	,3.291744865e-004
	,3.317001243e-004
	,3.342360835e-004
	,3.367820222e-004
	,3.393377280e-004
	,3.419031239e-004
	,3.444782894e-004
	,3.470633981e-004
	,3.496583693e-004
	,3.522620046e-004
	,3.548687546e-004
	,3.574553185e-004
	,3.600137154e-004
	,3.625679854e-004
	,3.651241958e-004
	,3.676829419e-004
	,3.702446439e-004
	,3.728106875e-004
	,3.753839957e-004
	,3.779693744e-004
	,3.805735216e-004
	,3.832047699e-004
	,3.858729528e-004
	,3.885894924e-004
	,3.913677495e-004
	,3.942236101e-004
	,3.971761577e-004
	,4.002481400e-004
	,4.034662942e-004
	,4.068615063e-004
	,4.104687769e-004
	,4.143269120e-004
	,4.184778417e-004
	,4.229655769e-004
	,4.278348970e-004
	,4.331299089e-004
	,4.388925300e-004
	,4.451607588e-004
	,4.519674790e-004
	,4.593401563e-004
	,4.673006468e-004
	,4.758650866e-004
	,4.850439317e-004
	,4.948421122e-004
	,5.052590223e-004
	,5.162882509e-004
	,5.279170320e-004
	,5.401380812e-004
	,5.529348557e-004
	,5.663024824e-004
	,5.797385565e-004
	,5.933551180e-004
	,6.074948615e-004
	,6.221374987e-004
	,6.372682571e-004
	,6.528748152e-004
	,6.689304342e-004
	,6.854156147e-004
	,7.023051597e-004
	,7.195734300e-004
	,7.371977929e-004
	,-5.941111289e-004
	,-5.776704376e-004
	,-5.614366607e-004
	,-5.454774714e-004
	,-5.297223445e-004
	,-5.139440819e-004
	,-4.979084548e-004
	,-4.814596613e-004
	,-4.645067156e-004
	,-4.470646471e-004
	,-4.293018855e-004
	,-4.114801331e-004
	,-3.938137469e-004
	,-3.764108691e-004
	,-3.592819751e-004
	,-3.423759097e-004
	,-3.256189508e-004
	,-3.089643599e-004
	,-2.924487350e-004
	,-2.761456904e-004
	,-2.600890703e-004
	,-2.442706092e-004
	,-2.287137741e-004
	,-2.134778608e-004
	,-1.985690314e-004
	,-1.839523219e-004
	,-1.695827492e-004
	,-1.553968073e-004
	,-1.413749762e-004
	,-1.275900919e-004
	,-1.141413644e-004
	,-1.010943764e-004
	,-8.847608355e-005
	,-7.628462239e-005
	,-6.449438107e-005
	,-5.305978795e-005
	,-4.191807233e-005
	,-3.099577225e-005
	,-2.029262605e-005
	,-9.934074423e-006
	,-1.180106925e-017
	,9.521739948e-006
	,1.867899508e-005
	,2.752894288e-005
	,3.612846327e-005
	,4.452781623e-005
	,5.276123666e-005
	,6.082503589e-005
	,6.863414712e-005
	,7.605040627e-005
	,8.309868114e-005
	,8.990836861e-005
	,9.655025124e-005
	,1.030517884e-004
	,1.094168804e-004
	,1.156358733e-004
	,1.216971404e-004
	,1.275930499e-004
	,1.333250417e-004
	,1.389112088e-004
	,1.443798107e-004
	,1.497546387e-004
	,1.550491632e-004
	,1.602667388e-004
	,1.654006359e-004
	,1.704322064e-004
	,1.753302723e-004
	,1.800676930e-004
	,1.846654318e-004
	,1.891908798e-004
	,1.936997478e-004
	,1.982156506e-004
	,2.027351787e-004
	,2.072249688e-004
	,2.116163023e-004
	,2.158564053e-004
	,2.199741882e-004
	,2.240184905e-004
	,2.280110591e-004
	,2.319526384e-004
	,2.358247184e-004
	,2.396099763e-004
	,2.433223286e-004
	,2.469551744e-004
	,2.504743839e-004
	,2.538506508e-004
	,2.571007891e-004
	,2.601420787e-004
	,2.627459102e-004
	,2.652111054e-004
	,2.677259905e-004
	,2.702902424e-004
	,2.728862163e-004
	,2.755001953e-004
	,2.781233605e-004
	,2.807507393e-004
	,2.833796332e-004
	,2.860083832e-004
	,2.886357706e-004
	,2.912606990e-004
	,2.938818443e-004
	,2.964970215e-004
	,2.991015281e-004
	,3.016829326e-004
	,3.042103306e-004
	,3.066461826e-004
	,3.090033977e-004
	,3.113149775e-004
	,3.135880300e-004
	,3.158306061e-004
	,3.180657801e-004
	,3.203062551e-004
	,3.225547540e-004
	,3.248108345e-004
	,3.270734310e-004
	,3.293416230e-004
	,3.316146976e-004
	,3.338918697e-004
	,3.361722225e-004
	,3.384545557e-004
	,3.407374804e-004
	,3.430220657e-004
	,3.453089639e-004
	,3.475977764e-004
	,3.498871331e-004
	,3.521733486e-004
	,3.544474360e-004
	,3.566972365e-004
	,3.589249012e-004
	,3.611463804e-004
	,3.633714979e-004
	,3.656033793e-004
	,3.678426513e-004
	,3.700878861e-004
	,3.723364574e-004
	,3.745851712e-004
	,3.768298161e-004
	,3.790666912e-004
	,3.812963990e-004
	,3.835225674e-004
	,3.857481458e-004
	,3.879746971e-004
	,3.902026937e-004
	,3.924319157e-004
	,3.946620431e-004
	,3.968930868e-004
	,3.991250028e-004
	,4.013572255e-004
	,4.035893959e-004
	,4.058215127e-004
	,4.080537690e-004
	,4.102864878e-004
	,4.125201009e-004
	,4.147551382e-004
	,4.169922028e-004
	,4.192315794e-004
	,4.214705828e-004
	,4.236907473e-004
	,4.258623463e-004
	,4.280119581e-004
	,4.301558539e-004
	,4.322958448e-004
	,4.344315563e-004
	,4.365624318e-004
	,4.386880020e-004
	,4.408079031e-004
	,4.429220425e-004
	,4.450309910e-004
	,4.471364487e-004
	,4.492415602e-004
	,4.513507960e-004
	,4.534705068e-004
	,4.556099193e-004
	,4.577816352e-004
	,4.600018095e-004
	,4.622904956e-004
	,4.646718817e-004
	,4.671744185e-004
	,4.698305561e-004
	,4.726760215e-004
	,4.757489870e-004
	,4.790896556e-004
	,4.827399168e-004
	,4.867422713e-004
	,4.911383369e-004
	,4.959670871e-004
	,5.012636865e-004
	,5.070588268e-004
	,5.133785392e-004
	,5.202444809e-004
	,5.276739638e-004
	,5.356791085e-004
	,5.442677453e-004
	,5.534452807e-004
	,5.632136570e-004
	,5.735713261e-004
	,5.845141346e-004
	,5.959062576e-004
	,6.072133684e-004
	,6.190458784e-004
	,6.313857508e-004
	,-6.220231730e-004
	,-6.048937297e-004
	,-5.880558350e-004
	,-5.714122903e-004
	,-5.547364357e-004
	,-5.378583881e-004
	,-5.207644432e-004
	,-5.034640488e-004
	,-4.859749716e-004
	,-4.684062766e-004
	,-4.509462864e-004
	,-4.337094587e-004
	,-4.167059696e-004
	,-3.998516827e-004
	,-3.830510139e-004
	,-3.662875821e-004
	,-3.496175288e-004
	,-3.330944329e-004
	,-3.167272637e-004
	,-3.004718969e-004
	,-2.842556870e-004
	,-2.680477355e-004
	,-2.518463332e-004
	,-2.356371205e-004
	,-2.194588806e-004
	,-2.033859722e-004
	,-1.874980603e-004
	,-1.718795566e-004
	,-1.565964067e-004
	,-1.416836765e-004
	,-1.271501060e-004
	,-1.129883525e-004
	,-9.918782509e-005
	,-8.574707249e-005
	,-7.266139845e-005
	,-5.990375932e-005
	,-4.742429581e-005
	,-3.516220247e-005
	,-2.311563192e-005
	,-1.137464863e-005
	,-1.697494502e-022
	,1.100789014e-005
	,2.167476456e-005
	,3.203155457e-005
	,4.210015512e-005
	,5.187249380e-005
	,6.129667767e-005
	,7.029593751e-005
	,7.879582623e-005
	,8.685018529e-005
	,9.458764197e-005
	,1.021006636e-004
	,1.094446504e-004
	,1.166558522e-004
	,1.237598417e-004
	,1.307746983e-004
	,1.377125946e-004
	,1.445807691e-004
	,1.513820037e-004
	,1.581146544e-004
	,1.647723149e-004
	,1.713432599e-004
	,1.778101527e-004
	,1.841518885e-004
	,1.903503321e-004
	,1.963984430e-004
	,2.023021644e-004
	,2.080773899e-004
	,2.137442297e-004
	,2.193205712e-004
	,2.248183374e-004
	,2.302415398e-004
	,2.355829249e-004
	,2.408195342e-004
	,2.459227798e-004
	,2.508887514e-004
	,2.557321754e-004
	,2.604617365e-004
	,2.650874163e-004
	,2.696307016e-004
	,2.741150828e-004
	,2.785564892e-004
	,2.829633493e-004
	,2.873393982e-004
	,2.916856234e-004
	,2.960011943e-004
	,3.002837065e-004
	,3.045287882e-004
	,3.087285416e-004
	,3.128664913e-004
	,3.168981026e-004
	,3.206624347e-004
	,3.238115324e-004
	,3.265864834e-004
	,3.293401380e-004
	,3.321258252e-004
	,3.349287723e-004
	,3.377260922e-004
	,3.404944294e-004
	,3.432183269e-004
	,3.459046503e-004
	,3.485720551e-004
	,3.512321764e-004
	,3.538884346e-004
	,3.565394371e-004
	,3.591793042e-004
	,3.617945478e-004
	,3.643639668e-004
	,3.668773853e-004
	,3.693451060e-004
	,3.717787053e-004
	,3.741838262e-004
	,3.765625438e-004
	,3.789153309e-004
	,3.812419497e-004
	,3.835418571e-004
	,3.858144313e-004
	,3.880591466e-004
	,3.902757243e-004
	,3.924641891e-004
	,3.946247804e-004
	,3.967578659e-004
	,3.988639299e-004
	,4.009434833e-004
	,4.029966843e-004
	,4.050226584e-004
	,4.070212540e-004
	,4.089981131e-004
	,4.109591580e-004
	,4.129054282e-004
	,4.148336510e-004
	,4.167391373e-004
	,4.186243592e-004
	,4.204976194e-004
	,4.223631871e-004
	,4.242192749e-004
	,4.260689300e-004
	,4.279140491e-004
	,4.297541745e-004
	,4.315875554e-004
	,4.334104823e-004
	,4.352173464e-004
	,4.370054867e-004
	,4.387798327e-004
	,4.405470405e-004
	,4.423109095e-004
	,4.440733085e-004
	,4.458345597e-004
	,4.475943480e-004
	,4.493526255e-004
	,4.511094337e-004
	,4.528650255e-004
	,4.546201743e-004
	,4.563759425e-004
	,4.581322058e-004
	,4.598876362e-004
	,4.616412615e-004
	,4.633927698e-004
	,4.651422465e-004
	,4.668900050e-004
	,4.686364925e-004
	,4.703821193e-004
	,4.721265121e-004
	,4.738643360e-004
	,4.755685331e-004
	,4.772276158e-004
	,4.788757532e-004
	,4.805235998e-004
	,4.821724165e-004
	,4.838214027e-004
	,4.854697596e-004
	,4.871173438e-004
	,4.887645313e-004
	,4.904121362e-004
	,4.920614117e-004
	,4.937141132e-004
	,4.953726496e-004
	,4.970403123e-004
	,4.987215848e-004
	,5.004225192e-004
	,5.021510257e-004
	,5.039166483e-004
	,5.057303112e-004
	,5.076052069e-004
	,5.095579286e-004
	,5.116089006e-004
	,5.137824818e-004
	,5.161069248e-004
	,5.186140910e-004
	,5.213390870e-004
	,5.243188538e-004
	,5.275919639e-004
	,5.311970107e-004
	,5.351721387e-004
	,5.395534686e-004
	,5.443728450e-004
	,5.496575919e-004
	,5.554315450e-004
	,5.617133328e-004
	,5.685176707e-004
	,5.758554348e-004
	,-6.470740423e-004
	,-6.295891047e-004
	,-6.122145341e-004
	,-5.947749609e-004
	,-5.771009604e-004
	,-5.591929628e-004
	,-5.410990259e-004
	,-5.228359281e-004
	,-5.044914570e-004
	,-4.862563691e-004
	,-4.682501106e-004
	,-4.505397320e-004
	,-4.331731891e-004
	,-4.161755713e-004
	,-3.995484338e-004
	,-3.832640312e-004
	,-3.672530987e-004
	,-3.513826438e-004
	,-3.354481959e-004
	,-3.192576745e-004
	,-3.027652986e-004
	,-2.860534499e-004
	,-2.691994161e-004
	,-2.522867356e-004
	,-2.354572195e-004
	,-2.188317950e-004
	,-2.024637488e-004
	,-1.863441241e-004
	,-1.704290673e-004
	,-1.547013451e-004
	,-1.391953225e-004
	,-1.239728117e-004
	,-1.090780467e-004
	,-9.451780460e-005
	,-8.027142483e-005
	,-6.629480449e-005
	,-5.252661535e-005
	,-3.894232685e-005
	,-2.561136157e-005
	,-1.261803884e-005
	,2.453999616e-018
	,1.223483034e-005
	,2.409252888e-005
	,3.558356525e-005
	,4.670940985e-005
	,5.744769207e-005
	,6.774593007e-005
	,7.757697505e-005
	,8.699653281e-005
	,9.608652915e-005
	,1.049032281e-004
	,1.134651837e-004
	,1.217466580e-004
	,1.297450451e-004
	,1.375281545e-004
	,1.451495492e-004
	,1.526389562e-004
	,1.600149815e-004
	,1.672902106e-004
	,1.744732360e-004
	,1.815698161e-004
	,1.885838063e-004
	,1.955179484e-004
	,2.023743678e-004
	,2.091547055e-004
	,2.158600158e-004
	,2.224906209e-004
	,2.290459987e-004
	,2.355246165e-004
	,2.419234120e-004
	,2.482363645e-004
	,2.544517345e-004
	,2.605504533e-004
	,2.665157762e-004
	,2.723520507e-004
	,2.780803571e-004
	,2.837206142e-004
	,2.892862400e-004
	,2.947855190e-004
	,3.002232516e-004
	,3.056018144e-004
	,3.109217469e-004
	,3.161819770e-004
	,3.213797432e-004
	,3.265102222e-004
	,3.315658616e-004
	,3.365356169e-004
	,3.414049802e-004
	,3.461582552e-004
	,3.507819528e-004
	,3.552654553e-004
	,3.596012562e-004
	,3.637846637e-004
	,3.677969810e-004
	,3.715324739e-004
	,3.746777433e-004
	,3.773791080e-004
	,3.800811149e-004
	,3.828406813e-004
	,3.856338632e-004
	,3.884387825e-004
	,3.912401622e-004
	,3.940271095e-004
	,3.967908334e-004
	,3.995215912e-004
	,4.022010888e-004
	,4.047967781e-004
	,4.073131798e-004
	,4.097858727e-004
	,4.122279308e-004
	,4.146393035e-004
	,4.170162934e-004
	,4.193539624e-004
	,4.216475540e-004
	,4.238981985e-004
	,4.261141917e-004
	,4.283034799e-004
	,4.304703589e-004
	,4.326167451e-004
	,4.347434896e-004
	,4.368510049e-004
	,4.389395437e-004
	,4.410093465e-004
	,4.430607166e-004
	,4.450940090e-004
	,4.471095678e-004
	,4.491076864e-004
	,4.510886087e-004
	,4.530525410e-004
	,4.549996530e-004
	,4.569300564e-004
	,4.588437423e-004
	,4.607404208e-004
	,4.626191262e-004
	,4.644774156e-004
	,4.663111881e-004
	,4.681192574e-004
	,4.699074273e-004
	,4.716818827e-004
	,4.734453996e-004
	,4.751986803e-004
	,4.769414501e-004
	,4.786728011e-004
	,4.803919726e-004
	,4.820983629e-004
	,4.837887325e-004
	,4.854561530e-004
	,4.870936490e-004
	,4.886992528e-004
	,4.902713561e-004
	,4.918246810e-004
	,4.933715815e-004
	,4.949146903e-004
	,4.964547185e-004
	,4.979915154e-004
	,4.995242350e-004
	,5.010518926e-004
	,5.025737130e-004
	,5.040891557e-004
	,5.055978625e-004
	,5.070996200e-004
	,5.085943573e-004
	,5.100822360e-004
	,5.115638213e-004
	,5.130392195e-004
	,5.145080527e-004
	,5.159703580e-004
	,5.174262251e-004
	,5.188753408e-004
	,5.203158988e-004
	,5.217389455e-004
	,5.231126374e-004
	,5.244396934e-004
	,5.257556998e-004
	,5.270680426e-004
	,5.283760916e-004
	,5.296787078e-004
	,5.309751726e-004
	,5.322651687e-004
	,5.335487237e-004
	,5.348261979e-004
	,5.360983141e-004
	,5.373662190e-004
	,5.386315522e-004
	,5.398964671e-004
	,5.411635737e-004
	,5.424359811e-004
	,5.437177138e-004
	,5.450142246e-004
	,5.463320008e-004
	,5.476788025e-004
	,5.490648550e-004
	,5.505031129e-004
	,5.520093918e-004
	,5.536025831e-004
	,5.553047369e-004
	,5.571411364e-004
	,5.591401543e-004
	,5.613330042e-004
	,5.637532063e-004
	,5.664359212e-004
	,-6.704398795e-004
	,-6.524240371e-004
	,-6.343820553e-004
	,-6.161382540e-004
	,-5.976136454e-004
	,-5.788776399e-004
	,-5.599576495e-004
	,-5.409122022e-004
	,-5.219322035e-004
	,-5.031684536e-004
	,-4.846943405e-004
	,-4.665763467e-004
	,-4.488466109e-004
	,-4.315047071e-004
	,-4.145274902e-004
	,-3.978664914e-004
	,-3.814356987e-004
	,-3.651154899e-004
	,-3.487989410e-004
	,-3.323860040e-004
	,-3.157763311e-004
	,-2.989304958e-004
	,-2.819161100e-004
	,-2.648673935e-004
	,-2.478886191e-004
	,-2.310463715e-004
	,-2.143781717e-004
	,-1.978850876e-004
	,-1.815562396e-004
	,-1.654111387e-004
	,-1.494762755e-004
	,-1.337497824e-004
	,-1.181952896e-004
	,-1.027634529e-004
	,-8.742970073e-005
	,-7.219223823e-005
	,-5.710172445e-005
	,-4.226541121e-005
	,-2.777715210e-005
	,-1.368414203e-005
	,1.456819733e-017
	,1.327370571e-005
	,2.613221545e-005
	,3.855984788e-005
	,5.052587884e-005
	,6.199798413e-005
	,7.298061953e-005
	,8.352050142e-005
	,9.367684796e-005
	,1.035034197e-004
	,1.130447930e-004
	,1.223375282e-004
	,1.314118787e-004
	,1.402928984e-004
	,1.490008845e-004
	,1.575510215e-004
	,1.659513244e-004
	,1.741957111e-004
	,1.822484393e-004
	,1.900630081e-004
	,1.976726866e-004
	,2.051440614e-004
	,2.125137924e-004
	,2.197996537e-004
	,2.270116779e-004
	,2.341561347e-004
	,2.412368331e-004
	,2.482553497e-004
	,2.552105070e-004
	,2.620970230e-004
	,2.689038504e-004
	,2.756160953e-004
	,2.822260131e-004
	,2.887409214e-004
	,2.951730367e-004
	,3.015290521e-004
	,3.078090805e-004
	,3.140080406e-004
	,3.201156571e-004
	,3.261145732e-004
	,3.319774474e-004
	,3.376679992e-004
	,3.431569233e-004
	,3.484476457e-004
	,3.535756407e-004
	,3.585818576e-004
	,3.634967730e-004
	,3.683396151e-004
	,3.731217185e-004
	,3.778492906e-004
	,3.825250701e-004
	,3.871491750e-004
	,3.917193440e-004
	,3.962304911e-004
	,4.006729251e-004
	,4.050267308e-004
	,4.092417540e-004
	,4.131551767e-004
	,4.163846359e-004
	,4.191689726e-004
	,4.219921802e-004
	,4.248903877e-004
	,4.278313024e-004
	,4.307906088e-004
	,4.337519778e-004
	,4.367039153e-004
	,4.396379484e-004
	,4.425476278e-004
	,4.454279389e-004
	,4.482749401e-004
	,4.510855579e-004
	,4.538575186e-004
	,4.565893082e-004
	,4.592798047e-004
	,4.619276308e-004
	,4.645307069e-004
	,4.670854079e-004
	,4.695832165e-004
	,4.720009492e-004
	,4.743094403e-004
	,4.765323036e-004
	,4.787044077e-004
	,4.808382895e-004
	,4.829373360e-004
	,4.850021197e-004
	,4.870319378e-004
	,4.890250052e-004
	,4.909788527e-004
	,4.928928634e-004
	,4.947709979e-004
	,4.966189921e-004
	,4.984407549e-004
	,5.002382514e-004
	,5.020123906e-004
	,5.037635778e-004
	,5.054919514e-004
	,5.071974352e-004
	,5.088796295e-004
	,5.105374722e-004
	,5.121686510e-004
	,5.137695720e-004
	,5.153385999e-004
	,5.168800734e-004
	,5.184001993e-004
	,5.199024732e-004
	,5.213881129e-004
	,5.228573050e-004
	,5.243097821e-004
	,5.257449350e-004
	,5.271616196e-004
	,5.285576662e-004
	,5.299294083e-004
	,5.312728389e-004
	,5.325871173e-004
	,5.338753063e-004
	,5.351411413e-004
	,5.363872300e-004
	,5.376152171e-004
	,5.388263174e-004
	,5.400213587e-004
	,5.412005258e-004
	,5.423633315e-004
	,5.435069144e-004
	,5.446291967e-004
	,5.457360882e-004
	,5.468294642e-004
	,5.479095757e-004
	,5.489766654e-004
	,5.500312770e-004
	,5.510743393e-004
	,5.521069433e-004
	,5.531298155e-004
	,5.541431878e-004
	,5.551471716e-004
	,5.561419178e-004
	,5.571273991e-004
	,5.581026134e-004
	,5.590619499e-004
	,5.599827047e-004
	,5.608583819e-004
	,5.617197013e-004
	,5.625762536e-004
	,5.634291236e-004
	,5.642781772e-004
	,5.651232064e-004
	,5.659641038e-004
	,5.668008859e-004
	,5.676337377e-004
	,5.684631212e-004
	,5.692899526e-004
	,5.701157068e-004
	,5.709418249e-004
	,5.717690532e-004
	,5.725983638e-004
	,5.734317146e-004
	,5.742720795e-004
	,5.751234629e-004
	,5.759910391e-004
	,5.768813755e-004
	,5.778027165e-004
	,5.787653085e-004
	,-6.915417243e-004
	,-6.730357366e-004
	,-6.543900375e-004
	,-6.354183751e-004
	,-6.161640271e-004
	,-5.967191610e-004
	,-5.771427444e-004
	,-5.575981903e-004
	,-5.382648945e-004
	,-5.192165578e-004
	,-5.005063158e-004
	,-4.821777768e-004
	,-4.642316651e-004
	,-4.466368222e-004
	,-4.293313262e-004
	,-4.122120222e-004
	,-3.951518275e-004
	,-3.780609997e-004
	,-3.608643090e-004
	,-3.435059616e-004
	,-3.260363677e-004
	,-3.085818192e-004
	,-2.912787907e-004
	,-2.741966200e-004
	,-2.573300447e-004
	,-2.406229908e-004
	,-2.240000344e-004
	,-2.074184718e-004
	,-1.908749113e-004
	,-1.743878610e-004
	,-1.579864180e-004
	,-1.416724568e-004
	,-1.253969463e-004
	,-1.090980614e-004
	,-9.279957527e-005
	,-7.661410085e-005
	,-6.064191754e-005
	,-4.494404552e-005
	,-2.957257271e-005
	,-1.457854224e-005
	,-2.313202143e-017
	,1.413393071e-005
	,2.779767109e-005
	,4.096842492e-005
	,5.363573594e-005
	,6.581196542e-005
	,7.752830471e-005
	,8.882494275e-005
	,9.974259880e-005
	,1.103187112e-004
	,1.205869504e-004
	,1.305778511e-004
	,1.403191443e-004
	,1.498357854e-004
	,1.591501350e-004
	,1.682820818e-004
	,1.772491719e-004
	,1.860667545e-004
	,1.947481078e-004
	,2.033044755e-004
	,2.117449136e-004
	,2.200757476e-004
	,2.282990970e-004
	,2.364089144e-004
	,2.443813494e-004
	,2.521670439e-004
	,2.597405849e-004
	,2.671503241e-004
	,2.744457036e-004
	,2.816434975e-004
	,2.887428459e-004
	,2.957419950e-004
	,3.026435686e-004
	,3.094455666e-004
	,3.161316670e-004
	,3.226668147e-004
	,3.290063096e-004
	,3.351310415e-004
	,3.410697208e-004
	,3.468695133e-004
	,3.525669455e-004
	,3.581843403e-004
	,3.637346388e-004
	,3.692253731e-004
	,3.746609253e-004
	,3.800437279e-004
	,3.853749021e-004
	,3.906546017e-004
	,3.958821970e-004
	,4.010563739e-004
	,4.061751910e-004
	,4.112361175e-004
	,4.162360443e-004
	,4.211712150e-004
	,4.260369426e-004
	,4.308268511e-004
	,4.355310338e-004
	,4.401312343e-004
	,4.445855810e-004
	,4.487676324e-004
	,4.522750376e-004
	,4.550593815e-004
	,4.578852298e-004
	,4.608558387e-004
	,4.639065193e-004
	,4.669904098e-004
	,4.700777907e-004
	,4.731487593e-004
	,4.761889716e-004
	,4.791874052e-004
	,4.821354710e-004
	,4.850272356e-004
	,4.878600590e-004
	,4.906343048e-004
	,4.933519158e-004
	,4.960150887e-004
	,4.986254832e-004
	,5.011838605e-004
	,5.036902378e-004
	,5.061442548e-004
	,5.085454470e-004
	,5.108933864e-004
	,5.131877374e-004
	,5.154282647e-004
	,5.176148097e-004
	,5.197472332e-004
	,5.218253014e-004
	,5.238484359e-004
	,5.258150731e-004
	,5.277207148e-004
	,5.295520059e-004
	,5.312835542e-004
	,5.329192926e-004
	,5.344926326e-004
	,5.360206294e-004
	,5.375089101e-004
	,5.389597881e-004
	,5.403747523e-004
	,5.417550960e-004
	,5.431019336e-004
	,5.444159969e-004
	,5.456976261e-004
	,5.469476899e-004
	,5.481685395e-004
	,5.493624911e-004
	,5.505299606e-004
	,5.516700170e-004
	,5.527835740e-004
	,5.538750842e-004
	,5.549491638e-004
	,5.560083365e-004
	,5.570535989e-004
	,5.580852292e-004
	,5.591031445e-004
	,5.601069817e-004
	,5.610960247e-004
	,5.620690279e-004
	,5.630241521e-004
	,5.639596307e-004
	,5.648751698e-004
	,5.657722116e-004
	,5.666527091e-004
	,5.675182822e-004
	,5.683701430e-004
	,5.692092472e-004
	,5.700363987e-004
	,5.708522478e-004
	,5.716572479e-004
	,5.724516932e-004
	,5.732358215e-004
	,5.740099007e-004
	,5.747743634e-004
	,5.755298929e-004
	,5.762771314e-004
	,5.770156517e-004
	,5.777431221e-004
	,5.784602208e-004
	,5.791698307e-004
	,5.798725596e-004
	,5.805685455e-004
	,5.812578317e-004
	,5.819403993e-004
	,5.826161159e-004
	,5.832845036e-004
	,5.839436027e-004
	,5.845840553e-004
	,5.851857540e-004
	,5.857632198e-004
	,5.863334194e-004
	,5.868983486e-004
	,5.874569461e-004
	,5.880077020e-004
	,5.885490578e-004
	,5.890795591e-004
	,5.895978980e-004
	,5.901027254e-004
	,5.905934558e-004
	,5.910707341e-004
	,5.915363736e-004
	,5.919930813e-004
	,5.924440754e-004
	,-7.101559189e-004
	,-6.911572842e-004
	,-6.718702910e-004
	,-6.522528824e-004
	,-6.324384658e-004
	,-6.124923161e-004
	,-5.925262964e-004
	,-5.727358459e-004
	,-5.532320063e-004
	,-5.340449498e-004
	,-5.152173962e-004
	,-4.967648948e-004
	,-4.786568856e-004
	,-4.608229615e-004
	,-4.431459024e-004
	,-4.254858355e-004
	,-4.077557565e-004
	,-3.899031463e-004
	,-3.718942691e-004
	,-3.537981264e-004
	,-3.357544714e-004
	,-3.178988934e-004
	,-3.002975788e-004
	,-2.829382167e-004
	,-2.657670135e-004
	,-2.487449371e-004
	,-2.318631138e-004
	,-2.150986167e-004
	,-1.983972869e-004
	,-1.816748989e-004
	,-1.648195156e-004
	,-1.477518456e-004
	,-1.305371094e-004
	,-1.133400254e-004
	,-9.629769650e-005
	,-7.948934644e-005
	,-6.295605976e-005
	,-4.672000940e-005
	,-3.079769742e-005
	,-1.521224856e-005
	,1.861617835e-015
	,1.479782877e-005
	,2.914221912e-005
	,4.300505998e-005
	,5.638059951e-005
	,6.928380727e-005
	,8.174178909e-005
	,9.378517122e-005
	,1.054439274e-004
	,1.167466070e-004
	,1.277204095e-004
	,1.383912824e-004
	,1.487839352e-004
	,1.589217900e-004
	,1.688269081e-004
	,1.785199182e-004
	,1.880199544e-004
	,1.973446010e-004
	,2.065098322e-004
	,2.155299303e-004
	,2.244172649e-004
	,2.331822533e-004
	,2.418342122e-004
	,2.503803169e-004
	,2.588252642e-004
	,2.671708756e-004
	,2.754151880e-004
	,2.835510597e-004
	,2.915645142e-004
	,2.994322494e-004
	,3.071128130e-004
	,3.145309628e-004
	,3.216007369e-004
	,3.283198203e-004
	,3.347823615e-004
	,3.410801302e-004
	,3.472664079e-004
	,3.533692577e-004
	,3.594040565e-004
	,3.653797083e-004
	,3.713015351e-004
	,3.771726832e-004
	,3.829948508e-004
	,3.887686858e-004
	,3.944940153e-004
	,4.001699841e-004
	,4.057951413e-004
	,4.113674998e-004
	,4.168845783e-004
	,4.223434339e-004
	,4.277406874e-004
	,4.330725419e-004
	,4.383347891e-004
	,4.435227945e-004
	,4.486314399e-004
	,4.536549805e-004
	,4.585867250e-004
	,4.634183135e-004
	,4.681379988e-004
	,4.727260655e-004
	,4.771402716e-004
	,4.812565714e-004
	,4.846322614e-004
	,4.871383529e-004
	,4.897716429e-004
	,4.926013790e-004
	,4.955247513e-004
	,4.984821689e-004
	,5.014395281e-004
	,5.043756657e-004
	,5.072764221e-004
	,5.101316950e-004
	,5.129338503e-004
	,5.156767901e-004
	,5.183553777e-004
	,5.209651327e-004
	,5.235022068e-004
	,5.259635458e-004
	,5.283469912e-004
	,5.306514645e-004
	,5.328775146e-004
	,5.350275799e-004
	,5.371053380e-004
	,5.391147853e-004
	,5.410598899e-004
	,5.429446689e-004
	,5.447730672e-004
	,5.465485832e-004
	,5.482740276e-004
	,5.499515531e-004
	,5.515828230e-004
	,5.531691842e-004
	,5.547117961e-004
	,5.562117125e-004
	,5.576699273e-004
	,5.590873936e-004
	,5.604650204e-004
	,5.618036437e-004
	,5.631039530e-004
	,5.643663123e-004
	,5.655902819e-004
	,5.667731542e-004
	,5.679058094e-004
	,5.689727374e-004
	,5.699800750e-004
	,5.709490783e-004
	,5.718896592e-004
	,5.728045422e-004
	,5.736938656e-004
	,5.745565093e-004
	,5.753903901e-004
	,5.761925732e-004
	,5.769598932e-004
	,5.776909757e-004
	,5.783881783e-004
	,5.790561188e-004
	,5.796995976e-004
	,5.803229988e-004
	,5.809298408e-004
	,5.815226842e-004
	,5.821033034e-004
	,5.826728394e-004
	,5.832318892e-004
	,5.837805855e-004
	,5.843188321e-004
	,5.848467877e-004
	,5.853651617e-004
	,5.858749459e-004
	,5.863770404e-004
	,5.868721443e-004
	,5.873607983e-004
	,5.878434426e-004
	,5.883204554e-004
	,5.887921733e-004
	,5.892589059e-004
	,5.897209457e-004
	,5.901785778e-004
	,5.906320922e-004
	,5.910817965e-004
	,5.915280245e-004
	,5.919711145e-004
	,5.924113459e-004
	,5.928489121e-004
	,5.932839214e-004
	,5.937165115e-004
	,5.941469986e-004
	,5.945758708e-004
	,5.950024616e-004
	,5.954262877e-004
	,5.958484787e-004
	,5.962690661e-004
	,5.966873969e-004
	,5.971007500e-004
	,5.974981542e-004
	,5.978719581e-004
	,5.982391884e-004
	,5.986069701e-004
	,5.989760561e-004
	,5.993462892e-004
	,5.997175210e-004
	,6.000897609e-004
	,-7.265857078e-004
	,-7.070614555e-004
	,-6.872232490e-004
	,-6.671332360e-004
	,-6.468904459e-004
	,-6.265747822e-004
	,-6.063697843e-004
	,-5.864398672e-004
	,-5.668269308e-004
	,-5.475432140e-004
	,-5.286189052e-004
	,-5.100382910e-004
	,-4.917328590e-004
	,-4.735807822e-004
	,-4.554338194e-004
	,-4.372048154e-004
	,-4.188605591e-004
	,-4.003761505e-004
	,-3.817928376e-004
	,-3.632426293e-004
	,-3.448676531e-004
	,-3.267420944e-004
	,-3.088531643e-004
	,-2.911585444e-004
	,-2.736413634e-004
	,-2.562854857e-004
	,-2.390440043e-004
	,-2.218317362e-004
	,-2.045147330e-004
	,-1.869633332e-004
	,-1.691910405e-004
	,-1.513607886e-004
	,-1.336262664e-004
	,-1.160671886e-004
	,-9.871347282e-005
	,-8.157669741e-005
	,-6.467028990e-005
	,-4.801761487e-005
	,-3.165579985e-005
	,-1.563538800e-005
	,3.304250163e-016
	,1.522909335e-005
	,3.004969557e-005
	,4.446860868e-005
	,5.849349541e-005
	,7.212542210e-005
	,8.535147554e-005
	,9.815923775e-005
	,1.105589084e-004
	,1.225763005e-004
	,1.342390051e-004
	,1.455725291e-004
	,1.566005440e-004
	,1.673454732e-004
	,1.778287909e-004
	,1.880710846e-004
	,1.980919743e-004
	,2.079099483e-004
	,2.175421546e-004
	,2.270041640e-004
	,2.363096975e-004
	,2.454702797e-004
	,2.544947282e-004
	,2.633883011e-004
	,2.721511699e-004
	,2.807756410e-004
	,2.892414450e-004
	,2.975099933e-004
	,3.055280261e-004
	,3.132665543e-004
	,3.207638050e-004
	,3.280875752e-004
	,3.352881336e-004
	,3.423929891e-004
	,3.494155218e-004
	,3.563609271e-004
	,3.632281443e-004
	,3.700087915e-004
	,3.766831412e-004
	,3.832169694e-004
	,3.895788868e-004
	,3.957785701e-004
	,4.018567277e-004
	,4.078460991e-004
	,4.137632766e-004
	,4.196149032e-004
	,4.254025245e-004
	,4.311250063e-004
	,4.367796806e-004
	,4.423629190e-004
	,4.478704450e-004
	,4.532975217e-004
	,4.586390750e-004
	,4.638897775e-004
	,4.690441013e-004
	,4.740963352e-004
	,4.790405507e-004
	,4.838704774e-004
	,4.885792049e-004
	,4.931585152e-004
	,4.975973266e-004
	,5.018776664e-004
	,5.059621487e-004
	,5.097417705e-004
	,5.127503358e-004
	,5.147015814e-004
	,5.169511859e-004
	,5.194546683e-004
	,5.220529228e-004
	,5.246689440e-004
	,5.272614364e-004
	,5.298083171e-004
	,5.322996093e-004
	,5.347319309e-004
	,5.371043396e-004
	,5.394163417e-004
	,5.416674169e-004
	,5.438571524e-004
	,5.459855498e-004
	,5.480532691e-004
	,5.500615124e-004
	,5.520115042e-004
	,5.539039895e-004
	,5.557390300e-004
	,5.575159478e-004
	,5.592331530e-004
	,5.608876621e-004
	,5.624741646e-004
	,5.639837747e-004
	,5.654040490e-004
	,5.667246177e-004
	,5.679482591e-004
	,5.690923376e-004
	,5.701768864e-004
	,5.712164200e-004
	,5.722196834e-004
	,5.731917230e-004
	,5.741355803e-004
	,5.750533281e-004
	,5.759466012e-004
	,5.768167824e-004
	,5.776650429e-004
	,5.784923875e-004
	,5.792997330e-004
	,5.800879761e-004
	,5.808580223e-004
	,5.816107740e-004
	,5.823470968e-004
	,5.830677812e-004
	,5.837735015e-004
	,5.844647569e-004
	,5.851417408e-004
	,5.858039708e-004
	,5.864491309e-004
	,5.870704735e-004
	,5.876610363e-004
	,5.882277795e-004
	,5.887795231e-004
	,5.893190136e-004
	,5.898467927e-004
	,5.903643703e-004
	,5.908745101e-004
	,5.913793937e-004
	,5.918800012e-004
	,5.923765773e-004
	,5.928690460e-004
	,5.933571858e-004
	,5.938406647e-004
	,5.943190328e-004
	,5.947917997e-004
	,5.952586511e-004
	,5.957195672e-004
	,5.961748028e-004
	,5.966247828e-004
	,5.970699372e-004
	,5.975106102e-004
	,5.979470588e-004
	,5.983794849e-004
	,5.988080677e-004
	,5.992329854e-004
	,5.996544228e-004
	,6.000725591e-004
	,6.004875423e-004
	,6.008994786e-004
	,6.013084485e-004
	,6.017145300e-004
	,6.021178098e-004
	,6.025183856e-004
	,6.029163656e-004
	,6.033118675e-004
	,6.037050191e-004
	,6.040959587e-004
	,6.044848417e-004
	,6.048718779e-004
	,6.052573015e-004
	,6.056413575e-004
	,6.060242293e-004
	,6.064059384e-004
	,6.067862039e-004
	,6.071636110e-004
	,6.075344021e-004
	,-7.414570361e-004
	,-7.214890109e-004
	,-7.012053868e-004
	,-6.807113501e-004
	,-6.600974345e-004
	,-6.395136726e-004
	,-6.191605543e-004
	,-5.991329264e-004
	,-5.794236253e-004
	,-5.600437242e-004
	,-5.410024563e-004
	,-5.222465054e-004
	,-5.036592580e-004
	,-4.850884941e-004
	,-4.664406834e-004
	,-4.476904472e-004
	,-4.288181241e-004
	,-4.098267366e-004
	,-3.908094315e-004
	,-3.719070494e-004
	,-3.532051371e-004
	,-3.347135019e-004
	,-3.164360844e-004
	,-2.983869524e-004
	,-2.805481715e-004
	,-2.628495717e-004
	,-2.451654284e-004
	,-2.273159693e-004
	,-2.091572650e-004
	,-1.907583516e-004
	,-1.723267873e-004
	,-1.540223261e-004
	,-1.359232938e-004
	,-1.180573038e-004
	,-1.004267625e-004
	,-8.302464306e-005
	,-6.584708741e-005
	,-4.890929159e-005
	,-3.225636505e-005
	,-1.594147232e-005
	,2.062529619e-017
	,1.555374519e-005
	,3.072031273e-005
	,4.550956102e-005
	,5.993943465e-005
	,7.403155316e-005
	,8.780461584e-005
	,1.012697790e-004
	,1.144256268e-004
	,1.272522159e-004
	,1.397150463e-004
	,1.517937294e-004
	,1.635029265e-004
	,1.748750572e-004
	,1.859416801e-004
	,1.967295547e-004
	,2.072617380e-004
	,2.175586978e-004
	,2.276387520e-004
	,2.375179778e-004
	,2.472096733e-004
	,2.567232335e-004
	,2.660619509e-004
	,2.752186099e-004
	,2.841673058e-004
	,2.928555920e-004
	,3.012269120e-004
	,3.092855561e-004
	,3.170996858e-004
	,3.247436044e-004
	,3.322699859e-004
	,3.397094483e-004
	,3.470779857e-004
	,3.543834834e-004
	,3.616295247e-004
	,3.688173083e-004
	,3.759465633e-004
	,3.830159684e-004
	,3.900233140e-004
	,3.969654623e-004
	,4.038379595e-004
	,4.106356201e-004
	,4.173532196e-004
	,4.239832051e-004
	,4.305148172e-004
	,4.369322717e-004
	,4.432117400e-004
	,4.493211486e-004
	,4.552350212e-004
	,4.609588555e-004
	,4.665211351e-004
	,4.719460501e-004
	,4.772454461e-004
	,4.824226555e-004
	,4.874765051e-004
	,4.924035553e-004
	,4.971991716e-004
	,5.018579409e-004
	,5.063736426e-004
	,5.107387838e-004
	,5.149436579e-004
	,5.189753886e-004
	,5.228194309e-004
	,5.264662981e-004
	,5.299128120e-004
	,5.331358126e-004
	,5.359843244e-004
	,5.375751749e-004
	,5.389572162e-004
	,5.408415189e-004
	,5.429016480e-004
	,5.450240486e-004
	,5.471574840e-004
	,5.492731573e-004
	,5.513516114e-004
	,5.533764466e-004
	,5.553294100e-004
	,5.571853719e-004
	,5.589131602e-004
	,5.604980048e-004
	,5.619630681e-004
	,5.633455120e-004
	,5.646713881e-004
	,5.659549359e-004
	,5.672036126e-004
	,5.684213088e-004
	,5.696100017e-004
	,5.707706183e-004
	,5.719035047e-004
	,5.730087031e-004
	,5.740861534e-004
	,5.751358825e-004
	,5.761581863e-004
	,5.771537442e-004
	,5.781236016e-004
	,5.790690315e-004
	,5.799913610e-004
	,5.808918427e-004
	,5.817715958e-004
	,5.826315974e-004
	,5.834726983e-004
	,5.842956471e-004
	,5.851011115e-004
	,5.858896963e-004
	,5.866619563e-004
	,5.874184050e-004
	,5.881595198e-004
	,5.888857447e-004
	,5.895974911e-004
	,5.902951402e-004
	,5.909790525e-004
	,5.916495933e-004
	,5.923071798e-004
	,5.929523249e-004
	,5.935856328e-004
	,5.942077327e-004
	,5.948192007e-004
	,5.954205172e-004
	,5.960120578e-004
	,5.965940915e-004
	,5.971667658e-004
	,5.977300585e-004
	,5.982836682e-004
	,5.988267724e-004
	,5.993574579e-004
	,5.998712900e-004
	,6.003603759e-004
	,6.008246633e-004
	,6.012758862e-004
	,6.017215100e-004
	,6.021640472e-004
	,6.026041663e-004
	,6.030419139e-004
	,6.034771074e-004
	,6.039094497e-004
	,6.043385566e-004
	,6.047639908e-004
	,6.051853717e-004
	,6.056025233e-004
	,6.060155057e-004
	,6.064245067e-004
	,6.068297364e-004
	,6.072314109e-004
	,6.076297898e-004
	,6.080251480e-004
	,6.084176891e-004
	,6.088075449e-004
	,6.091948171e-004
	,6.095795998e-004
	,6.099619822e-004
	,6.103420470e-004
	,6.107198722e-004
	,6.110955396e-004
	,6.114691458e-004
	,6.118408092e-004
	,6.122106683e-004
	,6.125788629e-004
	,6.129455036e-004
	,6.133106580e-004
	,6.136743657e-004
	,6.140366597e-004
	,-7.553091781e-004
	,-7.349223517e-004
	,-7.142340958e-004
	,-6.933697791e-004
	,-6.724581047e-004
	,-6.516975880e-004
	,-6.312476323e-004
	,-6.111334558e-004
	,-5.913247604e-004
	,-5.718327382e-004
	,-5.526332988e-004
	,-5.336251771e-004
	,-5.146553026e-004
	,-4.956132644e-004
	,-4.764618005e-004
	,-4.571702979e-004
	,-4.377203512e-004
	,-4.181771022e-004
	,-3.987013537e-004
	,-3.794313759e-004
	,-3.604167097e-004
	,-3.416669416e-004
	,-3.231793583e-004
	,-3.049176638e-004
	,-2.868093174e-004
	,-2.687229867e-004
	,-2.504337873e-004
	,-2.317673919e-004
	,-2.128205936e-004
	,-1.938287213e-004
	,-1.749633668e-004
	,-1.563097367e-004
	,-1.379007510e-004
	,-1.197421486e-004
	,-1.018269923e-004
	,-8.414652154e-005
	,-6.670466960e-005
	,-4.953346239e-005
	,-3.267653458e-005
	,-1.616165924e-005
	,1.470411267e-016
	,1.580519911e-005
	,3.125343973e-005
	,4.634980534e-005
	,6.110794934e-005
	,7.554617342e-005
	,8.968314364e-005
	,1.035356958e-004
	,1.171176521e-004
	,1.304387739e-004
	,1.435031148e-004
	,1.563058825e-004
	,1.688282270e-004
	,1.810335524e-004
	,1.928801613e-004
	,2.043546589e-004
	,2.154821316e-004
	,2.263007753e-004
	,2.368430465e-004
	,2.471317948e-004
	,2.571796999e-004
	,2.669857712e-004
	,2.765267538e-004
	,2.857526785e-004
	,2.946243435e-004
	,3.031654833e-004
	,3.114297627e-004
	,3.194658012e-004
	,3.273245019e-004
	,3.350572215e-004
	,3.427021561e-004
	,3.502807059e-004
	,3.578026286e-004
	,3.652713922e-004
	,3.726872970e-004
	,3.800489746e-004
	,3.873540500e-004
	,3.945994182e-004
	,4.017813500e-004
	,4.088955276e-004
	,4.159370555e-004
	,4.229004663e-004
	,4.297797336e-004
	,4.365682927e-004
	,4.432590739e-004
	,4.498445438e-004
	,4.563167506e-004
	,4.626673651e-004
	,4.688876879e-004
	,4.749685316e-004
	,4.808999986e-004
	,4.866722783e-004
	,4.922748291e-004
	,4.976945762e-004
	,5.029145591e-004
	,5.079124650e-004
	,5.126630417e-004
	,5.171494337e-004
	,5.213747442e-004
	,5.253626785e-004
	,5.291492967e-004
	,5.327659507e-004
	,5.362306394e-004
	,5.395505625e-004
	,5.427253928e-004
	,5.457468872e-004
	,5.485924270e-004
	,5.512099694e-004
	,5.535234442e-004
	,5.555022395e-004
	,5.568471540e-004
	,5.572026776e-004
	,5.582709832e-004
	,5.595176283e-004
	,5.608247414e-004
	,5.621527405e-004
	,5.634832185e-004
	,5.648058087e-004
	,5.661138541e-004
	,5.674026337e-004
	,5.686685431e-004
	,5.699087460e-004
	,5.711211470e-004
	,5.723045643e-004
	,5.734588677e-004
	,5.745848556e-004
	,5.756839069e-004
	,5.767576062e-004
	,5.778074678e-004
	,5.788347883e-004
	,5.798406127e-004
	,5.808257693e-004
	,5.817909266e-004
	,5.827366462e-004
	,5.836634231e-004
	,5.845717126e-004
	,5.854619470e-004
	,5.863345461e-004
	,5.871899223e-004
	,5.880284843e-004
	,5.888506395e-004
	,5.896567968e-004
	,5.904473694e-004
	,5.912227777e-004
	,5.919834507e-004
	,5.927298258e-004
	,5.934623456e-004
	,5.941814526e-004
	,5.948875833e-004
	,5.955811636e-004
	,5.962626043e-004
	,5.969322999e-004
	,5.975906273e-004
	,5.982379460e-004
	,5.988745990e-004
	,5.995009134e-004
	,6.001172016e-004
	,6.007237614e-004
	,6.013208769e-004
	,6.019088180e-004
	,6.024878392e-004
	,6.030581785e-004
	,6.036200531e-004
	,6.041736553e-004
	,6.047191447e-004
	,6.052566395e-004
	,6.057862089e-004
	,6.063078662e-004
	,6.068215589e-004
	,6.073271492e-004
	,6.078244260e-004
	,6.083132489e-004
	,6.087937912e-004
	,6.092665835e-004
	,6.097321864e-004
	,6.101906574e-004
	,6.106406598e-004
	,6.110778332e-004
	,6.114981699e-004
	,6.119071337e-004
	,6.123109558e-004
	,6.127118343e-004
	,6.131102385e-004
	,6.135061189e-004
	,6.138993504e-004
	,6.142899016e-004
	,6.146778381e-004
	,6.150632596e-004
	,6.154462561e-004
	,6.158268959e-004
	,6.162052298e-004
	,6.165812995e-004
	,6.169551470e-004
	,6.173268259e-004
	,6.176964228e-004
	,6.180640899e-004
	,6.184300477e-004
	,6.187944661e-004
	,6.191573739e-004
	,6.195187482e-004
	,6.198785858e-004
	,-2.971645173e-006
	,-2.428116606e-006
	,-1.973424483e-006
	,-1.595746099e-006
	,-1.285560973e-006
	,-1.032385919e-006
	,-8.244120454e-007
	,-6.536346783e-007
	,-5.161215932e-007
	,-4.071713729e-007
	,-3.210599934e-007
	,-2.527767611e-007
	,-1.985520323e-007
	,-1.553832372e-007
	,-1.210230372e-007
	,-9.379891942e-008
	,-7.243843368e-008
	,-5.585815929e-008
	,-4.308865497e-008
	,-3.328031594e-008
	,-2.573355265e-008
	,-1.990259936e-008
	,-1.537821428e-008
	,-1.185663333e-008
	,-9.118678947e-009
	,-6.994318211e-009
	,-5.347370670e-009
	,-4.072774861e-009
	,-3.087075553e-009
	,-2.327106866e-009
	,-1.745644117e-009
	,-1.303936913e-009
	,-9.694312425e-010
	,-7.158651302e-010
	,-5.228923509e-010
	,-3.751346988e-010
	,-2.610759857e-010
	,-1.721051980e-010
	,-1.018890758e-010
	,-4.573870813e-011
	,-1.321091121e-017
	,3.819896519e-011
	,7.109554839e-011
	,1.004502314e-010
	,1.276262309e-010
	,1.536190174e-010
	,1.790797533e-010
	,2.044376312e-010
	,2.301046610e-010
	,2.564706604e-010
	,2.837956784e-010
	,3.122431542e-010
	,3.420826085e-010
	,3.738248950e-010
	,4.080816616e-010
	,4.454149956e-010
	,4.863054361e-010
	,5.311451685e-010
	,5.802229725e-010
	,6.338137118e-010
	,6.923878840e-010
	,7.566041970e-010
	,8.271807010e-010
	,9.049372058e-010
	,9.908581418e-010
	,1.086072320e-009
	,1.191858558e-009
	,1.309683366e-009
	,1.441237714e-009
	,1.588454523e-009
	,1.753472534e-009
	,1.938482293e-009
	,2.145451999e-009
	,2.376171188e-009
	,2.633569288e-009
	,2.923615771e-009
	,3.254161912e-009
	,3.634181583e-009
	,4.073284080e-009
	,4.580753179e-009
	,5.162825342e-009
	,5.821539440e-009
	,6.560105744e-009
	,7.403067177e-009
	,8.387849509e-009
	,9.551879066e-009
	,1.093041136e-008
	,1.258225755e-008
	,1.457498112e-008
	,1.699129898e-008
	,1.993277214e-008
	,2.349605737e-008
	,2.783923068e-008
	,3.316585456e-008
	,3.972258281e-008
	,4.781951654e-008
	,5.783966066e-008
	,7.023194865e-008
	,8.551377442e-008
	,1.042855113e-007
	,1.275780382e-007
	,1.565799335e-007
	,1.927080157e-007
	,2.365476140e-007
	,2.903605197e-007
	,3.545473853e-007
	,4.306806684e-007
	,5.182928469e-007
	,6.249695899e-007
	,7.557424610e-007
	,9.163790616e-007
	,1.113858414e-006
	,1.356775530e-006
	,1.655756478e-006
	,2.023908000e-006
	,2.475783774e-006
	,3.025374515e-006
	,3.698568912e-006
	,4.507682563e-006
	,5.491277200e-006
	,6.690246861e-006
	,8.148388752e-006
	,9.913467172e-006
	,1.195603742e-005
	,1.420450168e-005
	,1.670537883e-005
	,1.939616845e-005
	,2.252897063e-005
	,2.618508309e-005
	,3.044035212e-005
	,3.537684053e-005
	,4.108513343e-005
	,4.766372138e-005
	,5.521435499e-005
	,6.378837289e-005
	,7.338455612e-005
	,8.418037868e-005
	,9.619903741e-005
	,1.094031174e-004
	,1.239427020e-004
	,1.398086087e-004
	,1.568380147e-004
	,1.744906889e-004
	,1.931309927e-004
	,2.122549426e-004
	,2.305619741e-004
	,2.498226988e-004
	,2.704230549e-004
	,2.924632494e-004
	,3.158809850e-004
	,3.406003899e-004
	,3.665474040e-004
	,3.936521327e-004
	,4.218488545e-004
	,4.510757490e-004
	,4.812751996e-004
	,5.123940230e-004
	,5.443825541e-004
	,5.771961936e-004
	,6.107929241e-004
	,6.450871519e-004
	,6.800785889e-004
	,7.157430948e-004
	,7.520468092e-004
	,7.889598356e-004
	,8.264410041e-004
	,8.644586873e-004
	,9.029914105e-004
	,9.420068518e-004
	,9.814713994e-004
	,1.021341692e-003
	,1.061416127e-003
	,1.101789439e-003
	,1.142415725e-003
	,1.183245799e-003
	,1.223759263e-003
	,1.264233163e-003
	,1.304711238e-003
	,1.345124076e-003
	,1.385396231e-003
	,1.425446934e-003
	,1.465191149e-003
	,1.504540980e-003
	,1.543407455e-003
	,1.581702657e-003
	,1.619342141e-003
	,1.656220187e-003
	,1.691614073e-003
	,1.726075113e-003
	,1.759570782e-003
	,1.792085278e-003
	,1.823616249e-003
	,1.853863172e-003
	,1.883035385e-003
	,1.911196603e-003
	,1.938394434e-003
	,1.964687404e-003
	,1.990146027e-003
	,2.014848486e-003
	,2.038880356e-003
	,2.062317949e-003
	,-7.777981358e-006
	,-6.439851528e-006
	,-5.306352261e-006
	,-4.353477000e-006
	,-3.545411382e-006
	,-2.861712068e-006
	,-2.293056133e-006
	,-1.828862339e-006
	,-1.456785047e-006
	,-1.160188840e-006
	,-9.220742368e-007
	,-7.288322776e-007
	,-5.723086624e-007
	,-4.468643618e-007
	,-3.473825633e-007
	,-2.696152730e-007
	,-2.093809572e-007
	,-1.628054824e-007
	,-1.266955571e-007
	,-9.853688846e-008
	,-7.642890752e-008
	,-5.906181770e-008
	,-4.549126382e-008
	,-3.489908047e-008
	,-2.663016178e-008
	,-2.023620151e-008
	,-1.535221082e-008
	,-1.164500063e-008
	,-8.834954159e-009
	,-6.702605533e-009
	,-5.080567296e-009
	,-3.842376478e-009
	,-2.892520238e-009
	,-2.159123323e-009
	,-1.589932797e-009
	,-1.147592235e-009
	,-8.028526435e-010
	,-5.319054738e-010
	,-3.162578451e-010
	,-1.422625331e-010
	,2.609121118e-019
	,1.178320684e-010
	,2.171304100e-010
	,3.030140173e-010
	,3.798482551e-010
	,4.512964809e-010
	,5.203457958e-010
	,5.893799573e-010
	,6.603239189e-010
	,7.347740011e-010
	,8.140622931e-010
	,8.992573299e-010
	,9.911259167e-010
	,1.090281063e-009
	,1.197683400e-009
	,1.314702946e-009
	,1.442722955e-009
	,1.582965640e-009
	,1.736657807e-009
	,1.905265209e-009
	,2.090411712e-009
	,2.293750335e-009
	,2.516791553e-009
	,2.760494839e-009
	,3.024909487e-009
	,3.309917726e-009
	,3.616992976e-009
	,3.949090699e-009
	,4.308872261e-009
	,4.697364591e-009
	,5.113093808e-009
	,5.552275474e-009
	,6.012061699e-009
	,6.495507578e-009
	,7.011391417e-009
	,7.570090058e-009
	,8.181414379e-009
	,8.854648860e-009
	,9.599029443e-009
	,1.042401416e-008
	,1.133998772e-008
	,1.236071777e-008
	,1.350515729e-008
	,1.479689415e-008
	,1.626504012e-008
	,1.794657642e-008
	,1.988767582e-008
	,2.214445631e-008
	,2.478489425e-008
	,2.789146068e-008
	,3.156516801e-008
	,3.592072107e-008
	,4.111393289e-008
	,4.733149394e-008
	,5.478902767e-008
	,6.371396359e-008
	,7.436555958e-008
	,8.716218950e-008
	,1.026822258e-007
	,1.214209588e-007
	,1.440597274e-007
	,1.715063257e-007
	,2.042933312e-007
	,2.425166864e-007
	,2.866983347e-007
	,3.392725705e-007
	,4.031108961e-007
	,4.812474443e-007
	,5.771733514e-007
	,6.951495331e-007
	,8.403457685e-007
	,1.019271988e-006
	,1.240118939e-006
	,1.511922376e-006
	,1.845282452e-006
	,2.256347484e-006
	,2.762737046e-006
	,3.374695694e-006
	,4.125244745e-006
	,5.046467828e-006
	,6.174477232e-006
	,7.540100592e-006
	,9.120908265e-006
	,1.088888381e-005
	,1.284738678e-005
	,1.503228295e-005
	,1.759952536e-005
	,2.061995145e-005
	,2.416277808e-005
	,2.830339551e-005
	,3.312502399e-005
	,3.871829871e-005
	,4.517755309e-005
	,5.256471130e-005
	,6.089119218e-005
	,7.030461413e-005
	,8.077263169e-005
	,9.238848201e-005
	,1.052492609e-004
	,1.193589425e-004
	,1.346207929e-004
	,1.504921853e-004
	,1.671919700e-004
	,1.839673378e-004
	,2.004327495e-004
	,2.179401748e-004
	,2.368228536e-004
	,2.571020234e-004
	,2.787302323e-004
	,3.014815855e-004
	,3.254190480e-004
	,3.504920299e-004
	,3.766437341e-004
	,4.037781876e-004
	,4.318461042e-004
	,4.608307243e-004
	,4.906907158e-004
	,5.213834995e-004
	,5.528687745e-004
	,5.851096882e-004
	,6.180733945e-004
	,6.517276560e-004
	,6.860418956e-004
	,7.209867862e-004
	,7.565338315e-004
	,7.926549700e-004
	,8.293222353e-004
	,8.665075010e-004
	,9.041822994e-004
	,9.423175835e-004
	,9.807746861e-004
	,1.019582716e-003
	,1.058721612e-003
	,1.098153850e-003
	,1.137834516e-003
	,1.177718037e-003
	,1.217184758e-003
	,1.256610329e-003
	,1.296045385e-003
	,1.335424497e-003
	,1.374677268e-003
	,1.413729010e-003
	,1.452501678e-003
	,1.490915042e-003
	,1.528888107e-003
	,1.565952052e-003
	,1.602195017e-003
	,1.637698319e-003
	,1.672407858e-003
	,1.706279016e-003
	,1.739274781e-003
	,1.771366480e-003
	,1.802316546e-003
	,1.832203071e-003
	,1.861098045e-003
	,1.889024336e-003
	,1.916020569e-003
	,1.942138079e-003
	,1.967438231e-003
	,1.991990359e-003
	,2.015868988e-003
	,-1.878642972e-005
	,-1.582896228e-005
	,-1.323139931e-005
	,-1.101567887e-005
	,-9.143497331e-006
	,-7.540274947e-006
	,-6.151270890e-006
	,-4.972486838e-006
	,-3.999879918e-006
	,-3.207677168e-006
	,-2.567518589e-006
	,-2.051520902e-006
	,-1.631486746e-006
	,-1.288526618e-006
	,-1.013327973e-006
	,-7.956252988e-007
	,-6.236450695e-007
	,-4.872031461e-007
	,-3.788471043e-007
	,-2.935309141e-007
	,-2.269112202e-007
	,-1.749763711e-007
	,-1.344535264e-007
	,-1.030174034e-007
	,-7.886502764e-008
	,-6.040568099e-008
	,-4.630550402e-008
	,-3.551132748e-008
	,-2.721348526e-008
	,-2.079964738e-008
	,-1.582391548e-008
	,-1.197281071e-008
	,-8.999746158e-009
	,-6.697898768e-009
	,-4.905160061e-009
	,-3.506011572e-009
	,-2.419641563e-009
	,-1.579915882e-009
	,-9.277727284e-010
	,-4.139684652e-010
	,1.869329054e-017
	,3.434275763e-010
	,6.384379009e-010
	,9.017633994e-010
	,1.146139124e-009
	,1.381209621e-009
	,1.613914588e-009
	,1.848966052e-009
	,2.090551746e-009
	,2.343579252e-009
	,2.612916958e-009
	,2.902553131e-009
	,3.215275550e-009
	,3.552855782e-009
	,3.916584939e-009
	,4.306536092e-009
	,4.720935021e-009
	,5.158970187e-009
	,5.622566554e-009
	,6.113290743e-009
	,6.630337010e-009
	,7.172358761e-009
	,7.741975868e-009
	,8.346961292e-009
	,8.996612841e-009
	,9.699315204e-009
	,1.046248649e-008
	,1.129311412e-008
	,1.219810622e-008
	,1.318427214e-008
	,1.425772785e-008
	,1.542323432e-008
	,1.668550159e-008
	,1.805282702e-008
	,1.953758115e-008
	,2.115349952e-008
	,2.291434803e-008
	,2.483457113e-008
	,2.693114298e-008
	,2.922428013e-008
	,3.173689874e-008
	,3.449455274e-008
	,3.752580052e-008
	,4.086246905e-008
	,4.453942461e-008
	,4.859321022e-008
	,5.305859858e-008
	,5.796472412e-008
	,6.334019026e-008
	,6.924025961e-008
	,7.576324284e-008
	,8.304729113e-008
	,9.125900654e-008
	,1.005886984e-007
	,1.112431246e-007
	,1.234164198e-007
	,1.372428496e-007
	,1.527477718e-007
	,1.699887070e-007
	,1.893890657e-007
	,2.118252711e-007
	,2.381843502e-007
	,2.693276567e-007
	,3.063737578e-007
	,3.507619870e-007
	,4.042542521e-007
	,4.690037982e-007
	,5.473270066e-007
	,6.422771717e-007
	,7.580732916e-007
	,8.991076213e-007
	,1.071629337e-006
	,1.283509026e-006
	,1.544332726e-006
	,1.864971411e-006
	,2.254246946e-006
	,2.729850514e-006
	,3.314189008e-006
	,4.032461100e-006
	,4.906204387e-006
	,5.936816053e-006
	,7.125213869e-006
	,8.472741640e-006
	,9.957129285e-006
	,1.170732436e-005
	,1.378766355e-005
	,1.625662993e-005
	,1.917669620e-005
	,2.261708417e-005
	,2.665300357e-005
	,3.136816765e-005
	,3.684832813e-005
	,4.313992682e-005
	,5.030155705e-005
	,5.841360820e-005
	,6.745690502e-005
	,7.758884464e-005
	,8.886344306e-005
	,1.012828143e-004
	,1.147246019e-004
	,1.287804379e-004
	,1.432767181e-004
	,1.578065282e-004
	,1.724912929e-004
	,1.882789138e-004
	,2.053627129e-004
	,2.237397834e-004
	,2.433745198e-004
	,2.641928586e-004
	,2.861631225e-004
	,3.092667710e-004
	,3.332571798e-004
	,3.581994013e-004
	,3.841020845e-004
	,4.109234375e-004
	,4.386233141e-004
	,4.671633287e-004
	,4.965069620e-004
	,5.266202263e-004
	,5.574708796e-004
	,5.890266058e-004
	,6.212584990e-004
	,6.541400420e-004
	,6.876444367e-004
	,7.217455309e-004
	,7.564175705e-004
	,7.916350527e-004
	,8.273727014e-004
	,8.636055011e-004
	,9.002579798e-004
	,9.373094561e-004
	,9.747502166e-004
	,1.012548220e-003
	,1.050676202e-003
	,1.089099666e-003
	,1.127779158e-003
	,1.166669763e-003
	,1.204922218e-003
	,1.243211418e-003
	,1.281521000e-003
	,1.319791517e-003
	,1.357959689e-003
	,1.395958910e-003
	,1.433539866e-003
	,1.470546670e-003
	,1.507098178e-003
	,1.543130693e-003
	,1.578585404e-003
	,1.613405266e-003
	,1.647533536e-003
	,1.680908348e-003
	,1.713491096e-003
	,1.745113275e-003
	,1.775739999e-003
	,1.805438184e-003
	,1.834210112e-003
	,1.862074158e-003
	,1.889062289e-003
	,1.914663438e-003
	,1.939367894e-003
	,1.963373657e-003
	,-4.006375805e-005
	,-3.481675071e-005
	,-2.995473908e-005
	,-2.558831726e-005
	,-2.175284012e-005
	,-1.837398174e-005
	,-1.535525261e-005
	,-1.269414878e-005
	,-1.043072165e-005
	,-8.542897633e-006
	,-6.977213332e-006
	,-5.679590043e-006
	,-4.590205478e-006
	,-3.671682020e-006
	,-2.912950609e-006
	,-2.298955289e-006
	,-1.808632649e-006
	,-1.421450392e-006
	,-1.117066112e-006
	,-8.774909621e-007
	,-6.879336310e-007
	,-5.366971147e-007
	,-4.166125147e-007
	,-3.226448789e-007
	,-2.496125868e-007
	,-1.926807273e-007
	,-1.480212794e-007
	,-1.130542517e-007
	,-8.593012516e-008
	,-6.505077475e-008
	,-4.907033710e-008
	,-3.687174497e-008
	,-2.753567380e-008
	,-2.036631990e-008
	,-1.487078542e-008
	,-1.066162195e-008
	,-7.421937948e-009
	,-4.903297678e-009
	,-2.916490753e-009
	,-1.318159524e-009
	,8.197800269e-018
	,1.118038275e-009
	,2.094227723e-009
	,2.974204691e-009
	,3.795962125e-009
	,4.588623119e-009
	,5.370701560e-009
	,6.148493025e-009
	,6.918668398e-009
	,7.681072214e-009
	,8.448308817e-009
	,9.239311928e-009
	,1.007359814e-008
	,1.096891207e-008
	,1.193965206e-008
	,1.299717226e-008
	,1.415106696e-008
	,1.541093171e-008
	,1.678784819e-008
	,1.829438725e-008
	,1.994334450e-008
	,2.174598894e-008
	,2.370976394e-008
	,2.583720566e-008
	,2.813242524e-008
	,3.061084042e-008
	,3.329734198e-008
	,3.621901740e-008
	,3.940134662e-008
	,4.286647015e-008
	,4.663371067e-008
	,5.072356531e-008
	,5.515902801e-008
	,5.996234234e-008
	,6.514992835e-008
	,7.072457929e-008
	,7.667672445e-008
	,8.301090061e-008
	,8.976608641e-008
	,9.699502585e-008
	,1.047352464e-007
	,1.129905271e-007
	,1.217138758e-007
	,1.308006926e-007
	,1.401345017e-007
	,1.496954886e-007
	,1.596082517e-007
	,1.700640171e-007
	,1.812434571e-007
	,1.932992879e-007
	,2.063664034e-007
	,2.205738860e-007
	,2.360524149e-007
	,2.529371430e-007
	,2.713707523e-007
	,2.915213280e-007
	,3.136233712e-007
	,3.379966245e-007
	,3.650402467e-007
	,3.952554184e-007
	,4.292727402e-007
	,4.678729780e-007
	,5.120300620e-007
	,5.629481338e-007
	,6.220958324e-007
	,6.912694955e-007
	,7.725403375e-007
	,8.686997544e-007
	,9.830998856e-007
	,1.119804263e-006
	,1.283552028e-006
	,1.479417511e-006
	,1.710986958e-006
	,1.988463465e-006
	,2.323458653e-006
	,2.728424966e-006
	,3.212148920e-006
	,3.787222552e-006
	,4.459008797e-006
	,5.218896184e-006
	,6.069361787e-006
	,7.056612455e-006
	,8.233532146e-006
	,9.644150181e-006
	,1.133328737e-005
	,1.335077110e-005
	,1.575283774e-005
	,1.860262794e-005
	,2.196825405e-005
	,2.592234855e-005
	,3.053300987e-005
	,3.584393783e-005
	,4.194445209e-005
	,4.880805088e-005
	,5.657693536e-005
	,6.532481066e-005
	,7.509127456e-005
	,8.585342272e-005
	,9.738974703e-005
	,1.093543183e-004
	,1.216594838e-004
	,1.338602524e-004
	,1.468265518e-004
	,1.609032972e-004
	,1.761199110e-004
	,1.924948309e-004
	,2.100273504e-004
	,2.286951416e-004
	,2.484730047e-004
	,2.693334516e-004
	,2.912470073e-004
	,3.141827706e-004
	,3.381089269e-004
	,3.627545142e-004
	,3.881525366e-004
	,4.143912510e-004
	,4.414389757e-004
	,4.692651847e-004
	,4.978403399e-004
	,5.271362385e-004
	,5.571261445e-004
	,5.877840341e-004
	,6.190843097e-004
	,6.510004957e-004
	,6.835090013e-004
	,7.165867238e-004
	,7.502092411e-004
	,7.843543386e-004
	,8.189896756e-004
	,8.540786970e-004
	,8.896026285e-004
	,9.255393328e-004
	,9.618659322e-004
	,9.985569266e-004
	,1.035583029e-003
	,1.072910636e-003
	,1.110501664e-003
	,1.148167936e-003
	,1.185100086e-003
	,1.222120123e-003
	,1.259180082e-003
	,1.296166832e-003
	,1.332871264e-003
	,1.369380532e-003
	,1.405641345e-003
	,1.441604355e-003
	,1.477217701e-003
	,1.512423901e-003
	,1.547167698e-003
	,1.581385979e-003
	,1.615016327e-003
	,1.648000962e-003
	,1.679836914e-003
	,1.710634385e-003
	,1.740610616e-003
	,1.769762117e-003
	,1.798097485e-003
	,1.825633152e-003
	,1.852390850e-003
	,1.878397328e-003
	,1.903685103e-003
	,-7.594973768e-005
	,-6.760412884e-005
	,-5.984242234e-005
	,-5.271131976e-005
	,-4.616171661e-005
	,-4.010732843e-005
	,-3.454875609e-005
	,-2.948676339e-005
	,-2.496817440e-005
	,-2.104973692e-005
	,-1.769177621e-005
	,-1.477996486e-005
	,-1.221434152e-005
	,-9.978842620e-006
	,-8.075034378e-006
	,-6.498828974e-006
	,-5.223565877e-006
	,-4.199570769e-006
	,-3.374278969e-006
	,-2.700017503e-006
	,-2.143647676e-006
	,-1.686397312e-006
	,-1.312984867e-006
	,-1.013322788e-006
	,-7.785215170e-007
	,-5.976417038e-007
	,-4.592520899e-007
	,-3.533925441e-007
	,-2.721268644e-007
	,-2.093081992e-007
	,-1.603497308e-007
	,-1.221147518e-007
	,-9.229651285e-008
	,-6.906810509e-008
	,-5.100358083e-008
	,-3.689984094e-008
	,-2.579890135e-008
	,-1.702054352e-008
	,-1.006709956e-008
	,-4.510919886e-009
	,6.631309183e-018
	,3.733450145e-009
	,6.899829829e-009
	,9.669971849e-009
	,1.217637167e-008
	,1.451967882e-008
	,1.678530312e-008
	,1.904995332e-008
	,2.138139437e-008
	,2.383794026e-008
	,2.647051187e-008
	,2.932537654e-008
	,3.244469733e-008
	,3.586401371e-008
	,3.960578778e-008
	,4.367472399e-008
	,4.807622361e-008
	,5.284665238e-008
	,5.804289273e-008
	,6.371799563e-008
	,6.991470239e-008
	,7.666138092e-008
	,8.395764374e-008
	,9.175470629e-008
	,9.995630637e-008
	,1.084772231e-007
	,1.173227105e-007
	,1.265590522e-007
	,1.362265524e-007
	,1.463268831e-007
	,1.568729438e-007
	,1.679457694e-007
	,1.796863121e-007
	,1.922364438e-007
	,2.057066881e-007
	,2.201761445e-007
	,2.357057535e-007
	,2.523578052e-007
	,2.702108808e-007
	,2.893578711e-007
	,3.098912363e-007
	,3.318863138e-007
	,3.553953229e-007
	,3.804792780e-007
	,4.072627086e-007
	,4.359317993e-007
	,4.666908172e-007
	,4.997386192e-007
	,5.352712524e-007
	,5.735029005e-007
	,6.146833076e-007
	,6.590933264e-007
	,7.070370882e-007
	,7.588412877e-007
	,8.148566835e-007
	,8.754578431e-007
	,9.410376011e-007
	,1.011989795e-006
	,1.088670498e-006
	,1.171339585e-006
	,1.260141483e-006
	,1.355270931e-006
	,1.457312608e-006
	,1.567304238e-006
	,1.686536281e-006
	,1.816465021e-006
	,1.958817189e-006
	,2.115800746e-006
	,2.290015081e-006
	,2.484201556e-006
	,2.700655017e-006
	,2.940456303e-006
	,3.203381247e-006
	,3.492473006e-006
	,3.814359089e-006
	,4.182617842e-006
	,4.610956011e-006
	,5.114159661e-006
	,5.708638348e-006
	,6.414985196e-006
	,7.256934144e-006
	,8.262088137e-006
	,9.458651376e-006
	,1.088147210e-005
	,1.257750017e-005
	,1.459616946e-005
	,1.699233952e-005
	,1.982366840e-005
	,2.313788077e-005
	,2.700474000e-005
	,3.145903305e-005
	,3.653253222e-005
	,4.233102837e-005
	,4.892498774e-005
	,5.635653733e-005
	,6.461115852e-005
	,7.353165512e-005
	,8.278891282e-005
	,9.241806772e-005
	,1.021362741e-004
	,1.124957338e-004
	,1.237693612e-004
	,1.360602917e-004
	,1.493857246e-004
	,1.637498954e-004
	,1.791530789e-004
	,1.955884656e-004
	,2.130461641e-004
	,2.315133019e-004
	,2.509741844e-004
	,2.714109820e-004
	,2.928039309e-004
	,3.151316948e-004
	,3.383718181e-004
	,3.625010966e-004
	,3.872705937e-004
	,4.125651983e-004
	,4.386182317e-004
	,4.654052878e-004
	,4.929023310e-004
	,5.210854986e-004
	,5.499312074e-004
	,5.794165095e-004
	,6.095182566e-004
	,6.402133900e-004
	,6.714784458e-004
	,7.032907822e-004
	,7.356436050e-004
	,7.685155994e-004
	,8.018616891e-004
	,8.356637685e-004
	,8.699041796e-004
	,9.045636994e-004
	,9.396202988e-004
	,9.750486289e-004
	,1.010819936e-003
	,1.046902193e-003
	,1.083260347e-003
	,1.119420934e-003
	,1.154849225e-003
	,1.190277069e-003
	,1.225703372e-003
	,1.261090939e-003
	,1.296410002e-003
	,1.331632820e-003
	,1.366726892e-003
	,1.401613631e-003
	,1.435925057e-003
	,1.469898218e-003
	,1.503497074e-003
	,1.536689536e-003
	,1.569440463e-003
	,1.601678172e-003
	,1.633289360e-003
	,1.664270850e-003
	,1.694572045e-003
	,1.724153678e-003
	,1.752989566e-003
	,1.781066887e-003
	,1.808385753e-003
	,1.834958355e-003
	,-1.318633879e-004
	,-1.195314567e-004
	,-1.078435874e-004
	,-9.697266986e-005
	,-8.699905686e-005
	,-7.790270547e-005
	,-6.950447203e-005
	,-6.153136627e-005
	,-5.394418998e-005
	,-4.690812277e-005
	,-4.052412647e-005
	,-3.480718848e-005
	,-2.973765869e-005
	,-2.527571503e-005
	,-2.129049924e-005
	,-1.769944051e-005
	,-1.457784159e-005
	,-1.194184818e-005
	,-9.719068875e-006
	,-7.850524110e-006
	,-6.310500094e-006
	,-5.059293012e-006
	,-4.038967273e-006
	,-3.204004168e-006
	,-2.528569335e-006
	,-1.990805217e-006
	,-1.564177830e-006
	,-1.222161367e-006
	,-9.472674394e-007
	,-7.297214365e-007
	,-5.594224300e-007
	,-4.255252385e-007
	,-3.197791670e-007
	,-2.371584947e-007
	,-1.733904977e-007
	,-1.243276248e-007
	,-8.651016255e-008
	,-5.712949187e-008
	,-3.396481506e-008
	,-1.533271986e-008
	,6.892391029e-018
	,1.293047223e-008
	,2.417444629e-008
	,3.431485529e-008
	,4.377854651e-008
	,5.290446002e-008
	,6.195702040e-008
	,7.105770672e-008
	,8.022854267e-008
	,8.963311214e-008
	,9.956958111e-008
	,1.102590513e-007
	,1.217522831e-007
	,1.339153138e-007
	,1.465229905e-007
	,1.594556500e-007
	,1.727472835e-007
	,1.865391694e-007
	,2.010683445e-007
	,2.165920199e-007
	,2.333366082e-007
	,2.514968331e-007
	,2.712544934e-007
	,2.927901943e-007
	,3.162869857e-007
	,3.419394388e-007
	,3.699509040e-007
	,4.005160465e-007
	,4.337965927e-007
	,4.698809572e-007
	,5.087506227e-007
	,5.503527812e-007
	,5.947728355e-007
	,6.422616182e-007
	,6.931717009e-007
	,7.479581047e-007
	,8.070996338e-007
	,8.710148686e-007
	,9.400587791e-007
	,1.014554127e-006
	,1.094745648e-006
	,1.180678969e-006
	,1.272134123e-006
	,1.368687260e-006
	,1.469988709e-006
	,1.576178236e-006
	,1.687868689e-006
	,1.805662298e-006
	,1.929804043e-006
	,2.060072154e-006
	,2.195650439e-006
	,2.334890515e-006
	,2.475353022e-006
	,2.614853406e-006
	,2.753143053e-006
	,2.892222969e-006
	,3.034988539e-006
	,3.184020951e-006
	,3.341261772e-006
	,3.508133815e-006
	,3.685721378e-006
	,3.874888767e-006
	,4.076330343e-006
	,4.290600781e-006
	,4.518239164e-006
	,4.760051081e-006
	,5.017275684e-006
	,5.291515301e-006
	,5.584628432e-006
	,5.898737702e-006
	,6.236330205e-006
	,6.600409399e-006
	,6.994700339e-006
	,7.423919544e-006
	,7.894071483e-006
	,8.412822855e-006
	,8.989925000e-006
	,9.637650828e-006
	,1.037120039e-005
	,1.120905444e-005
	,1.217322016e-005
	,1.328920675e-005
	,1.458776225e-005
	,1.610357667e-005
	,1.787232040e-005
	,1.992567509e-005
	,2.229279453e-005
	,2.502956241e-005
	,2.819375693e-005
	,3.184845650e-005
	,3.604240703e-005
	,4.080282427e-005
	,4.610582821e-005
	,5.180840821e-005
	,5.783943206e-005
	,6.420535086e-005
	,7.084831253e-005
	,7.804720096e-005
	,8.598219367e-005
	,9.472436881e-005
	,1.043082824e-004
	,1.147557325e-004
	,1.260827279e-004
	,1.383015090e-004
	,1.514211504e-004
	,1.654477472e-004
	,1.803834104e-004
	,1.962273959e-004
	,2.129816172e-004
	,2.306411890e-004
	,2.491988856e-004
	,2.686452645e-004
	,2.889688854e-004
	,3.101569398e-004
	,3.321951027e-004
	,3.550679016e-004
	,3.787589398e-004
	,4.032048943e-004
	,4.277903792e-004
	,4.530765834e-004
	,4.790427763e-004
	,5.056678886e-004
	,5.329305373e-004
	,5.608087502e-004
	,5.892809210e-004
	,6.183260005e-004
	,6.479464538e-004
	,6.781673014e-004
	,7.089015968e-004
	,7.401320764e-004
	,7.718458562e-004
	,8.040222178e-004
	,8.366429802e-004
	,8.696923542e-004
	,9.031473872e-004
	,9.369827198e-004
	,9.711712723e-004
	,1.005685207e-003
	,1.040505918e-003
	,1.074956923e-003
	,1.108376869e-003
	,1.141858816e-003
	,1.175224527e-003
	,1.208465327e-003
	,1.241615267e-003
	,1.274764403e-003
	,1.307992942e-003
	,1.341315427e-003
	,1.374557736e-003
	,1.407579686e-003
	,1.440548905e-003
	,1.473381424e-003
	,1.505992236e-003
	,1.538287583e-003
	,1.570171659e-003
	,1.601568177e-003
	,1.632410150e-003
	,1.662642406e-003
	,1.692222564e-003
	,1.721121510e-003
	,1.749323503e-003
	,-2.034419678e-004
	,-1.892497961e-004
	,-1.753820634e-004
	,-1.619515026e-004
	,-1.491102766e-004
	,-1.369227143e-004
	,-1.252983521e-004
	,-1.140864679e-004
	,-1.032075930e-004
	,-9.266001959e-005
	,-8.254107941e-005
	,-7.304082173e-005
	,-6.435213597e-005
	,-5.654579303e-005
	,-4.949167301e-005
	,-4.300470964e-005
	,-3.695950113e-005
	,-3.132164668e-005
	,-2.626036728e-005
	,-2.190457096e-005
	,-1.822870579e-005
	,-1.512547550e-005
	,-1.246006338e-005
	,-1.015400421e-005
	,-8.208156055e-006
	,-6.583610625e-006
	,-5.216119565e-006
	,-4.086976684e-006
	,-3.187447835e-006
	,-2.483243643e-006
	,-1.931985443e-006
	,-1.495014469e-006
	,-1.144810765e-006
	,-8.671878054e-007
	,-6.490246955e-007
	,-4.762668571e-007
	,-3.373516076e-007
	,-2.248307460e-007
	,-1.340894132e-007
	,-6.059496913e-008
	,2.683904417e-017
	,5.094211168e-008
	,9.445569864e-008
	,1.322455732e-007
	,1.659898465e-007
	,1.973810899e-007
	,2.279282401e-007
	,2.588773518e-007
	,2.912076269e-007
	,3.255784544e-007
	,3.621809925e-007
	,4.005596387e-007
	,4.404370265e-007
	,4.822778690e-007
	,5.269119960e-007
	,5.752935738e-007
	,6.279786544e-007
	,6.854384278e-007
	,7.479033893e-007
	,8.153931230e-007
	,8.882527298e-007
	,9.673809673e-007
	,1.053733395e-006
	,1.148031729e-006
	,1.250694209e-006
	,1.361553756e-006
	,1.479454649e-006
	,1.602058665e-006
	,1.726657286e-006
	,1.852171645e-006
	,1.979487012e-006
	,2.109731197e-006
	,2.243197482e-006
	,2.379775953e-006
	,2.520084329e-006
	,2.665800068e-006
	,2.818967761e-006
	,2.981434111e-006
	,3.154671476e-006
	,3.339781582e-006
	,3.537812556e-006
	,3.749802207e-006
	,3.976517069e-006
	,4.218410602e-006
	,4.475529211e-006
	,4.747448469e-006
	,5.033630962e-006
	,5.334230131e-006
	,5.650384097e-006
	,5.983624718e-006
	,6.335283404e-006
	,6.706325950e-006
	,7.097336052e-006
	,7.508518067e-006
	,7.939966808e-006
	,8.392175236e-006
	,8.866231389e-006
	,9.363511039e-006
	,9.885291469e-006
	,1.043258142e-005
	,1.100619821e-005
	,1.160694945e-005
	,1.223546908e-005
	,1.289175848e-005
	,1.357484287e-005
	,1.428303437e-005
	,1.501516372e-005
	,1.577195012e-005
	,1.655595133e-005
	,1.737038743e-005
	,1.821825511e-005
	,1.910207717e-005
	,2.002387716e-005
	,2.098524227e-005
	,2.198729720e-005
	,2.303056343e-005
	,2.411468613e-005
	,2.523803435e-005
	,2.639725939e-005
	,2.758740860e-005
	,2.880408982e-005
	,3.004688187e-005
	,3.132414015e-005
	,3.265239660e-005
	,3.405230903e-005
	,3.554579408e-005
	,3.715664766e-005
	,3.892076787e-005
	,4.088639919e-005
	,4.310953537e-005
	,4.564735799e-005
	,4.855538256e-005
	,5.188649650e-005
	,5.569095735e-005
	,6.001569711e-005
	,6.490408227e-005
	,7.039440569e-005
	,7.651889642e-005
	,8.331105199e-005
	,9.079993908e-005
	,9.900959069e-005
	,1.079604483e-004
	,1.176695829e-004
	,1.281501561e-004
	,1.394153038e-004
	,1.514770186e-004
	,1.643414350e-004
	,1.780114013e-004
	,1.924861708e-004
	,2.077611875e-004
	,2.238285065e-004
	,2.406786019e-004
	,2.583074663e-004
	,2.767103657e-004
	,2.958820217e-004
	,3.158279510e-004
	,3.365440802e-004
	,3.580233379e-004
	,3.802588213e-004
	,4.032414087e-004
	,4.267960299e-004
	,4.503938220e-004
	,4.746320902e-004
	,4.994884755e-004
	,5.249398744e-004
	,5.509970631e-004
	,5.777055278e-004
	,6.049526742e-004
	,6.327205479e-004
	,6.609923451e-004
	,6.898049607e-004
	,7.190543533e-004
	,7.486929972e-004
	,7.786773370e-004
	,8.089851491e-004
	,8.394949892e-004
	,8.693348965e-004
	,8.983466021e-004
	,9.279471079e-004
	,9.587292762e-004
	,9.905456791e-004
	,1.021933742e-003
	,1.052952451e-003
	,1.084456078e-003
	,1.116368736e-003
	,1.148625190e-003
	,1.181165995e-003
	,1.213934495e-003
	,1.246874921e-003
	,1.279931167e-003
	,1.313046025e-003
	,1.346160794e-003
	,1.379215219e-003
	,1.412147775e-003
	,1.444907139e-003
	,1.477435189e-003
	,1.509639663e-003
	,1.541457639e-003
	,1.572830171e-003
	,1.603703690e-003
	,1.634031265e-003
	,-2.884098468e-004
	,-2.732454607e-004
	,-2.584721559e-004
	,-2.440000481e-004
	,-2.296487094e-004
	,-2.151954316e-004
	,-2.005717552e-004
	,-1.860337152e-004
	,-1.718399731e-004
	,-1.580594105e-004
	,-1.446570897e-004
	,-1.317292667e-004
	,-1.194359133e-004
	,-1.078286881e-004
	,-9.689555663e-005
	,-8.669943758e-005
	,-7.739490310e-005
	,-6.900111926e-005
	,-6.133664424e-005
	,-5.413215657e-005
	,-4.729494174e-005
	,-4.081529219e-005
	,-3.470111718e-005
	,-2.910686963e-005
	,-2.417585209e-005
	,-1.995623732e-005
	,-1.642216972e-005
	,-1.348313814e-005
	,-1.100865818e-005
	,-8.900534846e-006
	,-7.119109544e-006
	,-5.609431373e-006
	,-4.344575586e-006
	,-3.311435189e-006
	,-2.485080881e-006
	,-1.830564419e-006
	,-1.309001658e-006
	,-8.852083983e-007
	,-5.362691711e-007
	,-2.453814125e-007
	,3.049419003e-017
	,2.088904756e-007
	,3.903252928e-007
	,5.522810260e-007
	,7.000093890e-007
	,8.384792432e-007
	,9.737155501e-007
	,1.110705906e-006
	,1.252436739e-006
	,1.400986278e-006
	,1.558519861e-006
	,1.725378867e-006
	,1.897368490e-006
	,2.069647469e-006
	,2.243692859e-006
	,2.423832981e-006
	,2.613675199e-006
	,2.813774251e-006
	,3.017285832e-006
	,3.221366570e-006
	,3.438181476e-006
	,3.674060040e-006
	,3.931626910e-006
	,4.212301719e-006
	,4.516518209e-006
	,4.843967540e-006
	,5.193834409e-006
	,5.564867253e-006
	,5.956611117e-006
	,6.370205228e-006
	,6.808596253e-006
	,7.275646133e-006
	,7.774639600e-006
	,8.307516466e-006
	,8.874553695e-006
	,9.474386965e-006
	,1.010483259e-005
	,1.076386157e-005
	,1.144908052e-005
	,1.215619019e-005
	,1.287862164e-005
	,1.360992936e-005
	,1.434840639e-005
	,1.509869712e-005
	,1.586801518e-005
	,1.666364937e-005
	,1.749175819e-005
	,1.835514035e-005
	,1.925322850e-005
	,2.018207998e-005
	,2.113419985e-005
	,2.209957433e-005
	,2.306899990e-005
	,2.403777975e-005
	,2.500588740e-005
	,2.597494402e-005
	,2.694607517e-005
	,2.792027425e-005
	,2.889935510e-005
	,2.988554785e-005
	,3.088055687e-005
	,3.188591438e-005
	,3.290452847e-005
	,3.394106110e-005
	,3.500017081e-005
	,3.608482358e-005
	,3.719631898e-005
	,3.833473011e-005
	,3.949978813e-005
	,4.069212572e-005
	,4.191341992e-005
	,4.316555572e-005
	,4.444996369e-005
	,4.576765208e-005
	,4.711962518e-005
	,4.850721521e-005
	,4.993218147e-005
	,5.139627194e-005
	,5.290114790e-005
	,5.444848649e-005
	,5.604014986e-005
	,5.767830419e-005
	,5.936549784e-005
	,6.110476062e-005
	,6.289972326e-005
	,6.475441121e-005
	,6.667280766e-005
	,6.866313570e-005
	,7.073582790e-005
	,7.290302227e-005
	,7.517975839e-005
	,7.758466066e-005
	,8.014056356e-005
	,8.287520596e-005
	,8.582234964e-005
	,8.902275528e-005
	,9.252299288e-005
	,9.637586453e-005
	,1.006378371e-004
	,1.053663418e-004
	,1.106171316e-004
	,1.164420215e-004
	,1.228871631e-004
	,1.299918924e-004
	,1.377881459e-004
	,1.463003575e-004
	,1.555456945e-004
	,1.655344650e-004
	,1.762705790e-004
	,1.877519158e-004
	,1.999706707e-004
	,2.129139221e-004
	,2.265659367e-004
	,2.409094147e-004
	,2.560048225e-004
	,2.717967907e-004
	,2.882642973e-004
	,3.054162205e-004
	,3.232590473e-004
	,3.417923747e-004
	,3.610300412e-004
	,3.809443785e-004
	,4.014983092e-004
	,4.227273913e-004
	,4.442465949e-004
	,4.658347883e-004
	,4.878025446e-004
	,5.101176030e-004
	,5.327826963e-004
	,5.558726146e-004
	,5.794991369e-004
	,6.036127910e-004
	,6.284091466e-004
	,6.540043368e-004
	,6.804231564e-004
	,7.076466136e-004
	,7.356419304e-004
	,7.643777634e-004
	,7.938286435e-004
	,8.239499780e-004
	,8.547070967e-004
	,8.860672116e-004
	,9.179960459e-004
	,9.504478657e-004
	,9.804436978e-004
	,1.010791177e-003
	,1.041461833e-003
	,1.072425849e-003
	,1.103651822e-003
	,1.135106560e-003
	,1.166754873e-003
	,1.198559399e-003
	,1.230480486e-003
	,1.262476161e-003
	,1.294502227e-003
	,1.326530749e-003
	,1.358547848e-003
	,1.390450265e-003
	,1.422186100e-003
	,1.453703608e-003
	,1.484952047e-003
	,-3.765129599e-004
	,-3.590890717e-004
	,-3.420088256e-004
	,-3.253801551e-004
	,-3.093060908e-004
	,-2.938701949e-004
	,-2.791155222e-004
	,-2.649736906e-004
	,-2.511369893e-004
	,-2.371281157e-004
	,-2.226994601e-004
	,-2.080974530e-004
	,-1.936883655e-004
	,-1.797329043e-004
	,-1.663568027e-004
	,-1.535598890e-004
	,-1.412708110e-004
	,-1.294317011e-004
	,-1.180355912e-004
	,-1.070854319e-004
	,-9.647942256e-005
	,-8.617861919e-005
	,-7.628585073e-005
	,-6.708713540e-005
	,-5.875730278e-005
	,-5.118880942e-005
	,-4.417334064e-005
	,-3.775190092e-005
	,-3.201464252e-005
	,-2.689480649e-005
	,-2.225821755e-005
	,-1.810390107e-005
	,-1.454725282e-005
	,-1.158698779e-005
	,-9.126615606e-006
	,-7.051191166e-006
	,-5.257351926e-006
	,-3.677857531e-006
	,-2.282824192e-006
	,-1.061305360e-006
	,1.206181160e-017
	,9.237669720e-007
	,1.715635113e-006
	,2.399256317e-006
	,3.022547486e-006
	,3.623984245e-006
	,4.230435101e-006
	,4.858537506e-006
	,5.512149102e-006
	,6.184547176e-006
	,6.872966395e-006
	,7.577741822e-006
	,8.287811755e-006
	,8.994896396e-006
	,9.704778685e-006
	,1.043427668e-005
	,1.120318289e-005
	,1.202115046e-005
	,1.288773287e-005
	,1.379604827e-005
	,1.473828277e-005
	,1.571171296e-005
	,1.671395562e-005
	,1.772997668e-005
	,1.876034759e-005
	,1.980305169e-005
	,2.084388642e-005
	,2.189816473e-005
	,2.296049064e-005
	,2.402521043e-005
	,2.509163675e-005
	,2.616079572e-005
	,2.723776333e-005
	,2.833188253e-005
	,2.945412377e-005
	,3.061497829e-005
	,3.182354339e-005
	,3.308653323e-005
	,3.440707198e-005
	,3.578402156e-005
	,3.721394737e-005
	,3.869510907e-005
	,4.022759179e-005
	,4.181073555e-005
	,4.344160173e-005
	,4.511434829e-005
	,4.682041384e-005
	,4.854991011e-005
	,5.029240652e-005
	,5.203718975e-005
	,5.378049247e-005
	,5.552135386e-005
	,5.725778620e-005
	,5.899137689e-005
	,6.072885596e-005
	,6.247961348e-005
	,6.425257316e-005
	,6.605486551e-005
	,6.789206599e-005
	,6.976874653e-005
	,7.168866145e-005
	,7.365474773e-005
	,7.566918062e-005
	,7.773349336e-005
	,7.984872078e-005
	,8.201545177e-005
	,8.423367066e-005
	,8.650234520e-005
	,8.881867952e-005
	,9.117712730e-005
	,9.357040550e-005
	,9.599172515e-005
	,9.843262102e-005
	,1.008830571e-004
	,1.033336458e-004
	,1.057767496e-004
	,1.082061393e-004
	,1.106162134e-004
	,1.130016068e-004
	,1.153574273e-004
	,1.176803341e-004
	,1.199697340e-004
	,1.222287104e-004
	,1.244637545e-004
	,1.266826858e-004
	,1.288923812e-004
	,1.310980186e-004
	,1.333039754e-004
	,1.355151317e-004
	,1.377372243e-004
	,1.399760502e-004
	,1.422359047e-004
	,1.445162239e-004
	,1.468228048e-004
	,1.491674914e-004
	,1.515590559e-004
	,1.540064409e-004
	,1.565199736e-004
	,1.591119893e-004
	,1.617975107e-004
	,1.645948530e-004
	,1.675263577e-004
	,1.706197368e-004
	,1.739085105e-004
	,1.774306450e-004
	,1.812307245e-004
	,1.853583052e-004
	,1.898662773e-004
	,1.948086893e-004
	,2.002383265e-004
	,2.062044181e-004
	,2.127507563e-004
	,2.199143435e-004
	,2.277246422e-004
	,2.362148547e-004
	,2.453964119e-004
	,2.552745786e-004
	,2.658527892e-004
	,2.771509907e-004
	,2.891892776e-004
	,3.019558517e-004
	,3.154745478e-004
	,3.297736289e-004
	,3.448790446e-004
	,3.608112326e-004
	,3.775851761e-004
	,3.952117417e-004
	,4.136992348e-004
	,4.330544424e-004
	,4.531326675e-004
	,4.731879652e-004
	,4.940394397e-004
	,5.156735672e-004
	,5.380763936e-004
	,5.612333927e-004
	,5.851292275e-004
	,6.097588515e-004
	,6.350979330e-004
	,6.611255518e-004
	,6.878213715e-004
	,7.152672047e-004
	,7.434071680e-004
	,7.721692222e-004
	,8.015295950e-004
	,8.314628704e-004
	,8.619418585e-004
	,8.929703822e-004
	,9.243433622e-004
	,9.529550440e-004
	,9.818747893e-004
	,1.011077164e-003
	,1.040534105e-003
	,1.070218601e-003
	,1.100100700e-003
	,1.130148896e-003
	,1.160330200e-003
	,1.190668549e-003
	,1.221086891e-003
	,1.251536737e-003
	,1.281995168e-003
	,1.312414483e-003
	,-4.622132855e-004
	,-4.439691722e-004
	,-4.260460747e-004
	,-4.084801428e-004
	,-3.913080804e-004
	,-3.745570517e-004
	,-3.582257629e-004
	,-3.422716600e-004
	,-3.266177752e-004
	,-3.111791766e-004
	,-2.958315803e-004
	,-2.805453521e-004
	,-2.652889844e-004
	,-2.500738139e-004
	,-2.350154498e-004
	,-2.202477320e-004
	,-2.058666672e-004
	,-1.919159486e-004
	,-1.784069205e-004
	,-1.653532390e-004
	,-1.527623445e-004
	,-1.406441801e-004
	,-1.290610860e-004
	,-1.181169374e-004
	,-1.078924731e-004
	,-9.840786213e-005
	,-8.960355287e-005
	,-8.130717844e-005
	,-7.317293839e-005
	,-6.477393168e-005
	,-5.611819615e-005
	,-4.765455564e-005
	,-3.973037915e-005
	,-3.252038451e-005
	,-2.605336140e-005
	,-2.030900090e-005
	,-1.524578173e-005
	,-1.077670531e-005
	,-6.808945127e-006
	,-3.248267729e-006
	,-1.237544931e-017
	,3.024510057e-006
	,5.893752304e-006
	,8.637123789e-006
	,1.128538546e-005
	,1.386085234e-005
	,1.629887945e-005
	,1.860676834e-005
	,2.090140412e-005
	,2.323128565e-005
	,2.559577135e-005
	,2.798641066e-005
	,3.039921641e-005
	,3.281236299e-005
	,3.520604465e-005
	,3.758280894e-005
	,3.994220841e-005
	,4.229335896e-005
	,4.462759928e-005
	,4.691214511e-005
	,4.917729345e-005
	,5.150597625e-005
	,5.393679052e-005
	,5.647480906e-005
	,5.911400903e-005
	,6.182850355e-005
	,6.452674458e-005
	,6.706483660e-005
	,6.944544922e-005
	,7.175118860e-005
	,7.399952917e-005
	,7.615257311e-005
	,7.814651924e-005
	,8.009410313e-005
	,8.205025798e-005
	,8.402681564e-005
	,8.603858210e-005
	,8.810597844e-005
	,9.024003910e-005
	,9.244100841e-005
	,9.470710441e-005
	,9.703897581e-005
	,9.943969875e-005
	,1.019060948e-004
	,1.044187411e-004
	,1.069385359e-004
	,1.094187461e-004
	,1.118284774e-004
	,1.141648666e-004
	,1.164454055e-004
	,1.186935234e-004
	,1.209288316e-004
	,1.231619613e-004
	,1.253947631e-004
	,1.276427457e-004
	,1.299274502e-004
	,1.322568894e-004
	,1.346302151e-004
	,1.370412430e-004
	,1.394798557e-004
	,1.419348850e-004
	,1.443980262e-004
	,1.468643536e-004
	,1.493291769e-004
	,1.517856206e-004
	,1.542257195e-004
	,1.566442537e-004
	,1.590405628e-004
	,1.614159921e-004
	,1.637716254e-004
	,1.661094238e-004
	,1.684335239e-004
	,1.707486314e-004
	,1.730575875e-004
	,1.753627096e-004
	,1.776715445e-004
	,1.799933427e-004
	,1.823345110e-004
	,1.846994722e-004
	,1.870915603e-004
	,1.895131332e-004
	,1.919655139e-004
	,1.944490118e-004
	,1.969631571e-004
	,1.995076246e-004
	,2.020827692e-004
	,2.046888340e-004
	,2.073256058e-004
	,2.099924693e-004
	,2.126883797e-004
	,2.154117310e-004
	,2.181602753e-004
	,2.209312471e-004
	,2.237217079e-004
	,2.265288751e-004
	,2.293501075e-004
	,2.321821603e-004
	,2.350180500e-004
	,2.378380718e-004
	,2.406380415e-004
	,2.434274875e-004
	,2.462065802e-004
	,2.489752331e-004
	,2.517350050e-004
	,2.544890254e-004
	,2.572427593e-004
	,2.600052294e-004
	,2.627907292e-004
	,2.656189625e-004
	,2.685152839e-004
	,2.715105842e-004
	,2.746424481e-004
	,2.779549422e-004
	,2.814980034e-004
	,2.853251264e-004
	,2.894934250e-004
	,2.940629007e-004
	,2.990940611e-004
	,3.046421320e-004
	,3.107609090e-004
	,3.174992709e-004
	,3.249008070e-004
	,3.330035514e-004
	,3.418399822e-004
	,3.514373799e-004
	,3.618184120e-004
	,3.730018261e-004
	,3.850031620e-004
	,3.978354821e-004
	,4.115099644e-004
	,4.260364414e-004
	,4.414238292e-004
	,4.576804709e-004
	,4.748144591e-004
	,4.928342983e-004
	,5.114961860e-004
	,5.302116830e-004
	,5.497458307e-004
	,5.700849928e-004
	,5.912145403e-004
	,6.131187219e-004
	,6.357801721e-004
	,6.591794010e-004
	,6.832943134e-004
	,7.080998158e-004
	,7.335674688e-004
	,7.596658712e-004
	,7.863610574e-004
	,8.136174973e-004
	,8.415004067e-004
	,8.700577871e-004
	,8.991230380e-004
	,9.286586475e-004
	,9.565539216e-004
	,9.834165983e-004
	,1.010533230e-003
	,1.037854006e-003
	,1.065325019e-003
	,1.092888432e-003
	,1.120512752e-003
	,1.148279265e-003
	,-5.343148086e-004
	,-5.165180078e-004
	,-4.986812349e-004
	,-4.809110466e-004
	,-4.632731641e-004
	,-4.457840069e-004
	,-4.284818053e-004
	,-4.114136265e-004
	,-3.946222804e-004
	,-3.781576411e-004
	,-3.620125538e-004
	,-3.460625317e-004
	,-3.301424927e-004
	,-3.141293671e-004
	,-2.979685608e-004
	,-2.817226128e-004
	,-2.655350570e-004
	,-2.495734683e-004
	,-2.339581995e-004
	,-2.187417328e-004
	,-2.039151317e-004
	,-1.894830365e-004
	,-1.755596430e-004
	,-1.622044743e-004
	,-1.494319176e-004
	,-1.372473288e-004
	,-1.256640271e-004
	,-1.146993021e-004
	,-1.043365207e-004
	,-9.446559086e-005
	,-8.480183158e-005
	,-7.497781608e-005
	,-6.501182317e-005
	,-5.522654883e-005
	,-4.580989803e-005
	,-3.693677124e-005
	,-2.866598034e-005
	,-2.092760546e-005
	,-1.361760136e-005
	,-6.651481933e-006
	,-3.968613828e-018
	,6.311552733e-006
	,1.226453263e-005
	,1.789086083e-005
	,2.327965519e-005
	,2.849860642e-005
	,3.354257188e-005
	,3.842710813e-005
	,4.309070029e-005
	,4.731157080e-005
	,5.120462163e-005
	,5.501221479e-005
	,5.882307403e-005
	,6.265778574e-005
	,6.651037996e-005
	,7.037289230e-005
	,7.422565001e-005
	,7.801473139e-005
	,8.175057442e-005
	,8.548767117e-005
	,8.924477809e-005
	,9.301678502e-005
	,9.678800496e-005
	,1.005383732e-004
	,1.042494525e-004
	,1.079122785e-004
	,1.115309824e-004
	,1.151122365e-004
	,1.186496085e-004
	,1.221090157e-004
	,1.254044304e-004
	,1.284643675e-004
	,1.313926163e-004
	,1.342661021e-004
	,1.370680383e-004
	,1.398173895e-004
	,1.425248450e-004
	,1.450562463e-004
	,1.474067252e-004
	,1.497630013e-004
	,1.521557630e-004
	,1.545824517e-004
	,1.570430588e-004
	,1.595347093e-004
	,1.620483183e-004
	,1.645711388e-004
	,1.670908983e-004
	,1.695990104e-004
	,1.720914310e-004
	,1.745701545e-004
	,1.770395043e-004
	,1.795013239e-004
	,1.819644514e-004
	,1.844375458e-004
	,1.869218303e-004
	,1.894136803e-004
	,1.918999856e-004
	,1.943620991e-004
	,1.968147341e-004
	,1.992827772e-004
	,2.017759657e-004
	,2.042966511e-004
	,2.068449209e-004
	,2.094204720e-004
	,2.120227328e-004
	,2.146502566e-004
	,2.173005617e-004
	,2.199702185e-004
	,2.226549939e-004
	,2.253502368e-004
	,2.280517076e-004
	,2.307566361e-004
	,2.334644520e-004
	,2.361773652e-004
	,2.389004133e-004
	,2.416395718e-004
	,2.443987755e-004
	,2.471776496e-004
	,2.499732938e-004
	,2.527900751e-004
	,2.556368301e-004
	,2.585184598e-004
	,2.614365961e-004
	,2.643912842e-004
	,2.673817462e-004
	,2.704066647e-004
	,2.734639603e-004
	,2.765503841e-004
	,2.796623477e-004
	,2.827971003e-004
	,2.859513703e-004
	,2.891198700e-004
	,2.922947946e-004
	,2.954655579e-004
	,2.986190104e-004
	,3.017411938e-004
	,3.048215212e-004
	,3.078578018e-004
	,3.108580807e-004
	,3.138381535e-004
	,3.168171565e-004
	,3.198130480e-004
	,3.228392661e-004
	,3.258998784e-004
	,3.289751416e-004
	,3.320686945e-004
	,3.352062746e-004
	,3.383951749e-004
	,3.416382277e-004
	,3.449378605e-004
	,3.482970266e-004
	,3.517196591e-004
	,3.552110451e-004
	,3.587782069e-004
	,3.624303144e-004
	,3.661791264e-004
	,3.700394440e-004
	,3.740295377e-004
	,3.781714945e-004
	,3.824914082e-004
	,3.870193292e-004
	,3.917888870e-004
	,3.968365163e-004
	,4.022002614e-004
	,4.079182027e-004
	,4.140266518e-004
	,4.205594105e-004
	,4.275456410e-004
	,4.350104712e-004
	,4.429706034e-004
	,4.514454173e-004
	,4.604449350e-004
	,4.699947125e-004
	,4.801164841e-004
	,4.908389446e-004
	,5.022172480e-004
	,5.142908137e-004
	,5.271140122e-004
	,5.407348684e-004
	,5.551914396e-004
	,5.705159914e-004
	,5.867205324e-004
	,6.027738182e-004
	,6.195980484e-004
	,6.370704614e-004
	,6.550068115e-004
	,6.735190517e-004
	,6.925889230e-004
	,7.122654537e-004
	,7.325850381e-004
	,7.535569075e-004
	,7.751810882e-004
	,7.974497421e-004
	,8.203502684e-004
	,8.438665436e-004
	,8.679799878e-004
	,8.926695683e-004
	,9.179121471e-004
	,9.436826075e-004
	,9.699538273e-004
	,9.935963708e-004
	,-5.812484236e-004
	,-5.646165562e-004
	,-5.478966977e-004
	,-5.310843178e-004
	,-5.142525162e-004
	,-4.975180674e-004
	,-4.809648108e-004
	,-4.645757842e-004
	,-4.482513797e-004
	,-4.318016854e-004
	,-4.150044422e-004
	,-3.977507782e-004
	,-3.800472218e-004
	,-3.620841632e-004
	,-3.441466069e-004
	,-3.264388862e-004
	,-3.090605882e-004
	,-2.920488051e-004
	,-2.754077383e-004
	,-2.591218009e-004
	,-2.431791330e-004
	,-2.276011528e-004
	,-2.124279029e-004
	,-1.976847126e-004
	,-1.833842888e-004
	,-1.695442273e-004
	,-1.561671007e-004
	,-1.432118507e-004
	,-1.305700961e-004
	,-1.180863562e-004
	,-1.056018363e-004
	,-9.316269561e-005
	,-8.101127198e-005
	,-6.933041051e-005
	,-5.818160522e-005
	,-4.753200931e-005
	,-3.727521475e-005
	,-2.734343743e-005
	,-1.781437471e-005
	,-8.712811291e-006
	,-4.542993893e-018
	,8.365708152e-006
	,1.642889335e-005
	,2.424606531e-005
	,3.187480900e-005
	,3.936301258e-005
	,4.674295241e-005
	,5.402339439e-005
	,6.116312485e-005
	,6.800861429e-005
	,7.440275085e-005
	,8.045318848e-005
	,8.628843589e-005
	,9.192269128e-005
	,9.732617583e-005
	,1.024862851e-004
	,1.073770861e-004
	,1.120094156e-004
	,1.165316078e-004
	,1.210744315e-004
	,1.256849933e-004
	,1.303701850e-004
	,1.351229590e-004
	,1.399309235e-004
	,1.447784495e-004
	,1.496464783e-004
	,1.545109048e-004
	,1.593387628e-004
	,1.640973709e-004
	,1.687653402e-004
	,1.732979143e-004
	,1.776040002e-004
	,1.816144683e-004
	,1.852872540e-004
	,1.886757253e-004
	,1.919861074e-004
	,1.953154683e-004
	,1.986745916e-004
	,2.020496222e-004
	,2.054201293e-004
	,2.087636213e-004
	,2.120341006e-004
	,2.150390382e-004
	,2.177060353e-004
	,2.203333376e-004
	,2.229817989e-004
	,2.256392517e-004
	,2.282953730e-004
	,2.309452976e-004
	,2.335847436e-004
	,2.362050173e-004
	,2.387864082e-004
	,2.413154159e-004
	,2.438183249e-004
	,2.463203507e-004
	,2.488296067e-004
	,2.513472370e-004
	,2.538719433e-004
	,2.563998182e-004
	,2.589180549e-004
	,2.613943075e-004
	,2.638068897e-004
	,2.661915455e-004
	,2.685797200e-004
	,2.709808045e-004
	,2.733962005e-004
	,2.758253313e-004
	,2.782682047e-004
	,2.807245153e-004
	,2.831934448e-004
	,2.856731158e-004
	,2.881636569e-004
	,2.906681794e-004
	,2.931876718e-004
	,2.957219961e-004
	,2.982708846e-004
	,3.008341528e-004
	,3.034117330e-004
	,3.060035349e-004
	,3.086088327e-004
	,3.112248035e-004
	,3.138442604e-004
	,3.164579421e-004
	,3.190680535e-004
	,3.216839037e-004
	,3.243100819e-004
	,3.269478320e-004
	,3.295973603e-004
	,3.322586020e-004
	,3.349313919e-004
	,3.376152421e-004
	,3.403088261e-004
	,3.430106345e-004
	,3.457212797e-004
	,3.484428429e-004
	,3.511770032e-004
	,3.539248296e-004
	,3.566870770e-004
	,3.594643948e-004
	,3.622574239e-004
	,3.650667793e-004
	,3.678929583e-004
	,3.707363135e-004
	,3.735970715e-004
	,3.764751377e-004
	,3.793701561e-004
	,3.822819048e-004
	,3.852102795e-004
	,3.881546306e-004
	,3.911101317e-004
	,3.940501379e-004
	,3.969585809e-004
	,3.998696640e-004
	,4.027940851e-004
	,4.057327962e-004
	,4.086854561e-004
	,4.116521050e-004
	,4.146337224e-004
	,4.176325516e-004
	,4.206524759e-004
	,4.236993548e-004
	,4.267813666e-004
	,4.299093610e-004
	,4.330971104e-004
	,4.363615466e-004
	,4.397229206e-004
	,4.432048873e-004
	,4.468348188e-004
	,4.506443829e-004
	,4.546700121e-004
	,4.589529093e-004
	,4.635385925e-004
	,4.684760605e-004
	,4.738161166e-004
	,4.796099855e-004
	,4.859077518e-004
	,4.927569569e-004
	,5.002014408e-004
	,5.082807061e-004
	,5.170294821e-004
	,5.264766315e-004
	,5.366467700e-004
	,5.475602118e-004
	,5.592323582e-004
	,5.716742109e-004
	,5.848940484e-004
	,5.988981470e-004
	,6.136914217e-004
	,6.292106463e-004
	,6.445735645e-004
	,6.606573993e-004
	,6.774394066e-004
	,6.948987244e-004
	,7.130237274e-004
	,7.317894710e-004
	,7.511650713e-004
	,7.711420235e-004
	,7.917179747e-004
	,8.128754081e-004
	,8.346008379e-004
	,8.568773945e-004
	,-6.172731351e-004
	,-6.005109002e-004
	,-5.837855680e-004
	,-5.672042236e-004
	,-5.508921227e-004
	,-5.348760410e-004
	,-5.190047857e-004
	,-5.030050433e-004
	,-4.865907731e-004
	,-4.695686708e-004
	,-4.519187134e-004
	,-4.337822366e-004
	,-4.154305159e-004
	,-3.971359169e-004
	,-3.790601039e-004
	,-3.612490605e-004
	,-3.436613977e-004
	,-3.262077901e-004
	,-3.088650433e-004
	,-2.917124141e-004
	,-2.748223774e-004
	,-2.582272998e-004
	,-2.419292396e-004
	,-2.259242083e-004
	,-2.102412603e-004
	,-1.948920131e-004
	,-1.798336579e-004
	,-1.649943417e-004
	,-1.502953187e-004
	,-1.357335364e-004
	,-1.214249887e-004
	,-1.074996920e-004
	,-9.403051212e-005
	,-8.103642907e-005
	,-6.849997593e-005
	,-5.637531771e-005
	,-4.458635668e-005
	,-3.302786018e-005
	,-2.165450944e-005
	,-1.060542321e-005
	,-1.305426212e-017
	,1.016396279e-005
	,1.993961135e-005
	,2.939381849e-005
	,3.859360570e-005
	,4.759780750e-005
	,5.644468592e-005
	,6.512179898e-005
	,7.351093427e-005
	,8.146628154e-005
	,8.907131584e-005
	,9.647418620e-005
	,1.037419975e-004
	,1.109017461e-004
	,1.179592832e-004
	,1.249054693e-004
	,1.317221396e-004
	,1.383910110e-004
	,1.449096023e-004
	,1.512936024e-004
	,1.575578987e-004
	,1.637054205e-004
	,1.697318974e-004
	,1.756324270e-004
	,1.813990779e-004
	,1.870134060e-004
	,1.924486595e-004
	,1.977034342e-004
	,2.028362759e-004
	,2.079227129e-004
	,2.130053776e-004
	,2.180888727e-004
	,2.231382072e-004
	,2.280764470e-004
	,2.328484380e-004
	,2.374913823e-004
	,2.420614175e-004
	,2.465845462e-004
	,2.510665571e-004
	,2.555036486e-004
	,2.598807596e-004
	,2.641656874e-004
	,2.683629997e-004
	,2.724790998e-004
	,2.764796898e-004
	,2.803036383e-004
	,2.838385171e-004
	,2.868008772e-004
	,2.895256405e-004
	,2.923170270e-004
	,2.951854364e-004
	,2.981090271e-004
	,3.010699017e-004
	,3.040556700e-004
	,3.070585389e-004
	,3.100741861e-004
	,3.131002343e-004
	,3.161350272e-004
	,3.191769753e-004
	,3.222240329e-004
	,3.252727191e-004
	,3.283156519e-004
	,3.313349846e-004
	,3.342912688e-004
	,3.371457478e-004
	,3.399230535e-004
	,3.426669997e-004
	,3.453964166e-004
	,3.481140047e-004
	,3.508128023e-004
	,3.534828809e-004
	,3.561336540e-004
	,3.587848258e-004
	,3.614451869e-004
	,3.641164733e-004
	,3.667982805e-004
	,3.694898257e-004
	,3.721904992e-004
	,3.748997960e-004
	,3.776169679e-004
	,3.803407993e-004
	,3.830690614e-004
	,3.858011392e-004
	,3.885368071e-004
	,3.912708903e-004
	,3.939908206e-004
	,3.966833860e-004
	,3.993550151e-004
	,4.020204180e-004
	,4.046870725e-004
	,4.073575822e-004
	,4.100341190e-004
	,4.127180624e-004
	,4.154079853e-004
	,4.181003871e-004
	,4.207895989e-004
	,4.234706740e-004
	,4.261449401e-004
	,4.288168849e-004
	,4.314895137e-004
	,4.341643353e-004
	,4.368422703e-004
	,4.395241561e-004
	,4.422109472e-004
	,4.449036739e-004
	,4.476031766e-004
	,4.503098878e-004
	,4.530239910e-004
	,4.557458172e-004
	,4.584761767e-004
	,4.612161145e-004
	,4.639659273e-004
	,4.667256665e-004
	,4.694955476e-004
	,4.722746953e-004
	,4.750548079e-004
	,4.777942999e-004
	,4.804783510e-004
	,4.831573642e-004
	,4.858460811e-004
	,4.885470514e-004
	,4.912611653e-004
	,4.939886266e-004
	,4.967290032e-004
	,4.994820968e-004
	,5.022486925e-004
	,5.050307616e-004
	,5.078315076e-004
	,5.106554558e-004
	,5.135085903e-004
	,5.163985437e-004
	,5.193349025e-004
	,5.223297229e-004
	,5.253981726e-004
	,5.285592468e-004
	,5.318364334e-004
	,5.352580417e-004
	,5.388567664e-004
	,5.426695561e-004
	,5.467378421e-004
	,5.511071577e-004
	,5.558262021e-004
	,5.609448251e-004
	,5.665129852e-004
	,5.725792645e-004
	,5.791896054e-004
	,5.863859772e-004
	,5.942047041e-004
	,6.026759653e-004
	,6.118238872e-004
	,6.216675926e-004
	,6.322218733e-004
	,6.434964832e-004
	,6.554973747e-004
	,6.682282071e-004
	,6.814656131e-004
	,6.946964870e-004
	,7.085911360e-004
	,7.231287048e-004
	,7.382860665e-004
	,7.540444822e-004
	,-6.486100307e-004
	,-6.308493185e-004
	,-6.132421569e-004
	,-5.959177625e-004
	,-5.788803201e-004
	,-5.619601777e-004
	,-5.449229552e-004
	,-5.276583071e-004
	,-5.101292192e-004
	,-4.923337802e-004
	,-4.743414722e-004
	,-4.563361383e-004
	,-4.384916606e-004
	,-4.208680390e-004
	,-4.033983919e-004
	,-3.859751438e-004
	,-3.685723377e-004
	,-3.512495549e-004
	,-3.340737912e-004
	,-3.170767063e-004
	,-3.002395669e-004
	,-2.834855635e-004
	,-2.667131781e-004
	,-2.498796995e-004
	,-2.330290782e-004
	,-2.162208467e-004
	,-1.994899797e-004
	,-1.829164327e-004
	,-1.666162835e-004
	,-1.506841371e-004
	,-1.351716687e-004
	,-1.200954218e-004
	,-1.054483378e-004
	,-9.120739702e-005
	,-7.733743342e-005
	,-6.379762282e-005
	,-5.054219301e-005
	,-3.750881491e-005
	,-2.467513769e-005
	,-1.214256033e-005
	,-4.020830199e-018
	,1.174662813e-005
	,2.313000710e-005
	,3.419227495e-005
	,4.496803440e-005
	,5.545941083e-005
	,6.561744257e-005
	,7.534396667e-005
	,8.455150081e-005
	,9.332718068e-005
	,1.018062823e-004
	,1.100676091e-004
	,1.181551501e-004
	,1.261007589e-004
	,1.339295252e-004
	,1.416590963e-004
	,1.493000611e-004
	,1.568578767e-004
	,1.643349082e-004
	,1.717311095e-004
	,1.790436804e-004
	,1.862671274e-004
	,1.933939217e-004
	,2.004155293e-004
	,2.073249125e-004
	,2.141216429e-004
	,2.208160216e-004
	,2.274257105e-004
	,2.339673110e-004
	,2.404497786e-004
	,2.468693476e-004
	,2.532021401e-004
	,2.594014059e-004
	,2.654287901e-004
	,2.712877057e-004
	,2.769946155e-004
	,2.825586575e-004
	,2.879924252e-004
	,2.933225617e-004
	,2.985806986e-004
	,3.037903689e-004
	,3.089650435e-004
	,3.141112542e-004
	,3.192312088e-004
	,3.243240704e-004
	,3.293861751e-004
	,3.344100519e-004
	,3.393807468e-004
	,3.442624594e-004
	,3.489389309e-004
	,3.530196657e-004
	,3.564180118e-004
	,3.597420503e-004
	,3.631054751e-004
	,3.664501317e-004
	,3.697708752e-004
	,3.730839425e-004
	,3.763840848e-004
	,3.796568942e-004
	,3.828860238e-004
	,3.860664126e-004
	,3.892135672e-004
	,3.923465782e-004
	,3.954734968e-004
	,3.985896108e-004
	,4.016781467e-004
	,4.047237956e-004
	,4.077293178e-004
	,4.107044590e-004
	,4.136557421e-004
	,4.165867327e-004
	,4.194994497e-004
	,4.223951068e-004
	,4.252744961e-004
	,4.281381987e-004
	,4.309867023e-004
	,4.338204700e-004
	,4.366399917e-004
	,4.394458341e-004
	,4.422386810e-004
	,4.450193002e-004
	,4.477884060e-004
	,4.505465312e-004
	,4.532939955e-004
	,4.560308836e-004
	,4.587568976e-004
	,4.614709012e-004
	,4.641697786e-004
	,4.668468465e-004
	,4.694954247e-004
	,4.721199687e-004
	,4.747331049e-004
	,4.773437665e-004
	,4.799560003e-004
	,4.825714066e-004
	,4.851899208e-004
	,4.878068291e-004
	,4.904049776e-004
	,4.929805842e-004
	,4.955325178e-004
	,4.980530821e-004
	,5.005477822e-004
	,5.030306810e-004
	,5.055100524e-004
	,5.079882259e-004
	,5.104650306e-004
	,5.129394872e-004
	,5.154104077e-004
	,5.178766277e-004
	,5.203372124e-004
	,5.227916019e-004
	,5.252384599e-004
	,5.276758918e-004
	,5.301025877e-004
	,5.325176890e-004
	,5.349208720e-004
	,5.373126341e-004
	,5.396946590e-004
	,5.420696389e-004
	,5.444390900e-004
	,5.468008887e-004
	,5.491443886e-004
	,5.514234240e-004
	,5.536186923e-004
	,5.557924102e-004
	,5.579648721e-004
	,5.601394764e-004
	,5.623172278e-004
	,5.644989667e-004
	,5.666856669e-004
	,5.688782967e-004
	,5.710776985e-004
	,5.732847889e-004
	,5.755010161e-004
	,5.777288456e-004
	,5.799716563e-004
	,5.822328207e-004
	,5.845165841e-004
	,5.868291102e-004
	,5.891785985e-004
	,5.915754671e-004
	,5.940327374e-004
	,5.965665050e-004
	,5.991964374e-004
	,6.019462215e-004
	,6.048439385e-004
	,6.079222822e-004
	,6.112186396e-004
	,6.147747860e-004
	,6.186361073e-004
	,6.228493272e-004
	,6.274609396e-004
	,6.325161815e-004
	,6.380590746e-004
	,6.441312384e-004
	,6.507712815e-004
	,6.580129022e-004
	,6.658855938e-004
	,6.744139464e-004
	,6.836180769e-004
	,6.935147249e-004
	,-6.748566638e-004
	,-6.566902222e-004
	,-6.387634512e-004
	,-6.210440561e-004
	,-6.033559966e-004
	,-5.854682304e-004
	,-5.673099959e-004
	,-5.489107472e-004
	,-5.302872167e-004
	,-5.114887591e-004
	,-4.926975944e-004
	,-4.741012786e-004
	,-4.557994008e-004
	,-4.378282536e-004
	,-4.202041176e-004
	,-4.029400659e-004
	,-3.860255394e-004
	,-3.694046934e-004
	,-3.529536289e-004
	,-3.364697357e-004
	,-3.197390119e-004
	,-3.026846027e-004
	,-2.853779886e-004
	,-2.678978984e-004
	,-2.502989444e-004
	,-2.327065467e-004
	,-2.152773949e-004
	,-1.980940578e-004
	,-1.811597003e-004
	,-1.644712637e-004
	,-1.480659824e-004
	,-1.319686648e-004
	,-1.161789925e-004
	,-1.007025407e-004
	,-8.554483863e-005
	,-7.068046219e-005
	,-5.604617989e-005
	,-4.158788290e-005
	,-2.736359808e-005
	,-1.348463100e-005
	,-2.924286441e-018
	,1.309235550e-005
	,2.581301996e-005
	,3.818073778e-005
	,5.019266034e-005
	,6.180052556e-005
	,7.291540123e-005
	,8.350989173e-005
	,9.367020015e-005
	,1.034980980e-004
	,1.130579981e-004
	,1.223649894e-004
	,1.313862418e-004
	,1.401471740e-004
	,1.487251062e-004
	,1.571687123e-004
	,1.655058709e-004
	,1.737532364e-004
	,1.819184353e-004
	,1.900001679e-004
	,1.979899310e-004
	,2.058796014e-004
	,2.136694397e-004
	,2.213658752e-004
	,2.289752938e-004
	,2.365016016e-004
	,2.439462368e-004
	,2.513083541e-004
	,2.585840495e-004
	,2.657637603e-004
	,2.728285781e-004
	,2.797546244e-004
	,2.865362339e-004
	,2.931951300e-004
	,2.997584487e-004
	,3.062462530e-004
	,3.126720742e-004
	,3.190450605e-004
	,3.253714240e-004
	,3.316553404e-004
	,3.378994528e-004
	,3.441050790e-004
	,3.502721872e-004
	,3.563991800e-004
	,3.624825425e-004
	,3.685166222e-004
	,3.744943945e-004
	,3.804101865e-004
	,3.862617605e-004
	,3.920446874e-004
	,3.977355664e-004
	,4.032472251e-004
	,4.082432309e-004
	,4.121815278e-004
	,4.157899539e-004
	,4.195371670e-004
	,4.234021800e-004
	,4.273330042e-004
	,4.312927227e-004
	,4.352560464e-004
	,4.392048524e-004
	,4.431253593e-004
	,4.470063666e-004
	,4.508380158e-004
	,4.546105783e-004
	,4.583122367e-004
	,4.619223328e-004
	,4.653990184e-004
	,4.687230591e-004
	,4.719408860e-004
	,4.750833499e-004
	,4.781594232e-004
	,4.811713684e-004
	,4.841188729e-004
	,4.870009418e-004
	,4.898208846e-004
	,4.925894555e-004
	,4.953187977e-004
	,4.980172342e-004
	,5.006896094e-004
	,5.033388364e-004
	,5.059668757e-004
	,5.085752314e-004
	,5.111651795e-004
	,5.137378286e-004
	,5.162941058e-004
	,5.188347484e-004
	,5.213603061e-004
	,5.238711109e-004
	,5.263671597e-004
	,5.288478104e-004
	,5.313110969e-004
	,5.337526272e-004
	,5.361663453e-004
	,5.385522705e-004
	,5.409200660e-004
	,5.432788406e-004
	,5.456328212e-004
	,5.479832663e-004
	,5.503300386e-004
	,5.526721453e-004
	,5.550075359e-004
	,5.573321799e-004
	,5.596387342e-004
	,5.619176253e-004
	,5.641647353e-004
	,5.663862034e-004
	,5.685913074e-004
	,5.707862865e-004
	,5.729742592e-004
	,5.751564695e-004
	,5.773309936e-004
	,5.794901553e-004
	,5.816421873e-004
	,5.837961330e-004
	,5.859539458e-004
	,5.881166554e-004
	,5.902853359e-004
	,5.924607626e-004
	,5.946428723e-004
	,5.968309755e-004
	,5.990243888e-004
	,6.012227132e-004
	,6.034257807e-004
	,6.056334597e-004
	,6.078452545e-004
	,6.100590512e-004
	,6.122652746e-004
	,6.144180442e-004
	,6.164653693e-004
	,6.184806114e-004
	,6.205002812e-004
	,6.225286211e-004
	,6.245648466e-004
	,6.266076159e-004
	,6.286557996e-004
	,6.307086666e-004
	,6.327659882e-004
	,6.348281952e-004
	,6.368966103e-004
	,6.389733226e-004
	,6.410598518e-004
	,6.431564072e-004
	,6.452635334e-004
	,6.473832559e-004
	,6.495191343e-004
	,6.516762451e-004
	,6.538613231e-004
	,6.560830511e-004
	,6.583524370e-004
	,6.606832488e-004
	,6.630924728e-004
	,6.656007202e-004
	,6.682324790e-004
	,6.710161400e-004
	,6.739839120e-004
	,6.771718739e-004
	,6.806201742e-004
	,6.843716320e-004
	,6.884687845e-004
	,6.929538834e-004
	,-6.993633398e-004
	,-6.809003653e-004
	,-6.625571132e-004
	,-6.442192545e-004
	,-6.257083283e-004
	,-6.068999665e-004
	,-5.878381266e-004
	,-5.685626218e-004
	,-5.490898655e-004
	,-5.295584102e-004
	,-5.101635887e-004
	,-4.910178448e-004
	,-4.722009766e-004
	,-4.537598012e-004
	,-4.357113958e-004
	,-4.180503827e-004
	,-4.007490042e-004
	,-3.837479688e-004
	,-3.669403396e-004
	,-3.501790944e-004
	,-3.333195820e-004
	,-3.162197750e-004
	,-2.987882295e-004
	,-2.810587696e-004
	,-2.631762153e-004
	,-2.453144704e-004
	,-2.276058218e-004
	,-2.101236421e-004
	,-1.928885526e-004
	,-1.758821250e-004
	,-1.590670640e-004
	,-1.424211563e-004
	,-1.259317074e-004
	,-1.095675813e-004
	,-9.330971471e-005
	,-7.714865631e-005
	,-6.110502860e-005
	,-4.528479737e-005
	,-2.979672758e-005
	,-1.469507389e-005
	,7.308594225e-019
	,1.427974578e-005
	,2.813855983e-005
	,4.156093079e-005
	,5.450295636e-005
	,6.691403653e-005
	,7.880280248e-005
	,9.023507758e-005
	,1.012821035e-004
	,1.119989376e-004
	,1.224243102e-004
	,1.325877911e-004
	,1.425187431e-004
	,1.522472099e-004
	,1.617988857e-004
	,1.711912729e-004
	,1.804290387e-004
	,1.894910016e-004
	,1.983187026e-004
	,2.068968083e-004
	,2.152998438e-004
	,2.235874846e-004
	,2.317880113e-004
	,2.399159623e-004
	,2.479798420e-004
	,2.559845304e-004
	,2.639315998e-004
	,2.718182468e-004
	,2.796350878e-004
	,2.873658289e-004
	,2.949975507e-004
	,3.025361540e-004
	,3.099997824e-004
	,3.174029077e-004
	,3.247530858e-004
	,3.320537162e-004
	,3.393062699e-004
	,3.465113254e-004
	,3.536689945e-004
	,3.607792302e-004
	,3.678422691e-004
	,3.748591128e-004
	,3.818315873e-004
	,3.887616011e-004
	,3.956498006e-004
	,4.024941302e-004
	,4.092884595e-004
	,4.160209712e-004
	,4.226718100e-004
	,4.292098274e-004
	,4.355899855e-004
	,4.417562908e-004
	,4.476488953e-004
	,4.531682416e-004
	,4.579442036e-004
	,4.615716928e-004
	,4.650182608e-004
	,4.686361486e-004
	,4.723619575e-004
	,4.761410399e-004
	,4.799443677e-004
	,4.837563512e-004
	,4.875672002e-004
	,4.913696924e-004
	,4.951580084e-004
	,4.989272862e-004
	,5.026734187e-004
	,5.063929959e-004
	,5.100834255e-004
	,5.137430782e-004
	,5.173708936e-004
	,5.209656584e-004
	,5.245258480e-004
	,5.280498415e-004
	,5.315360459e-004
	,5.349828403e-004
	,5.383882967e-004
	,5.417494178e-004
	,5.450598791e-004
	,5.483028964e-004
	,5.514387990e-004
	,5.544444724e-004
	,5.573653537e-004
	,5.602392396e-004
	,5.630792208e-004
	,5.658892248e-004
	,5.686700660e-004
	,5.714210521e-004
	,5.741403557e-004
	,5.768257924e-004
	,5.794774662e-004
	,5.820997018e-004
	,5.846980910e-004
	,5.872761887e-004
	,5.898350848e-004
	,5.923737053e-004
	,5.948885071e-004
	,5.973733218e-004
	,5.998234458e-004
	,6.022437369e-004
	,6.046452216e-004
	,6.070354094e-004
	,6.094171402e-004
	,6.117908268e-004
	,6.141557702e-004
	,6.165104997e-004
	,6.188525182e-004
	,6.211776604e-004
	,6.234798046e-004
	,6.257530676e-004
	,6.279963167e-004
	,6.302135501e-004
	,6.324098953e-004
	,6.345892926e-004
	,6.367543273e-004
	,6.389065887e-004
	,6.410470545e-004
	,6.431764054e-004
	,6.452952144e-004
	,6.474040321e-004
	,6.495034079e-004
	,6.515940759e-004
	,6.536771681e-004
	,6.557544697e-004
	,6.578275509e-004
	,6.598952949e-004
	,6.619515062e-004
	,6.639955352e-004
	,6.660358728e-004
	,6.680745555e-004
	,6.701117578e-004
	,6.721469322e-004
	,6.741779372e-004
	,6.761963607e-004
	,6.781632212e-004
	,6.800012939e-004
	,6.817769144e-004
	,6.835538595e-004
	,6.853401950e-004
	,6.871338609e-004
	,6.889318872e-004
	,6.907318199e-004
	,6.925318432e-004
	,6.943306840e-004
	,6.961275284e-004
	,6.979220200e-004
	,6.997144526e-004
	,7.015056407e-004
	,7.032955507e-004
	,7.050843744e-004
	,7.068732860e-004
	,7.086641691e-004
	,7.104595798e-004
	,7.122628386e-004
	,7.140782104e-004
	,7.159111533e-004
	,7.177686483e-004
	,7.196595841e-004
	,7.215952222e-004
	,7.235897936e-004
	,7.256611945e-004
	,-7.218407853e-004
	,-7.029784174e-004
	,-6.841271527e-004
	,-6.651767857e-004
	,-6.459393209e-004
	,-6.263797496e-004
	,-6.065758447e-004
	,-5.865566851e-004
	,-5.664264640e-004
	,-5.464008036e-004
	,-5.266151734e-004
	,-5.071461231e-004
	,-4.880529410e-004
	,-4.693529129e-004
	,-4.510319945e-004
	,-4.330505146e-004
	,-4.153348485e-004
	,-3.977648968e-004
	,-3.801985401e-004
	,-3.625250499e-004
	,-3.446583286e-004
	,-3.266026644e-004
	,-3.084725699e-004
	,-2.904131747e-004
	,-2.725387240e-004
	,-2.548839137e-004
	,-2.374173589e-004
	,-2.200661244e-004
	,-2.027438396e-004
	,-1.854124799e-004
	,-1.681123183e-004
	,-1.508898754e-004
	,-1.337363126e-004
	,-1.165843601e-004
	,-9.939084828e-005
	,-8.222636345e-005
	,-6.520088094e-005
	,-4.839416738e-005
	,-3.188060727e-005
	,-1.573373900e-005
	,3.796113086e-017
	,1.529320950e-005
	,3.011223721e-005
	,4.440922819e-005
	,5.815203548e-005
	,7.135336766e-005
	,8.405537324e-005
	,9.630575206e-005
	,1.081484489e-004
	,1.196229889e-004
	,1.307670858e-004
	,1.416181164e-004
	,1.522111628e-004
	,1.625771482e-004
	,1.727428214e-004
	,1.827312325e-004
	,1.925622077e-004
	,2.022527304e-004
	,2.118171834e-004
	,2.212673694e-004
	,2.306121444e-004
	,2.398562292e-004
	,2.489969080e-004
	,2.580153421e-004
	,2.668626749e-004
	,2.754878856e-004
	,2.839217227e-004
	,2.922276264e-004
	,3.004350096e-004
	,3.085559553e-004
	,3.166062834e-004
	,3.246035297e-004
	,3.325599969e-004
	,3.404825213e-004
	,3.483745182e-004
	,3.562373997e-004
	,3.640712042e-004
	,3.718747153e-004
	,3.796452027e-004
	,3.873777404e-004
	,3.950638568e-004
	,4.026889964e-004
	,4.102280569e-004
	,4.176394706e-004
	,4.248657338e-004
	,4.318599199e-004
	,4.386269740e-004
	,4.452161883e-004
	,4.516781600e-004
	,4.580455651e-004
	,4.643349958e-004
	,4.705514464e-004
	,4.766891846e-004
	,4.827256946e-004
	,4.885949703e-004
	,4.940623507e-004
	,4.983121046e-004
	,5.016390491e-004
	,5.052865481e-004
	,5.092165210e-004
	,5.133073705e-004
	,5.174892691e-004
	,5.217207434e-004
	,5.259749722e-004
	,5.302331362e-004
	,5.344809589e-004
	,5.387067735e-004
	,5.429005165e-004
	,5.470536362e-004
	,5.511601082e-004
	,5.552179901e-004
	,5.592294787e-004
	,5.631984616e-004
	,5.671279704e-004
	,5.710194164e-004
	,5.748729293e-004
	,5.786878707e-004
	,5.824632158e-004
	,5.861977903e-004
	,5.898904073e-004
	,5.935399430e-004
	,5.971453763e-004
	,6.007058072e-004
	,6.042204605e-004
	,6.076886783e-004
	,6.111099003e-004
	,6.144836243e-004
	,6.178093311e-004
	,6.210863306e-004
	,6.243134162e-004
	,6.274879900e-004
	,6.306035654e-004
	,6.336424265e-004
	,6.365652249e-004
	,6.393514214e-004
	,6.420458526e-004
	,6.446876298e-004
	,6.472913468e-004
	,6.498614289e-004
	,6.523983031e-004
	,6.548998572e-004
	,6.573612848e-004
	,6.597755796e-004
	,6.621388365e-004
	,6.644575246e-004
	,6.667441891e-004
	,6.690089972e-004
	,6.712576222e-004
	,6.734921898e-004
	,6.757127252e-004
	,6.779180465e-004
	,6.801059984e-004
	,6.822733476e-004
	,6.844160187e-004
	,6.865305792e-004
	,6.886161968e-004
	,6.906745168e-004
	,6.927078918e-004
	,6.947182682e-004
	,6.967070262e-004
	,6.986751398e-004
	,7.006233407e-004
	,7.025522286e-004
	,7.044623389e-004
	,7.063541860e-004
	,7.082282947e-004
	,7.100852284e-004
	,7.119256116e-004
	,7.137501344e-004
	,7.155595025e-004
	,7.173543159e-004
	,7.191349477e-004
	,7.209015161e-004
	,7.226541430e-004
	,7.243929225e-004
	,7.261179026e-004
	,7.278291094e-004
	,7.295265219e-004
	,7.312098056e-004
	,7.328743395e-004
	,7.344978661e-004
	,7.360158388e-004
	,7.374133530e-004
	,7.387866833e-004
	,7.401622944e-004
	,7.415401508e-004
	,7.429172391e-004
	,7.442907904e-004
	,7.456586239e-004
	,7.470190988e-004
	,7.483710475e-004
	,7.497137513e-004
	,7.510469543e-004
	,7.523708701e-004
	,7.536860594e-004
	,7.549931291e-004
	,7.562925638e-004
	,7.575849752e-004
	,7.588714506e-004
	,7.601537054e-004
	,7.614341225e-004
	,-7.417077955e-004
	,-7.224634465e-004
	,-7.031664698e-004
	,-6.836353522e-004
	,-6.637143094e-004
	,-6.434989598e-004
	,-6.230829591e-004
	,-6.025330967e-004
	,-5.820316556e-004
	,-5.617537478e-004
	,-5.417720461e-004
	,-5.221451681e-004
	,-5.029051895e-004
	,-4.840395676e-004
	,-4.655016531e-004
	,-4.472059758e-004
	,-4.290175159e-004
	,-4.107839189e-004
	,-3.924083926e-004
	,-3.738449049e-004
	,-3.551269143e-004
	,-3.363849101e-004
	,-3.177613161e-004
	,-2.993686907e-004
	,-2.812472001e-004
	,-2.633717707e-004
	,-2.456778018e-004
	,-2.280952362e-004
	,-2.105822695e-004
	,-1.930965102e-004
	,-1.755538606e-004
	,-1.578354283e-004
	,-1.398801122e-004
	,-1.217786603e-004
	,-1.036853287e-004
	,-8.572507269e-005
	,-6.798305726e-005
	,-5.050859340e-005
	,-3.333309430e-005
	,-1.648517185e-005
	,3.585227975e-015
	,1.607092254e-005
	,3.166185148e-005
	,4.672337905e-005
	,6.124811410e-005
	,7.525650464e-005
	,8.877754677e-005
	,1.018411333e-004
	,1.144779355e-004
	,1.267219474e-004
	,1.386092349e-004
	,1.501744961e-004
	,1.614497452e-004
	,1.724643817e-004
	,1.832454326e-004
	,1.938177056e-004
	,2.042038740e-004
	,2.144245157e-004
	,2.244981221e-004
	,2.344410695e-004
	,2.442674204e-004
	,2.539888263e-004
	,2.636156509e-004
	,2.731557057e-004
	,2.826136303e-004
	,2.919906071e-004
	,3.012850138e-004
	,3.104964341e-004
	,3.196298948e-004
	,3.286868344e-004
	,3.376431593e-004
	,3.464401239e-004
	,3.550383528e-004
	,3.634789450e-004
	,3.718222865e-004
	,3.800991906e-004
	,3.883146998e-004
	,3.964535638e-004
	,4.044776702e-004
	,4.123260389e-004
	,4.199451841e-004
	,4.273413398e-004
	,4.345708714e-004
	,4.416887571e-004
	,4.487299258e-004
	,4.557139356e-004
	,4.626513777e-004
	,4.695475996e-004
	,4.764045523e-004
	,4.832216563e-004
	,4.899961012e-004
	,4.967226531e-004
	,5.033927243e-004
	,5.099918236e-004
	,5.164924306e-004
	,5.228303832e-004
	,5.287988060e-004
	,5.334642010e-004
	,5.365163167e-004
	,5.401195851e-004
	,5.441704602e-004
	,5.484517558e-004
	,5.528591082e-004
	,5.573367433e-004
	,5.618513763e-004
	,5.663812485e-004
	,5.709109714e-004
	,5.754288725e-004
	,5.799255645e-004
	,5.843933188e-004
	,5.888262452e-004
	,5.932209926e-004
	,5.975766146e-004
	,6.018928613e-004
	,6.061685757e-004
	,6.104013975e-004
	,6.145881486e-004
	,6.187252091e-004
	,6.228087456e-004
	,6.268349193e-004
	,6.308002677e-004
	,6.347023600e-004
	,6.385404592e-004
	,6.423155854e-004
	,6.460297664e-004
	,6.496850657e-004
	,6.532830128e-004
	,6.568245008e-004
	,6.603099190e-004
	,6.637393315e-004
	,6.671126247e-004
	,6.704296114e-004
	,6.736900971e-004
	,6.768939209e-004
	,6.800409763e-004
	,6.831312192e-004
	,6.861646635e-004
	,6.891413652e-004
	,6.920613885e-004
	,6.949247471e-004
	,6.977312925e-004
	,7.004804967e-004
	,7.031709773e-004
	,7.057993321e-004
	,7.083569242e-004
	,7.108214858e-004
	,7.131532360e-004
	,7.153455128e-004
	,7.174386541e-004
	,7.194659937e-004
	,7.214505735e-004
	,7.234061584e-004
	,7.253380595e-004
	,7.272469623e-004
	,7.291316349e-004
	,7.309900666e-004
	,7.328197880e-004
	,7.346179222e-004
	,7.363814769e-004
	,7.381084358e-004
	,7.397991039e-004
	,7.414558050e-004
	,7.430813213e-004
	,7.446780369e-004
	,7.462478793e-004
	,7.477924643e-004
	,7.493131992e-004
	,7.508113150e-004
	,7.522878621e-004
	,7.537437204e-004
	,7.551796384e-004
	,7.565962777e-004
	,7.579942431e-004
	,7.593740999e-004
	,7.607363826e-004
	,7.620816015e-004
	,7.634102467e-004
	,7.647227918e-004
	,7.660196959e-004
	,7.673014066e-004
	,7.685683596e-004
	,7.698209742e-004
	,7.710596284e-004
	,7.722845596e-004
	,7.734956495e-004
	,7.746917639e-004
	,7.758681839e-004
	,7.770058291e-004
	,7.780485293e-004
	,7.790098312e-004
	,7.799610244e-004
	,7.809164137e-004
	,7.818742916e-004
	,7.828301288e-004
	,7.837828360e-004
	,7.847343123e-004
	,7.856834216e-004
	,7.866287063e-004
	,7.875692360e-004
	,7.885044672e-004
	,7.894341121e-004
	,-7.593727388e-004
	,-7.397203149e-004
	,-7.199000479e-004
	,-6.997329641e-004
	,-6.792237494e-004
	,-6.585067650e-004
	,-6.376381209e-004
	,-6.167432407e-004
	,-5.960260958e-004
	,-5.755957638e-004
	,-5.554911932e-004
	,-5.357557986e-004
	,-5.163929826e-004
	,-4.973593553e-004
	,-4.785670237e-004
	,-4.598751823e-004
	,-4.411236534e-004
	,-4.222229515e-004
	,-4.031528538e-004
	,-3.839407828e-004
	,-3.646950969e-004
	,-3.455579049e-004
	,-3.266493415e-004
	,-3.080204049e-004
	,-2.896474811e-004
	,-2.714692449e-004
	,-2.534358229e-004
	,-2.355102626e-004
	,-2.176123046e-004
	,-1.995844510e-004
	,-1.812531029e-004
	,-1.626140304e-004
	,-1.438407658e-004
	,-1.251090207e-004
	,-1.065195946e-004
	,-8.811644029e-005
	,-6.992583720e-005
	,-5.197826865e-005
	,-3.431149868e-005
	,-1.696957957e-005
	,1.508060797e-015
	,1.655662220e-005
	,3.268099474e-005
	,4.837633688e-005
	,6.364927267e-005
	,7.848822937e-005
	,9.286129014e-005
	,1.067524272e-004
	,1.201834273e-004
	,1.331921342e-004
	,1.458152992e-004
	,1.580859226e-004
	,1.700343283e-004
	,1.816890598e-004
	,1.930772641e-004
	,2.042247564e-004
	,2.151559171e-004
	,2.258935106e-004
	,2.364584704e-004
	,2.468696667e-004
	,2.571436339e-004
	,2.672941957e-004
	,2.773318895e-004
	,2.872631340e-004
	,2.970895756e-004
	,3.068099581e-004
	,3.164290798e-004
	,3.259690777e-004
	,3.354625265e-004
	,3.449331500e-004
	,3.543889091e-004
	,3.638250787e-004
	,3.732280512e-004
	,3.825691448e-004
	,3.917930103e-004
	,4.008082894e-004
	,4.095219913e-004
	,4.179133636e-004
	,4.260123648e-004
	,4.338550034e-004
	,4.415046351e-004
	,4.490319536e-004
	,4.564840357e-004
	,4.638860459e-004
	,4.712506618e-004
	,4.785838727e-004
	,4.858878304e-004
	,4.931622468e-004
	,5.004051035e-004
	,5.076130019e-004
	,5.147812750e-004
	,5.219038732e-004
	,5.289729211e-004
	,5.359776326e-004
	,5.429017091e-004
	,5.497164325e-004
	,5.563583700e-004
	,5.626279167e-004
	,5.673910195e-004
	,5.696262085e-004
	,5.730450291e-004
	,5.771247472e-004
	,5.815126648e-004
	,5.860651866e-004
	,5.907087903e-004
	,5.953996795e-004
	,6.001088134e-004
	,6.048152836e-004
	,6.095030792e-004
	,6.141595746e-004
	,6.187752431e-004
	,6.233443599e-004
	,6.278655897e-004
	,6.323406522e-004
	,6.367714986e-004
	,6.411585065e-004
	,6.455003999e-004
	,6.497948729e-004
	,6.540391600e-004
	,6.582303842e-004
	,6.623657343e-004
	,6.664425440e-004
	,6.704583191e-004
	,6.744107386e-004
	,6.782976422e-004
	,6.821170097e-004
	,6.858669350e-004
	,6.895455933e-004
	,6.931512036e-004
	,6.966819891e-004
	,7.001361486e-004
	,7.035118690e-004
	,7.068074291e-004
	,7.100214340e-004
	,7.131531154e-004
	,7.162024725e-004
	,7.191700678e-004
	,7.220566496e-004
	,7.248629968e-004
	,7.275901667e-004
	,7.302399395e-004
	,7.328150697e-004
	,7.353191060e-004
	,7.377558928e-004
	,7.401290630e-004
	,7.424417270e-004
	,7.446963665e-004
	,7.468948395e-004
	,7.490384050e-004
	,7.511277106e-004
	,7.531627292e-004
	,7.551427032e-004
	,7.570663121e-004
	,7.589323869e-004
	,7.607409715e-004
	,7.624931998e-004
	,7.641882441e-004
	,7.658165977e-004
	,7.673585268e-004
	,7.688200421e-004
	,7.702343815e-004
	,7.716198357e-004
	,7.729817292e-004
	,7.743208599e-004
	,7.756366472e-004
	,7.769283928e-004
	,7.781958732e-004
	,7.794393913e-004
	,7.806594980e-004
	,7.818567345e-004
	,7.830315263e-004
	,7.841841942e-004
	,7.853150500e-004
	,7.864244958e-004
	,7.875128733e-004
	,7.885801413e-004
	,7.896257760e-004
	,7.906488204e-004
	,7.916479012e-004
	,7.926212094e-004
	,7.935665132e-004
	,7.944813039e-004
	,7.953631990e-004
	,7.962106445e-004
	,7.970236850e-004
	,7.978043112e-004
	,7.985560858e-004
	,7.992832842e-004
	,7.999900641e-004
	,8.006799628e-004
	,8.013557037e-004
	,8.020191293e-004
	,8.026709898e-004
	,8.033098827e-004
	,8.039270171e-004
	,8.044922872e-004
	,8.050073640e-004
	,8.055169420e-004
	,8.060311615e-004
	,8.065492146e-004
	,8.070695050e-004
	,-7.753215436e-004
	,-7.552057524e-004
	,-7.348709035e-004
	,-7.141839548e-004
	,-6.932274717e-004
	,-6.720938165e-004
	,-6.508657746e-004
	,-6.297369732e-004
	,-6.088752206e-004
	,-5.883272994e-004
	,-5.681175906e-004
	,-5.482716291e-004
	,-5.287626987e-004
	,-5.095104737e-004
	,-4.903775919e-004
	,-4.711986692e-004
	,-4.518792382e-004
	,-4.324079157e-004
	,-4.128043389e-004
	,-3.931356549e-004
	,-3.735333649e-004
	,-3.541306926e-004
	,-3.349988139e-004
	,-3.161248425e-004
	,-2.974610797e-004
	,-2.789724275e-004
	,-2.606063743e-004
	,-2.422364980e-004
	,-2.236379845e-004
	,-2.046135512e-004
	,-1.852449470e-004
	,-1.657922261e-004
	,-1.464486973e-004
	,-1.273034176e-004
	,-1.083841473e-004
	,-8.969133119e-005
	,-7.122005055e-005
	,-5.297703600e-005
	,-3.499179465e-005
	,-1.731442719e-005
	,4.121436346e-016
	,1.691328407e-005
	,3.341702892e-005
	,4.952364825e-005
	,6.525218879e-005
	,8.061927811e-005
	,9.563558048e-005
	,1.103049868e-004
	,1.246157461e-004
	,1.385309469e-004
	,1.520120481e-004
	,1.650627971e-004
	,1.777221346e-004
	,1.900329576e-004
	,2.020319427e-004
	,2.137505488e-004
	,2.252168556e-004
	,2.364564680e-004
	,2.474927286e-004
	,2.583465178e-004
	,2.690357464e-004
	,2.795745022e-004
	,2.899717659e-004
	,3.002299939e-004
	,3.103458571e-004
	,3.203195733e-004
	,3.301734950e-004
	,3.399528851e-004
	,3.496977065e-004
	,3.594236684e-004
	,3.691214131e-004
	,3.787544659e-004
	,3.882515904e-004
	,3.975272268e-004
	,4.065614144e-004
	,4.154144687e-004
	,4.241504954e-004
	,4.328071412e-004
	,4.414036898e-004
	,4.499498796e-004
	,4.584495908e-004
	,4.669032427e-004
	,4.753079272e-004
	,4.836538398e-004
	,4.919211517e-004
	,5.000764489e-004
	,5.080793635e-004
	,5.159130969e-004
	,5.236030499e-004
	,5.311877433e-004
	,5.386926244e-004
	,5.461286324e-004
	,5.534974779e-004
	,5.607951746e-004
	,5.680132663e-004
	,5.751379510e-004
	,5.821458523e-004
	,5.889902749e-004
	,5.955455559e-004
	,6.011825071e-004
	,6.022185855e-004
	,6.048051628e-004
	,6.085866638e-004
	,6.128258625e-004
	,6.172962377e-004
	,6.218939103e-004
	,6.265604417e-004
	,6.312583486e-004
	,6.359611300e-004
	,6.406486265e-004
	,6.453050018e-004
	,6.499185737e-004
	,6.544827528e-004
	,6.589960937e-004
	,6.634598280e-004
	,6.678745861e-004
	,6.722389152e-004
	,6.765496023e-004
	,6.808025416e-004
	,6.849934313e-004
	,6.891181648e-004
	,6.931729670e-004
	,6.971543505e-004
	,7.010589598e-004
	,7.048833637e-004
	,7.086238537e-004
	,7.122763357e-004
	,7.158364947e-004
	,7.193005001e-004
	,7.226663203e-004
	,7.259349623e-004
	,7.291104365e-004
	,7.321982682e-004
	,7.352037939e-004
	,7.381312620e-004
	,7.409837192e-004
	,7.437632524e-004
	,7.464712827e-004
	,7.491088011e-004
	,7.516765271e-004
	,7.541750021e-004
	,7.566046363e-004
	,7.589657187e-004
	,7.612584013e-004
	,7.634826661e-004
	,7.656382804e-004
	,7.677247326e-004
	,7.697410940e-004
	,7.716856769e-004
	,7.735553489e-004
	,7.753445640e-004
	,7.770447418e-004
	,7.786456918e-004
	,7.801410613e-004
	,7.815351951e-004
	,7.828431214e-004
	,7.840829734e-004
	,7.852697019e-004
	,7.864137652e-004
	,7.875222981e-004
	,7.886003961e-004
	,7.896518273e-004
	,7.906793533e-004
	,7.916849219e-004
	,7.926698153e-004
	,7.936347244e-004
	,7.945796745e-004
	,7.955036065e-004
	,7.964030623e-004
	,7.972697146e-004
	,7.980957021e-004
	,7.988894835e-004
	,7.996635595e-004
	,8.004236209e-004
	,8.011717928e-004
	,8.019089762e-004
	,8.026356332e-004
	,8.033520622e-004
	,8.040585083e-004
	,8.047552122e-004
	,8.054424310e-004
	,8.061204474e-004
	,8.067895762e-004
	,8.074501788e-004
	,8.081026915e-004
	,8.087476613e-004
	,8.093856945e-004
	,8.100172381e-004
	,8.106424709e-004
	,8.112614563e-004
	,8.118742706e-004
	,8.124810292e-004
	,8.130818806e-004
	,8.136769981e-004
	,8.142665703e-004
	,8.148507822e-004
	,8.154297754e-004
	,8.160035803e-004
	,8.165720074e-004
	,8.171343933e-004
	,8.176887208e-004
	,-7.899640561e-004
	,-7.694650528e-004
	,-7.486901805e-004
	,-7.275685980e-004
	,-7.062134094e-004
	,-6.847110059e-004
	,-6.632141599e-004
	,-6.419294818e-004
	,-6.209581675e-004
	,-6.003051787e-004
	,-5.799906674e-004
	,-5.600164644e-004
	,-5.403208198e-004
	,-5.207779101e-004
	,-5.012204903e-004
	,-4.815389907e-004
	,-4.617173909e-004
	,-4.417721962e-004
	,-4.217345517e-004
	,-4.016961349e-004
	,-3.817913439e-004
	,-3.621115730e-004
	,-3.426717944e-004
	,-3.234663075e-004
	,-3.044904023e-004
	,-2.856896549e-004
	,-2.669004093e-004
	,-2.478286137e-004
	,-2.282515914e-004
	,-2.082974118e-004
	,-1.882546668e-004
	,-1.683252364e-004
	,-1.486058358e-004
	,-1.291309853e-004
	,-1.099045560e-004
	,-9.091945640e-005
	,-7.217278089e-005
	,-5.367650362e-005
	,-3.545823337e-005
	,-1.755444755e-005
	,2.489152636e-016
	,1.718560697e-005
	,3.399836491e-005
	,5.044335767e-005
	,6.653069163e-005
	,8.227286861e-005
	,9.768615946e-005
	,1.127906230e-004
	,1.276041709e-004
	,1.421375858e-004
	,1.563905186e-004
	,1.703449081e-004
	,1.839577356e-004
	,1.971722263e-004
	,2.099642665e-004
	,2.223652528e-004
	,2.344280578e-004
	,2.461994214e-004
	,2.577158349e-004
	,2.690058257e-004
	,2.800914164e-004
	,2.909879546e-004
	,3.017026972e-004
	,3.122335779e-004
	,3.225736609e-004
	,3.327305443e-004
	,3.427472221e-004
	,3.526812748e-004
	,3.625606070e-004
	,3.723637953e-004
	,3.820243388e-004
	,3.914805699e-004
	,4.007471016e-004
	,4.098849511e-004
	,4.189414553e-004
	,4.279422440e-004
	,4.369007099e-004
	,4.458245639e-004
	,4.547186557e-004
	,4.635859173e-004
	,4.724276549e-004
	,4.812437105e-004
	,4.900326146e-004
	,4.987917296e-004
	,5.075173626e-004
	,5.162048347e-004
	,5.248484913e-004
	,5.334416257e-004
	,5.419762443e-004
	,5.504424815e-004
	,5.588276395e-004
	,5.671157605e-004
	,5.752843104e-004
	,5.833000899e-004
	,5.911218465e-004
	,5.987194181e-004
	,6.060951592e-004
	,6.132700359e-004
	,6.202520993e-004
	,6.270132362e-004
	,6.334305922e-004
	,6.386704148e-004
	,6.367270340e-004
	,6.393057589e-004
	,6.429635010e-004
	,6.470455513e-004
	,6.513433155e-004
	,6.557572710e-004
	,6.602294352e-004
	,6.647213147e-004
	,6.692048874e-004
	,6.736588535e-004
	,6.780679277e-004
	,6.824237406e-004
	,6.867246238e-004
	,6.909721814e-004
	,6.951668294e-004
	,6.993056656e-004
	,7.033826938e-004
	,7.073897860e-004
	,7.113176831e-004
	,7.151574017e-004
	,7.189025136e-004
	,7.225513485e-004
	,7.261068818e-004
	,7.295741204e-004
	,7.329575047e-004
	,7.362598742e-004
	,7.394825669e-004
	,7.426258524e-004
	,7.456892983e-004
	,7.486719556e-004
	,7.515723337e-004
	,7.543881152e-004
	,7.571154786e-004
	,7.597477346e-004
	,7.622727809e-004
	,7.646693207e-004
	,7.669061479e-004
	,7.689587536e-004
	,7.708398022e-004
	,7.725934243e-004
	,7.742608344e-004
	,7.758675396e-004
	,7.774274156e-004
	,7.789479510e-004
	,7.804333341e-004
	,7.818860228e-004
	,7.833075344e-004
	,7.846988519e-004
	,7.860606389e-004
	,7.873933553e-004
	,7.886973188e-004
	,7.899727370e-004
	,7.912197236e-004
	,7.924383087e-004
	,7.936284529e-004
	,7.947900721e-004
	,7.959230828e-004
	,7.970274685e-004
	,7.981033683e-004
	,7.991511766e-004
	,8.001716354e-004
	,8.011658762e-004
	,8.021353638e-004
	,8.030817381e-004
	,8.040066261e-004
	,8.049115045e-004
	,8.057976414e-004
	,8.066660944e-004
	,8.075177324e-004
	,8.083532615e-004
	,8.091732424e-004
	,8.099780995e-004
	,8.107681227e-004
	,8.115434691e-004
	,8.123041677e-004
	,8.130501060e-004
	,8.137809073e-004
	,8.144954577e-004
	,8.151906210e-004
	,8.158604467e-004
	,8.165041243e-004
	,8.171304013e-004
	,8.177460708e-004
	,8.183538858e-004
	,8.189549023e-004
	,8.195495711e-004
	,8.201381141e-004
	,8.207206603e-004
	,8.212973017e-004
	,8.218681178e-004
	,8.224331891e-004
	,8.229926050e-004
	,8.235464728e-004
	,8.240949286e-004
	,8.246381586e-004
	,8.251764375e-004
	,8.257101800e-004
	,8.262399055e-004
	,8.267659590e-004
	,-3.321155249e-006
	,-2.721922446e-006
	,-2.221205758e-006
	,-1.803174862e-006
	,-1.456532805e-006
	,-1.172335415e-006
	,-9.408193454e-007
	,-7.509708309e-007
	,-5.951196827e-007
	,-4.695668661e-007
	,-3.701275936e-007
	,-2.916335761e-007
	,-2.294813235e-007
	,-1.801980550e-007
	,-1.410107612e-007
	,-1.098374541e-007
	,-8.513192168e-008
	,-6.572971997e-008
	,-5.065620260e-008
	,-3.904392918e-008
	,-3.012912976e-008
	,-2.327810522e-008
	,-1.799288569e-008
	,-1.389837598e-008
	,-1.071446861e-008
	,-8.238452614e-009
	,-6.317616087e-009
	,-4.828559135e-009
	,-3.675896273e-009
	,-2.784341735e-009
	,-2.095680562e-009
	,-1.567018860e-009
	,-1.164189523e-009
	,-8.583751894e-010
	,-6.259803768e-010
	,-4.485243986e-010
	,-3.119504481e-010
	,-2.057206768e-010
	,-1.219523938e-010
	,-5.481123423e-011
	,4.438221672e-018
	,4.580132725e-011
	,8.522790279e-011
	,1.203487762e-010
	,1.528181585e-010
	,1.839529946e-010
	,2.147418521e-010
	,2.458296894e-010
	,2.775574385e-010
	,3.102009215e-010
	,3.441323483e-010
	,3.796695966e-010
	,4.169788123e-010
	,4.562236445e-010
	,4.978641267e-010
	,5.426509775e-010
	,5.913675198e-010
	,6.447082406e-010
	,7.032714803e-010
	,7.675405811e-010
	,8.378750651e-010
	,9.147020892e-010
	,9.987744038e-010
	,1.091055252e-009
	,1.192581891e-009
	,1.304577532e-009
	,1.428512738e-009
	,1.566080437e-009
	,1.719228768e-009
	,1.890230411e-009
	,2.081748541e-009
	,2.296869328e-009
	,2.539029370e-009
	,2.811713137e-009
	,3.117998168e-009
	,3.460844519e-009
	,3.846267408e-009
	,4.284302282e-009
	,4.787385369e-009
	,5.369106330e-009
	,6.043094636e-009
	,6.820072617e-009
	,7.703582930e-009
	,8.689647112e-009
	,9.797949970e-009
	,1.107861353e-008
	,1.258210725e-008
	,1.435920679e-008
	,1.647454176e-008
	,1.899977553e-008
	,2.203497835e-008
	,2.570212304e-008
	,3.013975066e-008
	,3.552792006e-008
	,4.209397126e-008
	,5.009355850e-008
	,5.991613035e-008
	,7.201335388e-008
	,8.693676206e-008
	,1.052774550e-007
	,1.276721163e-007
	,1.553083513e-007
	,1.895100736e-007
	,2.317759347e-007
	,2.829028687e-007
	,3.455351227e-007
	,4.198746375e-007
	,5.069700975e-007
	,6.074901744e-007
	,7.296723659e-007
	,8.792977906e-007
	,1.062945719e-006
	,1.288581625e-006
	,1.566025710e-006
	,1.907417446e-006
	,2.327644276e-006
	,2.840216925e-006
	,3.467177439e-006
	,4.235546440e-006
	,5.158401697e-006
	,6.282137680e-006
	,7.652184267e-006
	,9.318087914e-006
	,1.132713631e-005
	,1.361505310e-005
	,1.614043598e-005
	,1.889481619e-005
	,2.194200612e-005
	,2.550165748e-005
	,2.966253299e-005
	,3.451086764e-005
	,4.014034974e-005
	,4.665284503e-005
	,5.415739260e-005
	,6.275980029e-005
	,7.245316682e-005
	,8.335128127e-005
	,9.558259965e-005
	,1.091110214e-004
	,1.239691334e-004
	,1.402567432e-004
	,1.579328207e-004
	,1.767084782e-004
	,1.962592424e-004
	,2.168142331e-004
	,2.375862292e-004
	,2.577173482e-004
	,2.788464996e-004
	,3.014853666e-004
	,3.256579781e-004
	,3.512926507e-004
	,3.783074462e-004
	,4.066249810e-004
	,4.361740323e-004
	,4.668890641e-004
	,4.987103540e-004
	,5.315833244e-004
	,5.654585368e-004
	,6.002920642e-004
	,6.360421447e-004
	,6.726736802e-004
	,7.100986103e-004
	,7.483387770e-004
	,7.873707375e-004
	,8.271696369e-004
	,8.677109739e-004
	,9.089515685e-004
	,9.508910595e-004
	,9.935078881e-004
	,1.036779981e-003
	,1.080684229e-003
	,1.125195968e-003
	,1.170287506e-003
	,1.215925014e-003
	,1.261367290e-003
	,1.307235367e-003
	,1.353498607e-003
	,1.400018646e-003
	,1.446789863e-003
	,1.493782149e-003
	,1.540936004e-003
	,1.588186735e-003
	,1.635463879e-003
	,1.682690747e-003
	,1.729784239e-003
	,1.776655030e-003
	,1.823208178e-003
	,1.869344181e-003
	,1.914954400e-003
	,1.959941646e-003
	,2.004203992e-003
	,2.047642907e-003
	,2.090166467e-003
	,2.131594968e-003
	,2.171350197e-003
	,2.209918043e-003
	,2.247274316e-003
	,2.283414781e-003
	,2.318344713e-003
	,2.352072910e-003
	,2.384207361e-003
	,-8.593019252e-006
	,-7.140256668e-006
	,-5.900588800e-006
	,-4.853391575e-006
	,-3.974776652e-006
	,-3.231348500e-006
	,-2.604239975e-006
	,-2.083900145e-006
	,-1.659927814e-006
	,-1.320658816e-006
	,-1.050729473e-006
	,-8.344870042e-007
	,-6.592696293e-007
	,-5.174194394e-007
	,-4.038028816e-007
	,-3.137156008e-007
	,-2.432767049e-007
	,-1.887439011e-007
	,-1.466217856e-007
	,-1.140137977e-007
	,-8.863701295e-008
	,-6.874654259e-008
	,-5.312084655e-008
	,-4.090970616e-008
	,-3.139079031e-008
	,-2.395971561e-008
	,-1.819801736e-008
	,-1.378749953e-008
	,-1.043765441e-008
	,-7.898818904e-009
	,-5.972826596e-009
	,-4.507960185e-009
	,-3.389531288e-009
	,-2.531052255e-009
	,-1.867306093e-009
	,-1.350127374e-009
	,-9.452233099e-010
	,-6.266668263e-010
	,-3.733468946e-010
	,-1.685923762e-010
	,-4.313089093e-017
	,1.413546261e-010
	,2.618851979e-010
	,3.666696969e-010
	,4.602908733e-010
	,5.468097534e-010
	,6.297546739e-010
	,7.121262912e-010
	,7.963776250e-010
	,8.845180078e-010
	,9.782563423e-010
	,1.079087736e-009
	,1.188300426e-009
	,1.306912620e-009
	,1.435606472e-009
	,1.575130622e-009
	,1.726918038e-009
	,1.892813022e-009
	,2.074554359e-009
	,2.273690711e-009
	,2.491915867e-009
	,2.731291424e-009
	,2.994085479e-009
	,3.282594566e-009
	,3.598785866e-009
	,3.943660987e-009
	,4.316968676e-009
	,4.718785194e-009
	,5.151761133e-009
	,5.620110597e-009
	,6.127092108e-009
	,6.673336731e-009
	,7.255873398e-009
	,7.869278175e-009
	,8.511402571e-009
	,9.189229870e-009
	,9.916400993e-009
	,1.070768950e-008
	,1.157710881e-008
	,1.253847723e-008
	,1.360613197e-008
	,1.479528679e-008
	,1.612330309e-008
	,1.761380012e-008
	,1.929889626e-008
	,2.121820253e-008
	,2.341969324e-008
	,2.596170600e-008
	,2.891415995e-008
	,3.236428389e-008
	,3.641752545e-008
	,4.120217615e-008
	,4.687461242e-008
	,5.362566449e-008
	,6.167078373e-008
	,7.128337337e-008
	,8.275715602e-008
	,9.637581474e-008
	,1.126772638e-007
	,1.323260079e-007
	,1.557593808e-007
	,1.839423587e-007
	,2.179115078e-007
	,2.583783925e-007
	,3.051485099e-007
	,3.587272184e-007
	,4.220793717e-007
	,4.985090988e-007
	,5.916916779e-007
	,7.057010507e-007
	,8.454923176e-007
	,1.017194920e-006
	,1.228402045e-006
	,1.488446455e-006
	,1.806576417e-006
	,2.197629203e-006
	,2.679448053e-006
	,3.271523596e-006
	,3.986613226e-006
	,4.862743901e-006
	,5.936100646e-006
	,7.249352113e-006
	,8.814134010e-006
	,1.062234326e-005
	,1.264814106e-005
	,1.484459209e-005
	,1.734926991e-005
	,2.029869768e-005
	,2.377113686e-005
	,2.784527797e-005
	,3.260697993e-005
	,3.815022712e-005
	,4.457534437e-005
	,5.198145052e-005
	,6.039103808e-005
	,6.989571850e-005
	,8.060939766e-005
	,9.244935491e-005
	,1.055769651e-004
	,1.200445867e-004
	,1.358262136e-004
	,1.527185374e-004
	,1.703300364e-004
	,1.886973867e-004
	,2.070482229e-004
	,2.252135495e-004
	,2.445297751e-004
	,2.653288470e-004
	,2.876195911e-004
	,3.111631894e-004
	,3.360329627e-004
	,3.621666621e-004
	,3.895032847e-004
	,4.179857907e-004
	,4.475044296e-004
	,4.780315091e-004
	,5.095526428e-004
	,5.420258581e-004
	,5.754123556e-004
	,6.096787861e-004
	,6.447942498e-004
	,6.807302333e-004
	,7.174607100e-004
	,7.549617936e-004
	,7.932113667e-004
	,8.321886903e-004
	,8.718739991e-004
	,9.122480891e-004
	,9.532918996e-004
	,9.949860959e-004
	,1.037310656e-003
	,1.080240381e-003
	,1.123756256e-003
	,1.167833994e-003
	,1.212380064e-003
	,1.256620952e-003
	,1.301224340e-003
	,1.346163783e-003
	,1.391417085e-003
	,1.436940092e-003
	,1.482684674e-003
	,1.528597973e-003
	,1.574621701e-003
	,1.620691629e-003
	,1.666737329e-003
	,1.712682213e-003
	,1.758441675e-003
	,1.803926024e-003
	,1.849048343e-003
	,1.893713869e-003
	,1.937826505e-003
	,1.981290763e-003
	,2.023666830e-003
	,2.064977283e-003
	,2.105309635e-003
	,2.144600147e-003
	,2.182810087e-003
	,2.219908593e-003
	,2.255876261e-003
	,2.290706584e-003
	,2.324187845e-003
	,-2.042043400e-005
	,-1.735434354e-005
	,-1.457733670e-005
	,-1.215315829e-005
	,-1.009450251e-005
	,-8.359608312e-006
	,-6.876149794e-006
	,-5.594633701e-006
	,-4.512368841e-006
	,-3.623344296e-006
	,-2.901234954e-006
	,-2.318620799e-006
	,-1.849737086e-006
	,-1.468994583e-006
	,-1.158775797e-006
	,-9.101592701e-007
	,-7.137640284e-007
	,-5.589876889e-007
	,-4.365180949e-007
	,-3.393369608e-007
	,-2.627759154e-007
	,-2.029828329e-007
	,-1.564085719e-007
	,-1.201113377e-007
	,-9.194912824e-008
	,-7.030273069e-008
	,-5.376377542e-008
	,-4.114042100e-008
	,-3.148734792e-008
	,-2.407793698e-008
	,-1.836029460e-008
	,-1.392444816e-008
	,-1.048262170e-008
	,-7.819257594e-009
	,-5.754100296e-009
	,-4.141990875e-009
	,-2.876341483e-009
	,-1.883171491e-009
	,-1.105465785e-009
	,-4.923288998e-010
	,-1.013014542e-017
	,4.064115465e-010
	,7.537337208e-010
	,1.062391864e-009
	,1.347977035e-009
	,1.622509577e-009
	,1.895292170e-009
	,2.173245996e-009
	,2.460904781e-009
	,2.761490416e-009
	,3.079317103e-009
	,3.419877647e-009
	,3.788267698e-009
	,4.188356477e-009
	,4.622650419e-009
	,5.092880346e-009
	,5.600193451e-009
	,6.143345848e-009
	,6.719242334e-009
	,7.327677678e-009
	,7.971398220e-009
	,8.651420386e-009
	,9.365786307e-009
	,1.011352747e-008
	,1.090055114e-008
	,1.173863308e-008
	,1.264016010e-008
	,1.361603441e-008
	,1.467605056e-008
	,1.582958149e-008
	,1.708597633e-008
	,1.845436803e-008
	,1.994273426e-008
	,2.155716765e-008
	,2.330427953e-008
	,2.519620068e-008
	,2.725033938e-008
	,2.948563915e-008
	,3.192117103e-008
	,3.457736500e-008
	,3.747858933e-008
	,4.065385026e-008
	,4.413618511e-008
	,4.796292686e-008
	,5.217652725e-008
	,5.682524879e-008
	,6.196311798e-008
	,6.764801037e-008
	,7.393626314e-008
	,8.087619790e-008
	,8.851780449e-008
	,9.695873899e-008
	,1.063710891e-007
	,1.169881731e-007
	,1.290815683e-007
	,1.429507594e-007
	,1.588975744e-007
	,1.771560376e-007
	,1.977643449e-007
	,2.205979321e-007
	,2.459284790e-007
	,2.748745773e-007
	,3.086896213e-007
	,3.486252845e-007
	,3.958598178e-007
	,4.519821320e-007
	,5.192224466e-007
	,6.001612935e-007
	,6.979586601e-007
	,8.164933907e-007
	,9.600052632e-007
	,1.133283133e-006
	,1.344547181e-006
	,1.603070127e-006
	,1.920230927e-006
	,2.309276729e-006
	,2.780819714e-006
	,3.354601143e-006
	,4.057633228e-006
	,4.917012510e-006
	,5.949339071e-006
	,7.168301429e-006
	,8.557325621e-006
	,1.010755932e-005
	,1.183676708e-005
	,1.387985928e-005
	,1.630811773e-005
	,1.918781198e-005
	,2.259022906e-005
	,2.659407181e-005
	,3.128553910e-005
	,3.675617667e-005
	,4.309505725e-005
	,5.032594371e-005
	,5.855941549e-005
	,6.782280654e-005
	,7.813885915e-005
	,8.964706491e-005
	,1.023872270e-004
	,1.163332545e-004
	,1.312814288e-004
	,1.469117486e-004
	,1.629081331e-004
	,1.788707407e-004
	,1.951115109e-004
	,2.125599760e-004
	,2.314039734e-004
	,2.516277282e-004
	,2.731907834e-004
	,2.959977185e-004
	,3.200373097e-004
	,3.450418646e-004
	,3.711204787e-004
	,3.982648272e-004
	,4.264333483e-004
	,4.555866018e-004
	,4.856872495e-004
	,5.167004156e-004
	,5.485942092e-004
	,5.813388969e-004
	,6.149044027e-004
	,6.492669446e-004
	,6.844040040e-004
	,7.202941014e-004
	,7.569172327e-004
	,7.942545757e-004
	,8.322881813e-004
	,8.709993480e-004
	,9.103714133e-004
	,9.503876927e-004
	,9.910305659e-004
	,1.032281759e-003
	,1.074122062e-003
	,1.116531046e-003
	,1.159486728e-003
	,1.202680313e-003
	,1.245527011e-003
	,1.288748719e-003
	,1.332313646e-003
	,1.376187392e-003
	,1.420332160e-003
	,1.464705958e-003
	,1.509261959e-003
	,1.553948072e-003
	,1.598702829e-003
	,1.643465202e-003
	,1.688168645e-003
	,1.732739544e-003
	,1.777099659e-003
	,1.821166827e-003
	,1.864739058e-003
	,1.907568910e-003
	,1.949772005e-003
	,1.991267859e-003
	,2.031983866e-003
	,2.071854459e-003
	,2.110819590e-003
	,2.148821627e-003
	,2.185814614e-003
	,2.221765512e-003
	,2.256620005e-003
	,-4.276413957e-005
	,-3.742358502e-005
	,-3.239871803e-005
	,-2.776126051e-005
	,-2.362985164e-005
	,-2.002610925e-005
	,-1.686339238e-005
	,-1.404425485e-005
	,-1.157105743e-005
	,-9.477896516e-006
	,-7.738239316e-006
	,-6.303060066e-006
	,-5.119337041e-006
	,-4.128605640e-006
	,-3.295621567e-006
	,-2.610155782e-006
	,-2.056853513e-006
	,-1.615263893e-006
	,-1.266996794e-006
	,-9.937344289e-007
	,-7.793301861e-007
	,-6.102599267e-007
	,-4.756617490e-007
	,-3.688449745e-007
	,-2.853155068e-007
	,-2.204956783e-007
	,-1.700873441e-007
	,-1.306184112e-007
	,-9.968796346e-008
	,-7.564821809e-008
	,-5.711155095e-008
	,-4.290109459e-008
	,-3.204507716e-008
	,-2.373478541e-008
	,-1.734178764e-008
	,-1.242014783e-008
	,-8.628408227e-009
	,-5.686713695e-009
	,-3.374195231e-009
	,-1.521656109e-009
	,-8.876952551e-018
	,1.288599800e-009
	,2.416681662e-009
	,3.436366364e-009
	,4.387731900e-009
	,5.305983022e-009
	,6.220054097e-009
	,7.149437550e-009
	,8.101264252e-009
	,9.069202854e-009
	,1.004236843e-008
	,1.102418012e-008
	,1.203372938e-008
	,1.309426193e-008
	,1.422883549e-008
	,1.545740986e-008
	,1.679563560e-008
	,1.825605524e-008
	,1.985042132e-008
	,2.159206325e-008
	,2.349657055e-008
	,2.558059088e-008
	,2.786003272e-008
	,3.034774438e-008
	,3.305063925e-008
	,3.597033874e-008
	,3.911503659e-008
	,4.251024084e-008
	,4.619137414e-008
	,5.019394903e-008
	,5.454971690e-008
	,5.928537014e-008
	,6.442515440e-008
	,6.999701530e-008
	,7.603298146e-008
	,8.256422972e-008
	,8.961255775e-008
	,9.717867757e-008
	,1.052470708e-007
	,1.138257547e-007
	,1.229702139e-007
	,1.327510089e-007
	,1.432150588e-007
	,1.543611319e-007
	,1.661171072e-007
	,1.783349039e-007
	,1.908622666e-007
	,2.036921501e-007
	,2.170103860e-007
	,2.310813687e-007
	,2.461504128e-007
	,2.624269932e-007
	,2.801010830e-007
	,2.993606530e-007
	,3.204031040e-007
	,3.434406552e-007
	,3.687061783e-007
	,3.964809633e-007
	,4.271584512e-007
	,4.612704333e-007
	,4.994790224e-007
	,5.425997248e-007
	,5.916438966e-007
	,6.478795267e-007
	,7.128644979e-007
	,7.884849812e-007
	,8.770125721e-007
	,9.811938895e-007
	,1.104313574e-006
	,1.250349148e-006
	,1.424431373e-006
	,1.632468949e-006
	,1.880675424e-006
	,2.174573380e-006
	,2.524212659e-006
	,2.942821080e-006
	,3.445891661e-006
	,4.042356383e-006
	,4.749021371e-006
	,5.568913369e-006
	,6.490112783e-006
	,7.510777130e-006
	,8.695018938e-006
	,1.010461854e-005
	,1.179011136e-005
	,1.380315324e-005
	,1.620104440e-005
	,1.904812704e-005
	,2.241604505e-005
	,2.638276064e-005
	,3.102837836e-005
	,3.641070319e-005
	,4.259884940e-005
	,4.965782015e-005
	,5.757401105e-005
	,6.649502930e-005
	,7.648756165e-005
	,8.757585659e-005
	,9.970702003e-005
	,1.126066062e-004
	,1.259231441e-004
	,1.395489672e-004
	,1.530939207e-004
	,1.674805270e-004
	,1.830706114e-004
	,1.998795155e-004
	,2.179341570e-004
	,2.372208252e-004
	,2.577126860e-004
	,2.793814961e-004
	,3.021978784e-004
	,3.261317264e-004
	,3.511525450e-004
	,3.769252326e-004
	,4.035814601e-004
	,4.311731450e-004
	,4.596704413e-004
	,4.890449497e-004
	,5.192694064e-004
	,5.503187806e-004
	,5.821695634e-004
	,6.147996638e-004
	,6.481874659e-004
	,6.823123068e-004
	,7.171569727e-004
	,7.527047028e-004
	,7.889388355e-004
	,8.258431981e-004
	,8.634018929e-004
	,9.015990975e-004
	,9.404188917e-004
	,9.798451097e-004
	,1.019861205e-003
	,1.060450092e-003
	,1.101600913e-003
	,1.143274920e-003
	,1.184855635e-003
	,1.226149903e-003
	,1.267808416e-003
	,1.309804097e-003
	,1.352106921e-003
	,1.394686438e-003
	,1.437506333e-003
	,1.480526038e-003
	,1.523700573e-003
	,1.566980475e-003
	,1.610311800e-003
	,1.653636211e-003
	,1.696863151e-003
	,1.739768861e-003
	,1.782396433e-003
	,1.824673401e-003
	,1.866530832e-003
	,1.907902588e-003
	,1.948722660e-003
	,1.988922816e-003
	,2.028432601e-003
	,2.067181808e-003
	,2.105104248e-003
	,2.142052447e-003
	,2.177693313e-003
	,-8.020827202e-005
	,-7.160454317e-005
	,-6.354990606e-005
	,-5.608288227e-005
	,-4.924375332e-005
	,-4.297278291e-005
	,-3.718759655e-005
	,-3.189276554e-005
	,-2.710021604e-005
	,-2.285986173e-005
	,-1.921030457e-005
	,-1.609715579e-005
	,-1.340141713e-005
	,-1.103045019e-005
	,-8.976071428e-006
	,-7.236601725e-006
	,-5.805797594e-006
	,-4.654036599e-006
	,-3.732912002e-006
	,-2.993202727e-006
	,-2.390650040e-006
	,-1.894026139e-006
	,-1.486431274e-006
	,-1.155332329e-006
	,-8.906564656e-007
	,-6.833127513e-007
	,-5.235453802e-007
	,-4.013856817e-007
	,-3.080506293e-007
	,-2.365025933e-007
	,-1.812877088e-007
	,-1.382958273e-007
	,-1.046795213e-007
	,-7.841709530e-008
	,-5.793169332e-008
	,-4.196582371e-008
	,-2.945051381e-008
	,-1.953167878e-008
	,-1.159770846e-008
	,-5.209143909e-009
	,7.675636573e-018
	,4.335681908e-009
	,8.029658675e-009
	,1.126027141e-008
	,1.418032332e-008
	,1.691275927e-008
	,1.954626581e-008
	,2.215668642e-008
	,2.481980603e-008
	,2.760697006e-008
	,3.058036435e-008
	,3.379534918e-008
	,3.730378924e-008
	,4.115506898e-008
	,4.539441157e-008
	,5.005696503e-008
	,5.515756144e-008
	,6.069222991e-008
	,6.667646122e-008
	,7.316919389e-008
	,8.024326983e-008
	,8.796434508e-008
	,9.638661280e-008
	,1.055415878e-007
	,1.154163474e-007
	,1.259296370e-007
	,1.369461713e-007
	,1.483676950e-007
	,1.602210514e-007
	,1.725884222e-007
	,1.855122989e-007
	,1.989958588e-007
	,2.130671399e-007
	,2.278453413e-007
	,2.435123834e-007
	,2.602353803e-007
	,2.781354353e-007
	,2.972997396e-007
	,3.178107270e-007
	,3.397701150e-007
	,3.632998396e-007
	,3.885267594e-007
	,4.155666445e-007
	,4.445096006e-007
	,4.754189482e-007
	,5.083785102e-007
	,5.435603566e-007
	,5.812115237e-007
	,6.215947591e-007
	,6.649626124e-007
	,7.115673145e-007
	,7.616907187e-007
	,8.156617944e-007
	,8.738482307e-007
	,9.366485138e-007
	,1.004493533e-006
	,1.077851202e-006
	,1.157229249e-006
	,1.243170984e-006
	,1.336237118e-006
	,1.436960290e-006
	,1.545767913e-006
	,1.662944567e-006
	,1.788837524e-006
	,1.924354015e-006
	,2.071120154e-006
	,2.231228348e-006
	,2.407116358e-006
	,2.601831442e-006
	,2.819125217e-006
	,3.063218546e-006
	,3.338141439e-006
	,3.646261986e-006
	,3.986735773e-006
	,4.358580240e-006
	,4.767770107e-006
	,5.230248153e-006
	,5.766049963e-006
	,6.393833989e-006
	,7.130912505e-006
	,8.002981244e-006
	,9.038252457e-006
	,1.026917663e-005
	,1.173341306e-005
	,1.347468402e-005
	,1.553377491e-005
	,1.797029618e-005
	,2.084828936e-005
	,2.422849824e-005
	,2.816884286e-005
	,3.274190141e-005
	,3.797209969e-005
	,4.391124143e-005
	,5.066339932e-005
	,5.829481028e-005
	,6.683797860e-005
	,7.624976505e-005
	,8.634276711e-005
	,9.676633072e-005
	,1.075547952e-004
	,1.184399696e-004
	,1.300070611e-004
	,1.425674149e-004
	,1.562246873e-004
	,1.709952570e-004
	,1.868778426e-004
	,2.038654249e-004
	,2.219482066e-004
	,2.411141331e-004
	,2.613489807e-004
	,2.826363761e-004
	,3.049590694e-004
	,3.282993914e-004
	,3.526376391e-004
	,3.779535449e-004
	,4.038866356e-004
	,4.305039952e-004
	,4.579685685e-004
	,4.862588607e-004
	,5.153540839e-004
	,5.452338439e-004
	,5.758791514e-004
	,6.072717969e-004
	,6.393942228e-004
	,6.722295728e-004
	,7.057600244e-004
	,7.399704943e-004
	,7.748443160e-004
	,8.103678094e-004
	,8.465256100e-004
	,8.833027137e-004
	,9.206842832e-004
	,9.586556852e-004
	,9.972422364e-004
	,1.036402723e-003
	,1.076092523e-003
	,1.116293933e-003
	,1.155952308e-003
	,1.195409563e-003
	,1.235224383e-003
	,1.275375027e-003
	,1.315837105e-003
	,1.356583367e-003
	,1.397583613e-003
	,1.438804663e-003
	,1.480210351e-003
	,1.521760692e-003
	,1.563371357e-003
	,1.604971168e-003
	,1.646508464e-003
	,1.687935737e-003
	,1.729209189e-003
	,1.770284996e-003
	,1.811064277e-003
	,1.851290419e-003
	,1.891089202e-003
	,1.930409958e-003
	,1.969201293e-003
	,2.007409920e-003
	,2.044979022e-003
	,2.081849221e-003
	,-1.376439516e-004
	,-1.251711869e-004
	,-1.132082227e-004
	,-1.019332855e-004
	,-9.146008870e-005
	,-8.185885493e-005
	,-7.311006056e-005
	,-6.501404817e-005
	,-5.732284247e-005
	,-5.004066068e-005
	,-4.332763774e-005
	,-3.726505449e-005
	,-3.184719119e-005
	,-2.707730402e-005
	,-2.290962874e-005
	,-1.919396625e-005
	,-1.587502607e-005
	,-1.302784924e-005
	,-1.064276534e-005
	,-8.639545468e-006
	,-6.959808956e-006
	,-5.578378280e-006
	,-4.457655849e-006
	,-3.544517139e-006
	,-2.799376673e-006
	,-2.200780840e-006
	,-1.727276599e-006
	,-1.352644250e-006
	,-1.053680994e-006
	,-8.145594407e-007
	,-6.256191073e-007
	,-4.779103290e-007
	,-3.618613247e-007
	,-2.699922473e-007
	,-1.978297118e-007
	,-1.417743408e-007
	,-9.840470311e-008
	,-6.476829983e-008
	,-3.838571985e-008
	,-1.729319240e-008
	,1.200806756e-018
	,1.458453955e-008
	,2.724987412e-008
	,3.863018933e-008
	,4.923605846e-008
	,5.945581511e-008
	,6.961792976e-008
	,7.996935304e-008
	,9.060515081e-008
	,1.015331426e-007
	,1.128911317e-007
	,1.249871773e-007
	,1.381116445e-007
	,1.523884462e-007
	,1.677145674e-007
	,1.837777883e-007
	,2.002762328e-007
	,2.171436681e-007
	,2.344883715e-007
	,2.525471732e-007
	,2.716543698e-007
	,2.921393227e-007
	,3.142837606e-007
	,3.383354485e-007
	,3.645257314e-007
	,3.930823986e-007
	,4.242451084e-007
	,4.582621427e-007
	,4.953778711e-007
	,5.358159980e-007
	,5.797429923e-007
	,6.272049395e-007
	,6.780942980e-007
	,7.323003130e-007
	,7.899740514e-007
	,8.515845445e-007
	,9.177591426e-007
	,9.891174694e-007
	,1.066200841e-006
	,1.149445587e-006
	,1.239203138e-006
	,1.335768892e-006
	,1.439330468e-006
	,1.549908098e-006
	,1.667313746e-006
	,1.791108369e-006
	,1.920840363e-006
	,2.056581492e-006
	,2.198971254e-006
	,2.348688543e-006
	,2.506087505e-006
	,2.671029795e-006
	,2.842604497e-006
	,3.018754398e-006
	,3.196314957e-006
	,3.372353853e-006
	,3.546430163e-006
	,3.721106085e-006
	,3.900146054e-006
	,4.086885161e-006
	,4.283802993e-006
	,4.492702454e-006
	,4.714960123e-006
	,4.951686047e-006
	,5.203785239e-006
	,5.471996648e-006
	,5.757040842e-006
	,6.059980239e-006
	,6.382510314e-006
	,6.726902304e-006
	,7.095876966e-006
	,7.492638657e-006
	,7.921058858e-006
	,8.385973025e-006
	,8.893492328e-006
	,9.451404724e-006
	,1.006963449e-005
	,1.076072819e-005
	,1.154030825e-005
	,1.242746861e-005
	,1.344502611e-005
	,1.461970264e-005
	,1.598189325e-005
	,1.756766788e-005
	,1.941647761e-005
	,2.156919364e-005
	,2.406221082e-005
	,2.691988012e-005
	,3.020400055e-005
	,3.398519102e-005
	,3.832751891e-005
	,4.327120048e-005
	,4.884824672e-005
	,5.502358357e-005
	,6.163256766e-005
	,6.857398562e-005
	,7.586757134e-005
	,8.344700356e-005
	,9.163223694e-005
	,1.006166468e-004
	,1.104636252e-004
	,1.212094108e-004
	,1.328834692e-004
	,1.454990297e-004
	,1.590658724e-004
	,1.735910677e-004
	,1.890792080e-004
	,2.055325127e-004
	,2.229508930e-004
	,2.413321106e-004
	,2.606719701e-004
	,2.809643571e-004
	,3.022014302e-004
	,3.243741681e-004
	,3.474725702e-004
	,3.714858108e-004
	,3.964012056e-004
	,4.219928161e-004
	,4.479228670e-004
	,4.746323173e-004
	,5.021110995e-004
	,5.303426497e-004
	,5.593106477e-004
	,5.889990487e-004
	,6.193927218e-004
	,6.504767450e-004
	,6.822364376e-004
	,7.146573275e-004
	,7.477243612e-004
	,7.814225153e-004
	,8.157391882e-004
	,8.506593826e-004
	,8.862369442e-004
	,9.224490179e-004
	,9.592212031e-004
	,9.965398429e-004
	,1.034391997e-003
	,1.072764063e-003
	,1.110306753e-003
	,1.147461644e-003
	,1.184967699e-003
	,1.222806486e-003
	,1.260958068e-003
	,1.299401214e-003
	,1.338125525e-003
	,1.377212367e-003
	,1.416449051e-003
	,1.455800817e-003
	,1.495235245e-003
	,1.534576516e-003
	,1.573783381e-003
	,1.612889067e-003
	,1.651982332e-003
	,1.691141777e-003
	,1.730379520e-003
	,1.769647358e-003
	,1.808865714e-003
	,1.847943156e-003
	,1.886681997e-003
	,1.925101084e-003
	,1.963121977e-003
	,-2.100096406e-004
	,-1.957988840e-004
	,-1.818240872e-004
	,-1.681389777e-004
	,-1.549158473e-004
	,-1.423128715e-004
	,-1.303673649e-004
	,-1.189900613e-004
	,-1.080161114e-004
	,-9.730032795e-005
	,-8.682158511e-005
	,-7.681830816e-005
	,-6.760292796e-005
	,-5.934588418e-005
	,-5.200982675e-005
	,-4.540500472e-005
	,-3.929486221e-005
	,-3.354659181e-005
	,-2.822319018e-005
	,-2.352241748e-005
	,-1.952532520e-005
	,-1.617530057e-005
	,-1.335915197e-005
	,-1.094691330e-005
	,-8.879746434e-006
	,-7.154567898e-006
	,-5.718010518e-006
	,-4.509754575e-006
	,-3.519063525e-006
	,-2.733308626e-006
	,-2.119402626e-006
	,-1.638733805e-006
	,-1.256343375e-006
	,-9.505352660e-007
	,-7.096335513e-007
	,-5.203751062e-007
	,-3.698998373e-007
	,-2.480261807e-007
	,-1.484278986e-007
	,-6.714641273e-008
	,1.362830269e-017
	,5.686735631e-008
	,1.061511471e-007
	,1.495469346e-007
	,1.883838264e-007
	,2.240655452e-007
	,2.581354147e-007
	,2.921297295e-007
	,3.273775674e-007
	,3.649338901e-007
	,4.054515749e-007
	,4.485712709e-007
	,4.932073856e-007
	,5.395946698e-007
	,5.885740508e-007
	,6.415641416e-007
	,6.993708322e-007
	,7.625035225e-007
	,8.315648319e-007
	,9.069946590e-007
	,9.888535887e-007
	,1.077101728e-006
	,1.172287955e-006
	,1.275572037e-006
	,1.388110457e-006
	,1.510694422e-006
	,1.643561532e-006
	,1.786175686e-006
	,1.936749175e-006
	,2.092026629e-006
	,2.248888028e-006
	,2.406797550e-006
	,2.567328259e-006
	,2.731744470e-006
	,2.900008561e-006
	,3.071653621e-006
	,3.247382613e-006
	,3.429517077e-006
	,3.620895137e-006
	,3.823835530e-006
	,4.040142304e-006
	,4.271439318e-006
	,4.518980006e-006
	,4.783665951e-006
	,5.066077141e-006
	,5.366366087e-006
	,5.684132143e-006
	,6.018619377e-006
	,6.369498862e-006
	,6.737583410e-006
	,7.124489256e-006
	,7.531724873e-006
	,7.960217301e-006
	,8.410341234e-006
	,8.882171017e-006
	,9.375944396e-006
	,9.892517071e-006
	,1.043327929e-005
	,1.099969115e-005
	,1.159297858e-005
	,1.221416122e-005
	,1.286434822e-005
	,1.354487536e-005
	,1.425706176e-005
	,1.500180517e-005
	,1.577915801e-005
	,1.658803313e-005
	,1.742636199e-005
	,1.829222141e-005
	,1.918558052e-005
	,2.010888892e-005
	,2.106599576e-005
	,2.206081281e-005
	,2.309682425e-005
	,2.417710423e-005
	,2.530445562e-005
	,2.648151477e-005
	,2.771076331e-005
	,2.899436722e-005
	,3.033376650e-005
	,3.172983634e-005
	,3.318224708e-005
	,3.468956037e-005
	,3.625180804e-005
	,3.787704410e-005
	,3.958616173e-005
	,4.140820105e-005
	,4.337324556e-005
	,4.550996399e-005
	,4.786016064e-005
	,5.048877598e-005
	,5.346933266e-005
	,5.687157276e-005
	,6.075743037e-005
	,6.518169679e-005
	,7.019317117e-005
	,7.583536517e-005
	,8.214667440e-005
	,8.916006604e-005
	,9.690184362e-005
	,1.054004002e-004
	,1.146754730e-004
	,1.247470326e-004
	,1.356315575e-004
	,1.473416068e-004
	,1.598869665e-004
	,1.732747567e-004
	,1.875094041e-004
	,2.025927479e-004
	,2.185342890e-004
	,2.353248553e-004
	,2.529571411e-004
	,2.714221783e-004
	,2.907153249e-004
	,3.108412262e-004
	,3.317885202e-004
	,3.535599989e-004
	,3.761583951e-004
	,3.995846306e-004
	,4.238376591e-004
	,4.484639427e-004
	,4.734294316e-004
	,4.991271783e-004
	,5.255432427e-004
	,5.526629336e-004
	,5.804768549e-004
	,6.089675823e-004
	,6.381144185e-004
	,6.679010606e-004
	,6.983111293e-004
	,7.293287724e-004
	,7.610221895e-004
	,7.934083234e-004
	,8.264342003e-004
	,8.599843875e-004
	,8.940388441e-004
	,9.285748685e-004
	,9.635697110e-004
	,9.989980346e-004
	,1.034815187e-003
	,1.068168521e-003
	,1.101407398e-003
	,1.133591628e-003
	,1.165480426e-003
	,1.198428732e-003
	,1.232518060e-003
	,1.267520754e-003
	,1.303262221e-003
	,1.339622647e-003
	,1.376514499e-003
	,1.413868319e-003
	,1.451624651e-003
	,1.489729311e-003
	,1.528130432e-003
	,1.566776529e-003
	,1.605615152e-003
	,1.644591922e-003
	,1.683649843e-003
	,1.722728840e-003
	,1.761765512e-003
	,1.800693112e-003
	,-2.963570935e-004
	,-2.808315927e-004
	,-2.656902814e-004
	,-2.508359551e-004
	,-2.361575068e-004
	,-2.215117372e-004
	,-2.067661313e-004
	,-1.920370235e-004
	,-1.775794159e-004
	,-1.635426413e-004
	,-1.499123354e-004
	,-1.367519682e-004
	,-1.241993429e-004
	,-1.123221883e-004
	,-1.010963586e-004
	,-9.050695031e-005
	,-8.070974927e-005
	,-7.183070574e-005
	,-6.383812957e-005
	,-5.652396242e-005
	,-4.961404663e-005
	,-4.305235613e-005
	,-3.683384510e-005
	,-3.102760372e-005
	,-2.578543033e-005
	,-2.124177531e-005
	,-1.742572723e-005
	,-1.426633527e-005
	,-1.164868896e-005
	,-9.444679982e-006
	,-7.585566926e-006
	,-6.027002189e-006
	,-4.710767919e-006
	,-3.614340002e-006
	,-2.718827625e-006
	,-1.998369168e-006
	,-1.422783908e-006
	,-9.587045946e-007
	,-5.790530975e-007
	,-2.648328944e-007
	,-1.159220377e-017
	,2.263147985e-007
	,4.232190158e-007
	,5.995048863e-007
	,7.622648538e-007
	,9.156323323e-007
	,1.063709088e-006
	,1.212503949e-006
	,1.367470365e-006
	,1.531839203e-006
	,1.707086540e-006
	,1.894454725e-006
	,2.093415367e-006
	,2.298431173e-006
	,2.504615269e-006
	,2.713267069e-006
	,2.928368341e-006
	,3.152659159e-006
	,3.381414609e-006
	,3.606719080e-006
	,3.840138824e-006
	,4.090830257e-006
	,4.363330289e-006
	,4.660534091e-006
	,4.984110217e-006
	,5.334581465e-006
	,5.711600250e-006
	,6.114470183e-006
	,6.542906339e-006
	,6.997095409e-006
	,7.476851750e-006
	,7.983171324e-006
	,8.519409133e-006
	,9.089553137e-006
	,9.696219150e-006
	,1.033991221e-005
	,1.101931980e-005
	,1.173268512e-005
	,1.247913272e-005
	,1.325818049e-005
	,1.406811082e-005
	,1.490453598e-005
	,1.575987698e-005
	,1.662567315e-005
	,1.749770328e-005
	,1.838029967e-005
	,1.928438511e-005
	,2.022002012e-005
	,2.119384396e-005
	,2.220931961e-005
	,2.326693253e-005
	,2.436390096e-005
	,2.549369995e-005
	,2.664613784e-005
	,2.780917665e-005
	,2.897290566e-005
	,3.013267741e-005
	,3.128790746e-005
	,3.243839199e-005
	,3.358232623e-005
	,3.471721053e-005
	,3.584209738e-005
	,3.695967404e-005
	,3.807706620e-005
	,3.920379666e-005
	,4.034826130e-005
	,4.151614414e-005
	,4.271027359e-005
	,4.393132459e-005
	,4.517968948e-005
	,4.645683129e-005
	,4.776506792e-005
	,4.910656477e-005
	,5.048281184e-005
	,5.189486844e-005
	,5.334390654e-005
	,5.483170000e-005
	,5.636022719e-005
	,5.793144133e-005
	,5.954724224e-005
	,6.120964487e-005
	,6.292097770e-005
	,6.468401401e-005
	,6.650207477e-005
	,6.837912695e-005
	,7.031951081e-005
	,7.232754005e-005
	,7.441228856e-005
	,7.658518487e-005
	,7.885963260e-005
	,8.125234601e-005
	,8.378409779e-005
	,8.648029070e-005
	,8.937129906e-005
	,9.249252010e-005
	,9.588409757e-005
	,9.959054513e-005
	,1.036626054e-004
	,1.081539209e-004
	,1.131211245e-004
	,1.186226977e-004
	,1.247147049e-004
	,1.314478076e-004
	,1.388655130e-004
	,1.470035081e-004
	,1.558897066e-004
	,1.655447068e-004
	,1.759824404e-004
	,1.872108675e-004
	,1.992325600e-004
	,2.120451409e-004
	,2.256415627e-004
	,2.400103819e-004
	,2.551363235e-004
	,2.710043520e-004
	,2.875944722e-004
	,3.050093672e-004
	,3.231456387e-004
	,3.420002503e-004
	,3.615906320e-004
	,3.819331612e-004
	,4.030409114e-004
	,4.249130009e-004
	,4.475450764e-004
	,4.701333881e-004
	,4.931613973e-004
	,5.168208371e-004
	,5.411356342e-004
	,5.661898314e-004
	,5.918466357e-004
	,6.179653976e-004
	,6.445151168e-004
	,6.715236261e-004
	,6.990245789e-004
	,7.271558715e-004
	,7.559361202e-004
	,7.852744743e-004
	,8.153267485e-004
	,8.462038884e-004
	,8.779382910e-004
	,9.105218192e-004
	,9.439275858e-004
	,9.775782399e-004
	,1.009130499e-003
	,1.041228282e-003
	,1.073848914e-003
	,1.106980827e-003
	,1.140602116e-003
	,1.174684215e-003
	,1.209206060e-003
	,1.244146397e-003
	,1.279483477e-003
	,1.315194772e-003
	,1.351256689e-003
	,1.387644289e-003
	,1.424331003e-003
	,1.461288350e-003
	,1.498485653e-003
	,1.535889760e-003
	,1.573464773e-003
	,1.611171805e-003
	,-3.871516391e-004
	,-3.694397164e-004
	,-3.520093419e-004
	,-3.349032864e-004
	,-3.181943974e-004
	,-3.019115330e-004
	,-2.861825639e-004
	,-2.712220831e-004
	,-2.570151151e-004
	,-2.432066060e-004
	,-2.291775169e-004
	,-2.147198443e-004
	,-2.001456520e-004
	,-1.858124606e-004
	,-1.719448838e-004
	,-1.586175697e-004
	,-1.457993806e-004
	,-1.334668735e-004
	,-1.216862967e-004
	,-1.105416728e-004
	,-9.990898055e-005
	,-8.953368101e-005
	,-7.937298167e-005
	,-6.978233558e-005
	,-6.106692488e-005
	,-5.322100477e-005
	,-4.603042396e-005
	,-3.941560870e-005
	,-3.348824632e-005
	,-2.823087421e-005
	,-2.350534460e-005
	,-1.920945984e-005
	,-1.543025967e-005
	,-1.225262298e-005
	,-9.616068190e-006
	,-7.405378136e-006
	,-5.512112028e-006
	,-3.864456645e-006
	,-2.416613485e-006
	,-1.134278869e-006
	,7.988934785e-018
	,9.971169417e-007
	,1.855990076e-006
	,2.587599067e-006
	,3.244512858e-006
	,3.872740919e-006
	,4.504048253e-006
	,5.161010504e-006
	,5.857435272e-006
	,6.592872511e-006
	,7.351353503e-006
	,8.117288608e-006
	,8.882362031e-006
	,9.648237549e-006
	,1.041949540e-005
	,1.120375491e-005
	,1.202318567e-005
	,1.289785135e-005
	,1.383676478e-005
	,1.483905219e-005
	,1.589533550e-005
	,1.699339225e-005
	,1.812196079e-005
	,1.926012997e-005
	,2.040458394e-005
	,2.156475133e-005
	,2.272714449e-005
	,2.391046700e-005
	,2.510864995e-005
	,2.631201450e-005
	,2.751955845e-005
	,2.873136509e-005
	,2.994735385e-005
	,3.116854335e-005
	,3.239862036e-005
	,3.364608267e-005
	,3.492341053e-005
	,3.624319984e-005
	,3.761471944e-005
	,3.904209501e-005
	,4.052516737e-005
	,4.206373767e-005
	,4.365926291e-005
	,4.531242344e-005
	,4.702146868e-005
	,4.878176307e-005
	,5.058608469e-005
	,5.242611342e-005
	,5.429340838e-005
	,5.617907750e-005
	,5.808134090e-005
	,6.000103221e-005
	,6.193308505e-005
	,6.386998172e-005
	,6.580578704e-005
	,6.773834169e-005
	,6.966999046e-005
	,7.160714007e-005
	,7.355877304e-005
	,7.553460931e-005
	,7.754359626e-005
	,7.959311607e-005
	,8.168891681e-005
	,8.383532776e-005
	,8.603541890e-005
	,8.829111189e-005
	,9.060328729e-005
	,9.297179436e-005
	,9.539511122e-005
	,9.786959345e-005
	,1.003907653e-004
	,1.029558219e-004
	,1.055604485e-004
	,1.081977134e-004
	,1.108598434e-004
	,1.135398465e-004
	,1.162319094e-004
	,1.189304741e-004
	,1.216288406e-004
	,1.243182827e-004
	,1.269883467e-004
	,1.296276238e-004
	,1.322256049e-004
	,1.347756318e-004
	,1.372769087e-004
	,1.397340207e-004
	,1.421546548e-004
	,1.445475235e-004
	,1.469217626e-004
	,1.492873029e-004
	,1.516547024e-004
	,1.540327307e-004
	,1.564242789e-004
	,1.588414250e-004
	,1.612990848e-004
	,1.638092231e-004
	,1.663844036e-004
	,1.690387676e-004
	,1.717887202e-004
	,1.746535533e-004
	,1.776561652e-004
	,1.808235114e-004
	,1.841869906e-004
	,1.877823393e-004
	,1.916494965e-004
	,1.958318570e-004
	,2.003752034e-004
	,2.053263180e-004
	,2.107381818e-004
	,2.166560488e-004
	,2.231230862e-004
	,2.301829686e-004
	,2.378772874e-004
	,2.462443517e-004
	,2.553177118e-004
	,2.651249990e-004
	,2.756873675e-004
	,2.870195307e-004
	,2.991301560e-004
	,3.120224425e-004
	,3.256948031e-004
	,3.401613055e-004
	,3.554291436e-004
	,3.714660204e-004
	,3.883500376e-004
	,4.060341889e-004
	,4.245214632e-004
	,4.438475823e-004
	,4.640525185e-004
	,4.844743261e-004
	,5.053867482e-004
	,5.271547486e-004
	,5.497746327e-004
	,5.732400892e-004
	,5.975430753e-004
	,6.226743266e-004
	,6.486236302e-004
	,6.753798301e-004
	,7.029309924e-004
	,7.312643794e-004
	,7.603667857e-004
	,7.902240062e-004
	,8.208327831e-004
	,8.521749696e-004
	,8.842273067e-004
	,9.169722041e-004
	,9.500534692e-004
	,9.803902756e-004
	,1.011275229e-003
	,1.042609805e-003
	,1.074377661e-003
	,1.106563460e-003
	,1.139151544e-003
	,1.172125020e-003
	,1.205505316e-003
	,1.239265588e-003
	,1.273360110e-003
	,1.307768368e-003
	,1.342468586e-003
	,1.377437575e-003
	,1.412650581e-003
	,-4.751532391e-004
	,-4.563906301e-004
	,-4.379091363e-004
	,-4.197564752e-004
	,-4.019784849e-004
	,-3.846234908e-004
	,-3.677284281e-004
	,-3.512957115e-004
	,-3.352827152e-004
	,-3.195668282e-004
	,-3.039772454e-004
	,-2.885326791e-004
	,-2.732060602e-004
	,-2.578891778e-004
	,-2.426033925e-004
	,-2.274900000e-004
	,-2.126986800e-004
	,-1.983387355e-004
	,-1.844596249e-004
	,-1.710598759e-004
	,-1.581322710e-004
	,-1.456825183e-004
	,-1.337414004e-004
	,-1.223934538e-004
	,-1.117363902e-004
	,-1.018221835e-004
	,-9.262467529e-005
	,-8.400551097e-005
	,-7.565601221e-005
	,-6.714911429e-005
	,-5.837118254e-005
	,-4.969376279e-005
	,-4.149306819e-005
	,-3.395972216e-005
	,-2.717907161e-005
	,-2.117387306e-005
	,-1.590144525e-005
	,-1.125484493e-005
	,-7.122288578e-006
	,-3.403193789e-006
	,-5.065157586e-018
	,3.179112852e-006
	,6.208919611e-006
	,9.123615621e-006
	,1.194708472e-005
	,1.471225502e-005
	,1.736067527e-005
	,1.985430209e-005
	,2.231401182e-005
	,2.480168667e-005
	,2.731856426e-005
	,2.986029272e-005
	,3.242785305e-005
	,3.500573258e-005
	,3.759072028e-005
	,4.019201688e-005
	,4.278140615e-005
	,4.534027617e-005
	,4.785680215e-005
	,5.030696313e-005
	,5.274526360e-005
	,5.526875183e-005
	,5.791883548e-005
	,6.069801671e-005
	,6.359328956e-005
	,6.657139369e-005
	,6.953401271e-005
	,7.232710469e-005
	,7.494498802e-005
	,7.748155278e-005
	,7.995134879e-005
	,8.230557234e-005
	,8.447916705e-005
	,8.661200551e-005
	,8.876182124e-005
	,9.093596638e-005
	,9.314594681e-005
	,9.541093951e-005
	,9.774239302e-005
	,1.001413730e-004
	,1.026069816e-004
	,1.051407241e-004
	,1.077480728e-004
	,1.104301345e-004
	,1.131717308e-004
	,1.159361718e-004
	,1.186738486e-004
	,1.213440984e-004
	,1.239322641e-004
	,1.264478442e-004
	,1.289111307e-004
	,1.313411245e-004
	,1.337483044e-004
	,1.361370079e-004
	,1.385329693e-004
	,1.409674967e-004
	,1.434550852e-004
	,1.459998987e-004
	,1.486000727e-004
	,1.512486626e-004
	,1.539346601e-004
	,1.566459992e-004
	,1.593726284e-004
	,1.621060383e-004
	,1.648364367e-004
	,1.675514338e-004
	,1.702382148e-004
	,1.728879202e-004
	,1.754975166e-004
	,1.780673936e-004
	,1.805992510e-004
	,1.830968735e-004
	,1.855662685e-004
	,1.880127993e-004
	,1.904422108e-004
	,1.928664760e-004
	,1.952985402e-004
	,1.977481583e-004
	,2.002226283e-004
	,2.027277851e-004
	,2.052683441e-004
	,2.078477445e-004
	,2.104679889e-004
	,2.131300350e-004
	,2.158350965e-004
	,2.185848251e-004
	,2.213802752e-004
	,2.242216580e-004
	,2.271084937e-004
	,2.300397012e-004
	,2.330135902e-004
	,2.360277997e-004
	,2.390792315e-004
	,2.421640287e-004
	,2.452776432e-004
	,2.484149381e-004
	,2.515695745e-004
	,2.547279716e-004
	,2.578661807e-004
	,2.609943053e-004
	,2.641196858e-004
	,2.672403731e-004
	,2.703539272e-004
	,2.734595585e-004
	,2.765594038e-004
	,2.796588257e-004
	,2.827663390e-004
	,2.858944033e-004
	,2.890600821e-004
	,2.922872189e-004
	,2.956068260e-004
	,2.990576814e-004
	,3.026848100e-004
	,3.065406182e-004
	,3.106838475e-004
	,3.151773919e-004
	,3.200848375e-004
	,3.254701816e-004
	,3.313951883e-004
	,3.379160873e-004
	,3.450845656e-004
	,3.529450069e-004
	,3.615358019e-004
	,3.708894880e-004
	,3.810334198e-004
	,3.919955164e-004
	,4.038043424e-004
	,4.164670652e-004
	,4.299990806e-004
	,4.444145836e-004
	,4.597270868e-004
	,4.759498278e-004
	,4.930961196e-004
	,5.111798521e-004
	,5.302171721e-004
	,5.492612598e-004
	,5.690276406e-004
	,5.896763227e-004
	,6.111990305e-004
	,6.335871743e-004
	,6.568316344e-004
	,6.809224619e-004
	,7.058486036e-004
	,7.315976502e-004
	,7.581554799e-004
	,7.855062499e-004
	,8.136320661e-004
	,8.425131671e-004
	,8.721275512e-004
	,9.024513018e-004
	,9.334589392e-004
	,9.651238696e-004
	,9.950572081e-004
	,1.024200347e-003
	,1.053783253e-003
	,1.083790135e-003
	,1.114202281e-003
	,1.144999879e-003
	,1.176161154e-003
	,1.207662122e-003
	,1.239478329e-003
	,-5.522642158e-004
	,-5.338793033e-004
	,-5.154380264e-004
	,-4.970136084e-004
	,-4.787496708e-004
	,-4.606938977e-004
	,-4.428313901e-004
	,-4.251710088e-004
	,-4.077454476e-004
	,-3.905973425e-004
	,-3.737967798e-004
	,-3.573670561e-004
	,-3.411934819e-004
	,-3.250795770e-004
	,-3.088894765e-004
	,-2.925811982e-004
	,-2.761982601e-004
	,-2.598442109e-004
	,-2.436670157e-004
	,-2.278030484e-004
	,-2.122972270e-004
	,-1.971841317e-004
	,-1.825999388e-004
	,-1.686188210e-004
	,-1.552661180e-004
	,-1.425494951e-004
	,-1.304727379e-004
	,-1.190389536e-004
	,-1.082425954e-004
	,-9.803193543e-005
	,-8.821293522e-005
	,-7.837167356e-005
	,-6.824107626e-005
	,-5.809361103e-005
	,-4.822557469e-005
	,-3.887257415e-005
	,-3.015208919e-005
	,-2.200540370e-005
	,-1.431826867e-005
	,-6.994743959e-006
	,-3.133151916e-018
	,6.644998406e-006
	,1.292961659e-005
	,1.888231709e-005
	,2.458581904e-005
	,3.011082393e-005
	,3.546213601e-005
	,4.067281165e-005
	,4.567685780e-005
	,5.021408957e-005
	,5.439476020e-005
	,5.849332786e-005
	,6.261095543e-005
	,6.677222649e-005
	,7.097148125e-005
	,7.519759873e-005
	,7.942653367e-005
	,8.360213016e-005
	,8.773603001e-005
	,9.188612159e-005
	,9.607332427e-005
	,1.002932013e-004
	,1.045298104e-004
	,1.087619148e-004
	,1.129687835e-004
	,1.171381894e-004
	,1.212694593e-004
	,1.253616020e-004
	,1.293961709e-004
	,1.333166332e-004
	,1.369992060e-004
	,1.403864369e-004
	,1.436332144e-004
	,1.468315123e-004
	,1.499570942e-004
	,1.529917366e-004
	,1.559318366e-004
	,1.586054574e-004
	,1.611205742e-004
	,1.636569223e-004
	,1.662315950e-004
	,1.688420267e-004
	,1.714904449e-004
	,1.741755802e-004
	,1.768885788e-004
	,1.796163567e-004
	,1.823467671e-004
	,1.850723910e-004
	,1.877900384e-004
	,1.904997824e-004
	,1.932065042e-004
	,1.959142311e-004
	,1.986250706e-004
	,2.013483114e-004
	,2.040867676e-004
	,2.068311523e-004
	,2.095562831e-004
	,2.122441450e-004
	,2.149225160e-004
	,2.176154914e-004
	,2.203300195e-004
	,2.230671872e-004
	,2.258262679e-004
	,2.286060918e-004
	,2.314057623e-004
	,2.342245506e-004
	,2.370611847e-004
	,2.399135456e-004
	,2.427787306e-004
	,2.456532425e-004
	,2.485334093e-004
	,2.514161522e-004
	,2.542998825e-004
	,2.571850411e-004
	,2.600742929e-004
	,2.629723458e-004
	,2.658836584e-004
	,2.688083289e-004
	,2.717459442e-004
	,2.747048627e-004
	,2.776941893e-004
	,2.807194290e-004
	,2.837836469e-004
	,2.868880883e-004
	,2.900326259e-004
	,2.932159706e-004
	,2.964355825e-004
	,2.996881609e-004
	,3.029716658e-004
	,3.062854709e-004
	,3.096282378e-004
	,3.129971540e-004
	,3.163879344e-004
	,3.197946694e-004
	,3.232094643e-004
	,3.266220357e-004
	,3.300196280e-004
	,3.333879785e-004
	,3.367144158e-004
	,3.399932455e-004
	,3.432302297e-004
	,3.464413603e-004
	,3.496453916e-004
	,3.528458010e-004
	,3.560343549e-004
	,3.592497370e-004
	,3.625135284e-004
	,3.658332003e-004
	,3.692128552e-004
	,3.726557133e-004
	,3.761651584e-004
	,3.797454228e-004
	,3.834021503e-004
	,3.871429278e-004
	,3.909778276e-004
	,3.949199739e-004
	,3.989861233e-004
	,4.031972301e-004
	,4.075789392e-004
	,4.121619326e-004
	,4.169820357e-004
	,4.220799936e-004
	,4.275008803e-004
	,4.332931528e-004
	,4.395067567e-004
	,4.461916547e-004
	,4.533956802e-004
	,4.611624280e-004
	,4.695291474e-004
	,4.785248341e-004
	,4.881686510e-004
	,4.984734343e-004
	,5.094480167e-004
	,5.210883010e-004
	,5.333908012e-004
	,5.463525424e-004
	,5.599907481e-004
	,5.743171326e-004
	,5.893823786e-004
	,6.052332791e-004
	,6.219317004e-004
	,6.386252939e-004
	,6.560254472e-004
	,6.743179940e-004
	,6.935099768e-004
	,7.135916581e-004
	,7.345202824e-004
	,7.561811199e-004
	,7.783454312e-004
	,8.011318710e-004
	,8.245708898e-004
	,8.486413468e-004
	,8.733903213e-004
	,8.988360681e-004
	,9.249809482e-004
	,9.518188667e-004
	,9.793393789e-004
	,1.007529750e-003
	,1.034992147e-003
	,1.060843479e-003
	,1.087121196e-003
	,-6.006047060e-004
	,-5.835484757e-004
	,-5.664337688e-004
	,-5.492537532e-004
	,-5.320142546e-004
	,-5.147607368e-004
	,-4.975846741e-004
	,-4.805690399e-004
	,-4.637247216e-004
	,-4.469793774e-004
	,-4.301445050e-004
	,-4.130190764e-004
	,-3.955000382e-004
	,-3.775323780e-004
	,-3.592423772e-004
	,-3.409074130e-004
	,-3.227591134e-004
	,-3.049280356e-004
	,-2.874753154e-004
	,-2.704284200e-004
	,-2.537928229e-004
	,-2.375597612e-004
	,-2.217314384e-004
	,-2.063379099e-004
	,-1.914117191e-004
	,-1.769720972e-004
	,-1.630324611e-004
	,-1.495762654e-004
	,-1.365209262e-004
	,-1.237008399e-004
	,-1.108981495e-004
	,-9.803635897e-005
	,-8.531129972e-005
	,-7.299280647e-005
	,-6.122157699e-005
	,-4.999868480e-005
	,-3.922074463e-005
	,-2.878274742e-005
	,-1.875349562e-005
	,-9.173941174e-006
	,1.759674677e-017
	,8.818560847e-006
	,1.732946941e-005
	,2.559526712e-005
	,3.368362831e-005
	,4.165160558e-005
	,4.953513329e-005
	,5.733789916e-005
	,6.499760375e-005
	,7.231545715e-005
	,7.913384777e-005
	,8.560697021e-005
	,9.186754453e-005
	,9.791771398e-005
	,1.037156674e-004
	,1.092400685e-004
	,1.144630903e-004
	,1.194344826e-004
	,1.243334945e-004
	,1.292841840e-004
	,1.343261206e-004
	,1.394633635e-004
	,1.446883494e-004
	,1.499893924e-004
	,1.553521992e-004
	,1.607587741e-004
	,1.661844337e-004
	,1.715930115e-004
	,1.769410395e-004
	,1.821989728e-004
	,1.873139469e-004
	,1.921625545e-004
	,1.965922544e-004
	,2.005433043e-004
	,2.042215044e-004
	,2.078637005e-004
	,2.115393692e-004
	,2.152481524e-004
	,2.189715634e-004
	,2.226856110e-004
	,2.263579130e-004
	,2.298756585e-004
	,2.329522088e-004
	,2.358237254e-004
	,2.387303791e-004
	,2.416787804e-004
	,2.446509656e-004
	,2.476360747e-004
	,2.506295956e-004
	,2.536279992e-004
	,2.566250637e-004
	,2.596072280e-004
	,2.625475580e-004
	,2.654323526e-004
	,2.682906307e-004
	,2.711449216e-004
	,2.739993022e-004
	,2.768492494e-004
	,2.796828289e-004
	,2.824710475e-004
	,2.851690279e-004
	,2.877907199e-004
	,2.903895597e-004
	,2.929885839e-004
	,2.955932140e-004
	,2.982043356e-004
	,3.008216021e-004
	,3.034450473e-004
	,3.060759632e-004
	,3.087152392e-004
	,3.113633986e-004
	,3.140198985e-004
	,3.166841372e-004
	,3.193596227e-004
	,3.220487762e-004
	,3.247518512e-004
	,3.274686686e-004
	,3.301989656e-004
	,3.329421843e-004
	,3.356966610e-004
	,3.384573519e-004
	,3.412140103e-004
	,3.439629646e-004
	,3.467144723e-004
	,3.494766612e-004
	,3.522524668e-004
	,3.550426384e-004
	,3.578467805e-004
	,3.606640293e-004
	,3.634930964e-004
	,3.663317127e-004
	,3.691773544e-004
	,3.720306846e-004
	,3.748957518e-004
	,3.777762228e-004
	,3.806737760e-004
	,3.835887239e-004
	,3.865210597e-004
	,3.894708941e-004
	,3.924385149e-004
	,3.954243855e-004
	,3.984291355e-004
	,4.014534935e-004
	,4.044981452e-004
	,4.075636175e-004
	,4.106503285e-004
	,4.137586447e-004
	,4.168882488e-004
	,4.200353724e-004
	,4.231777073e-004
	,4.262776612e-004
	,4.293702491e-004
	,4.324771491e-004
	,4.356018941e-004
	,4.387454620e-004
	,4.419088168e-004
	,4.450932608e-004
	,4.483004485e-004
	,4.515326615e-004
	,4.547934717e-004
	,4.580884151e-004
	,4.614255117e-004
	,4.648157284e-004
	,4.682733525e-004
	,4.718163441e-004
	,4.754667281e-004
	,4.792509538e-004
	,4.832001131e-004
	,4.873502466e-004
	,4.917423542e-004
	,4.964221683e-004
	,5.014393468e-004
	,5.068464917e-004
	,5.126980114e-004
	,5.190489439e-004
	,5.259534496e-004
	,5.334632733e-004
	,5.416264540e-004
	,5.504856674e-004
	,5.600784411e-004
	,5.704371720e-004
	,5.815896809e-004
	,5.935598794e-004
	,6.063684940e-004
	,6.200339180e-004
	,6.345732666e-004
	,6.500039605e-004
	,6.663057585e-004
	,6.824584823e-004
	,6.994572433e-004
	,7.172949059e-004
	,7.359612807e-004
	,7.554447968e-004
	,7.757326075e-004
	,7.968100491e-004
	,8.186598307e-004
	,8.412612534e-004
	,8.646205182e-004
	,8.887261960e-004
	,9.135427020e-004
	,9.390493802e-004
	,-6.374492528e-004
	,-6.203836846e-004
	,-6.033682255e-004
	,-5.863683277e-004
	,-5.694537853e-004
	,-5.527561980e-004
	,-5.363492089e-004
	,-5.201517803e-004
	,-5.039414738e-004
	,-4.874081097e-004
	,-4.702893836e-004
	,-4.524946845e-004
	,-4.340971341e-004
	,-4.153535675e-004
	,-3.965698214e-004
	,-3.779411599e-004
	,-3.595330243e-004
	,-3.413104738e-004
	,-3.232116751e-004
	,-3.052695710e-004
	,-2.875805958e-004
	,-2.702145833e-004
	,-2.531987640e-004
	,-2.365333322e-004
	,-2.202073853e-004
	,-2.042206401e-004
	,-1.885619772e-004
	,-1.731749735e-004
	,-1.579587289e-004
	,-1.428227995e-004
	,-1.278225464e-004
	,-1.131344991e-004
	,-9.889971951e-005
	,-8.517604513e-005
	,-7.195982098e-005
	,-5.920625593e-005
	,-4.683474921e-005
	,-3.472600546e-005
	,-2.279586495e-005
	,-1.117275952e-005
	,9.346560388e-018
	,1.071539732e-005
	,2.102632608e-005
	,3.100452657e-005
	,4.072444545e-005
	,5.025171596e-005
	,5.962668680e-005
	,6.882488815e-005
	,7.769292526e-005
	,8.608770043e-005
	,9.414254899e-005
	,1.020095778e-004
	,1.097484804e-004
	,1.173842590e-004
	,1.249237807e-004
	,1.323599834e-004
	,1.396767949e-004
	,1.468625429e-004
	,1.539277349e-004
	,1.608980992e-004
	,1.677941352e-004
	,1.746238532e-004
	,1.813838996e-004
	,1.880589714e-004
	,1.946175995e-004
	,2.010098917e-004
	,2.071860409e-004
	,2.131502907e-004
	,2.189711606e-004
	,2.247142478e-004
	,2.304062837e-004
	,2.360281271e-004
	,2.415096633e-004
	,2.467910869e-004
	,2.519122517e-004
	,2.569424172e-004
	,2.619171200e-004
	,2.668473071e-004
	,2.717332715e-004
	,2.765707710e-004
	,2.813485329e-004
	,2.860317102e-004
	,2.905998517e-004
	,2.950661473e-004
	,2.993885600e-004
	,3.034210045e-004
	,3.067892000e-004
	,3.096819517e-004
	,3.126096935e-004
	,3.156304609e-004
	,3.187223400e-004
	,3.218639203e-004
	,3.250397219e-004
	,3.282391970e-004
	,3.314558445e-004
	,3.346861953e-004
	,3.379283665e-004
	,3.411808621e-004
	,3.444417780e-004
	,3.477077844e-004
	,3.509717189e-004
	,3.542162506e-004
	,3.574024396e-004
	,3.604863000e-004
	,3.634851999e-004
	,3.664460966e-004
	,3.693929819e-004
	,3.723336489e-004
	,3.752695814e-004
	,3.781989912e-004
	,3.811161303e-004
	,3.840111225e-004
	,3.868845948e-004
	,3.897542895e-004
	,3.926326012e-004
	,3.955234026e-004
	,3.984273734e-004
	,4.013444317e-004
	,4.042745410e-004
	,4.072177570e-004
	,4.101737366e-004
	,4.131411339e-004
	,4.161164154e-004
	,4.190945469e-004
	,4.220657298e-004
	,4.250152384e-004
	,4.279469305e-004
	,4.308771407e-004
	,4.338153890e-004
	,4.367653185e-004
	,4.397282592e-004
	,4.427044852e-004
	,4.456932680e-004
	,4.486913279e-004
	,4.516904680e-004
	,4.546836520e-004
	,4.576745579e-004
	,4.606723174e-004
	,4.636826214e-004
	,4.667066298e-004
	,4.697436728e-004
	,4.727931534e-004
	,4.758548571e-004
	,4.789288785e-004
	,4.820155857e-004
	,4.851156311e-004
	,4.882299375e-004
	,4.913595665e-004
	,4.945054522e-004
	,4.976682277e-004
	,5.008483422e-004
	,5.040462811e-004
	,5.072625349e-004
	,5.104962105e-004
	,5.137357470e-004
	,5.169234448e-004
	,5.200363102e-004
	,5.231426186e-004
	,5.262616989e-004
	,5.293955151e-004
	,5.325435552e-004
	,5.357051632e-004
	,5.388800758e-004
	,5.420686781e-004
	,5.452722294e-004
	,5.484929914e-004
	,5.517339933e-004
	,5.549985823e-004
	,5.582907386e-004
	,5.616161634e-004
	,5.649831359e-004
	,5.684029940e-004
	,5.718905479e-004
	,5.754645095e-004
	,5.791479260e-004
	,5.829685162e-004
	,5.869590552e-004
	,5.911573426e-004
	,5.956065430e-004
	,6.003544802e-004
	,6.054530578e-004
	,6.109573163e-004
	,6.169236095e-004
	,6.234071013e-004
	,6.304603608e-004
	,6.381333066e-004
	,6.464719273e-004
	,6.555173462e-004
	,6.653064196e-004
	,6.758717514e-004
	,6.872423417e-004
	,6.994444204e-004
	,7.125016596e-004
	,7.264366583e-004
	,7.406478246e-004
	,7.552680161e-004
	,7.707254258e-004
	,7.870157125e-004
	,8.041306727e-004
	,8.220614175e-004
	,8.407982924e-004
	,-6.712397052e-004
	,-6.533965415e-004
	,-6.354723946e-004
	,-6.175862105e-004
	,-5.998982511e-004
	,-5.824840626e-004
	,-5.652522313e-004
	,-5.479943851e-004
	,-5.305366099e-004
	,-5.127731259e-004
	,-4.946753931e-004
	,-4.762996342e-004
	,-4.578221186e-004
	,-4.394413363e-004
	,-4.212378333e-004
	,-4.031587266e-004
	,-3.851230479e-004
	,-3.671289538e-004
	,-3.492362229e-004
	,-3.315014843e-004
	,-3.139553247e-004
	,-2.965871646e-004
	,-2.793197855e-004
	,-2.620138577e-004
	,-2.446127197e-004
	,-2.272165339e-004
	,-2.098773514e-004
	,-1.925943131e-004
	,-1.754604621e-004
	,-1.586297470e-004
	,-1.422163566e-004
	,-1.262748096e-004
	,-1.108165928e-004
	,-9.582499598e-005
	,-8.126282963e-005
	,-6.707520593e-005
	,-5.318987177e-005
	,-3.952032884e-005
	,-2.602222882e-005
	,-1.280738136e-005
	,-1.190550199e-017
	,1.238318399e-005
	,2.437874833e-005
	,3.603620372e-005
	,4.739598895e-005
	,5.845919773e-005
	,6.916782293e-005
	,7.940217548e-005
	,8.908787894e-005
	,9.836170523e-005
	,1.073822346e-004
	,1.162402428e-004
	,1.249846726e-004
	,1.336408940e-004
	,1.422177275e-004
	,1.507108268e-004
	,1.591074992e-004
	,1.673951037e-004
	,1.755677308e-004
	,1.836242014e-004
	,1.915623033e-004
	,1.993764743e-004
	,2.070590228e-004
	,2.146037863e-004
	,2.220119863e-004
	,2.292971725e-004
	,2.364826853e-004
	,2.435924254e-004
	,2.506428432e-004
	,2.576372504e-004
	,2.645581384e-004
	,2.713650642e-004
	,2.780312073e-004
	,2.845765515e-004
	,2.910265598e-004
	,2.973858652e-004
	,3.036516410e-004
	,3.098346395e-004
	,3.159608143e-004
	,3.220544290e-004
	,3.281285549e-004
	,3.341856733e-004
	,3.402199735e-004
	,3.462186055e-004
	,3.521625717e-004
	,3.580279505e-004
	,3.637839479e-004
	,3.693700825e-004
	,3.745754343e-004
	,3.788503192e-004
	,3.825404036e-004
	,3.862783234e-004
	,3.901042141e-004
	,3.939650968e-004
	,3.977954245e-004
	,4.015429219e-004
	,4.052324165e-004
	,4.088890424e-004
	,4.125119740e-004
	,4.160903098e-004
	,4.196140701e-004
	,4.230888907e-004
	,4.265327006e-004
	,4.299536826e-004
	,4.333440716e-004
	,4.366969733e-004
	,4.400165204e-004
	,4.433088969e-004
	,4.465781044e-004
	,4.498267109e-004
	,4.530565762e-004
	,4.562690848e-004
	,4.594652707e-004
	,4.626459433e-004
	,4.658117905e-004
	,4.689634491e-004
	,4.721015503e-004
	,4.752267533e-004
	,4.783397811e-004
	,4.814414544e-004
	,4.845326924e-004
	,4.876144173e-004
	,4.906873758e-004
	,4.937519818e-004
	,4.968081461e-004
	,4.998548307e-004
	,5.028888890e-004
	,5.059032805e-004
	,5.088902498e-004
	,5.118540732e-004
	,5.148068731e-004
	,5.177562773e-004
	,5.207078119e-004
	,5.236655351e-004
	,5.266310264e-004
	,5.296036397e-004
	,5.325795556e-004
	,5.355480897e-004
	,5.384817221e-004
	,5.413483389e-004
	,5.441774690e-004
	,5.470025417e-004
	,5.498367660e-004
	,5.526832638e-004
	,5.555419417e-004
	,5.584120549e-004
	,5.612929221e-004
	,5.641840807e-004
	,5.670853000e-004
	,5.699965709e-004
	,5.729181062e-004
	,5.758503828e-004
	,5.787943302e-004
	,5.817514621e-004
	,5.847222221e-004
	,5.877062290e-004
	,5.907036005e-004
	,5.937144317e-004
	,5.967378547e-004
	,5.997684446e-004
	,6.027754012e-004
	,6.056699872e-004
	,6.084954578e-004
	,6.113270022e-004
	,6.141759169e-004
	,6.170405578e-004
	,6.199182910e-004
	,6.228071530e-004
	,6.257058876e-004
	,6.286138332e-004
	,6.315308653e-004
	,6.344574061e-004
	,6.373944801e-004
	,6.403437762e-004
	,6.433076680e-004
	,6.462891895e-004
	,6.492921070e-004
	,6.523212640e-004
	,6.553831719e-004
	,6.584867279e-004
	,6.616439768e-004
	,6.648700130e-004
	,6.681822014e-004
	,6.716017443e-004
	,6.751550554e-004
	,6.788737805e-004
	,6.827948068e-004
	,6.869599851e-004
	,6.914156939e-004
	,6.962120434e-004
	,7.014016077e-004
	,7.070380298e-004
	,7.131747932e-004
	,7.198639293e-004
	,7.271547822e-004
	,7.350939811e-004
	,7.437242749e-004
	,7.530827857e-004
	,7.632009892e-004
	,7.741072682e-004
	,7.858330067e-004
	,-6.996323253e-004
	,-6.809257394e-004
	,-6.623117509e-004
	,-6.439319702e-004
	,-6.258123678e-004
	,-6.078060179e-004
	,-5.896518797e-004
	,-5.712196187e-004
	,-5.525013446e-004
	,-5.335042822e-004
	,-5.142721118e-004
	,-4.949756738e-004
	,-4.758423283e-004
	,-4.570177201e-004
	,-4.385452890e-004
	,-4.204206585e-004
	,-4.026439822e-004
	,-3.852068973e-004
	,-3.680527408e-004
	,-3.510453237e-004
	,-3.339765940e-004
	,-3.166642656e-004
	,-2.990495096e-004
	,-2.811738323e-004
	,-2.630948344e-004
	,-2.448643756e-004
	,-2.266078874e-004
	,-2.084925571e-004
	,-1.906089998e-004
	,-1.729851574e-004
	,-1.556765625e-004
	,-1.387351892e-004
	,-1.221698956e-004
	,-1.059586664e-004
	,-9.006684614e-005
	,-7.445895702e-005
	,-5.908286099e-005
	,-4.387374451e-005
	,-2.887513211e-005
	,-1.422677441e-005
	,1.451598097e-017
	,1.380538165e-005
	,2.721719019e-005
	,4.026525444e-005
	,5.295767667e-005
	,6.524615747e-005
	,7.702861686e-005
	,8.828696576e-005
	,9.912515442e-005
	,1.096397934e-004
	,1.198785977e-004
	,1.298343601e-004
	,1.394703617e-004
	,1.488443549e-004
	,1.580411636e-004
	,1.671081574e-004
	,1.760717856e-004
	,1.849478811e-004
	,1.937461357e-004
	,2.024732981e-004
	,2.111353037e-004
	,2.197376131e-004
	,2.282844902e-004
	,2.367782156e-004
	,2.452183530e-004
	,2.536007005e-004
	,2.619151910e-004
	,2.701418405e-004
	,2.782461254e-004
	,2.861826747e-004
	,2.939195033e-004
	,3.014679851e-004
	,3.088698994e-004
	,3.161634815e-004
	,3.233748102e-004
	,3.305212467e-004
	,3.376145791e-004
	,3.446629275e-004
	,3.516718882e-004
	,3.586451627e-004
	,3.655848208e-004
	,3.724912943e-004
	,3.793631475e-004
	,3.861966753e-004
	,3.929855180e-004
	,3.997209244e-004
	,4.063933904e-004
	,4.129931843e-004
	,4.195003873e-004
	,4.258461195e-004
	,4.317538221e-004
	,4.364473401e-004
	,4.403961817e-004
	,4.445090249e-004
	,4.488107579e-004
	,4.532288235e-004
	,4.577122210e-004
	,4.622277191e-004
	,4.667529102e-004
	,4.712720208e-004
	,4.757735123e-004
	,4.802486604e-004
	,4.846906722e-004
	,4.890941085e-004
	,4.934544208e-004
	,4.977669503e-004
	,5.020232295e-004
	,5.062004762e-004
	,5.102476065e-004
	,5.141446584e-004
	,5.179482939e-004
	,5.216958024e-004
	,5.253974353e-004
	,5.290536722e-004
	,5.326608353e-004
	,5.362142340e-004
	,5.397142269e-004
	,5.431696375e-004
	,5.465914212e-004
	,5.499868702e-004
	,5.533596294e-004
	,5.567113059e-004
	,5.600425821e-004
	,5.633537647e-004
	,5.666449549e-004
	,5.699160052e-004
	,5.731664126e-004
	,5.763951683e-004
	,5.796004526e-004
	,5.827789524e-004
	,5.859245704e-004
	,5.890277311e-004
	,5.920816233e-004
	,5.950931498e-004
	,5.980753056e-004
	,6.010353075e-004
	,6.039751457e-004
	,6.068945949e-004
	,6.097925061e-004
	,6.126668337e-004
	,6.155138759e-004
	,6.183270084e-004
	,6.210967902e-004
	,6.238170744e-004
	,6.264923188e-004
	,6.291330374e-004
	,6.317482821e-004
	,6.343442128e-004
	,6.369252132e-004
	,6.394949928e-004
	,6.420569856e-004
	,6.446133734e-004
	,6.471650183e-004
	,6.497112762e-004
	,6.522454498e-004
	,6.547694765e-004
	,6.572957770e-004
	,6.598281253e-004
	,6.623682116e-004
	,6.649176484e-004
	,6.674782680e-004
	,6.700518286e-004
	,6.726391611e-004
	,6.752393666e-004
	,6.778488043e-004
	,6.804547226e-004
	,6.829995633e-004
	,6.853957734e-004
	,6.877394711e-004
	,6.900932478e-004
	,6.924646245e-004
	,6.948525704e-004
	,6.972555865e-004
	,6.996728598e-004
	,7.021028423e-004
	,7.045438938e-004
	,7.069953608e-004
	,7.094571654e-004
	,7.119296082e-004
	,7.144133770e-004
	,7.169096403e-004
	,7.194201879e-004
	,7.219476145e-004
	,7.244955769e-004
	,7.270691737e-004
	,7.296754568e-004
	,7.323236692e-004
	,7.350242634e-004
	,7.377880693e-004
	,7.406280098e-004
	,7.435610089e-004
	,7.466085338e-004
	,7.497967506e-004
	,7.531566322e-004
	,7.567239755e-004
	,7.605392203e-004
	,7.646470029e-004
	,7.690954736e-004
	,7.739351700e-004
	,7.792179061e-004
	,7.849953860e-004
	,-7.250061464e-004
	,-7.059770329e-004
	,-6.871035178e-004
	,-6.684007220e-004
	,-6.497448431e-004
	,-6.309226410e-004
	,-6.117852619e-004
	,-5.923595886e-004
	,-5.726827551e-004
	,-5.527717734e-004
	,-5.327420480e-004
	,-5.128049359e-004
	,-4.931013239e-004
	,-4.737126849e-004
	,-4.546862667e-004
	,-4.360503239e-004
	,-4.178134915e-004
	,-3.999610164e-004
	,-3.824467373e-004
	,-3.651752282e-004
	,-3.479871747e-004
	,-3.306852132e-004
	,-3.130721491e-004
	,-2.950209243e-004
	,-2.765791399e-004
	,-2.579262941e-004
	,-2.392878641e-004
	,-2.208388607e-004
	,-2.026638594e-004
	,-1.847825468e-004
	,-1.671750842e-004
	,-1.497928167e-004
	,-1.325653752e-004
	,-1.154292807e-004
	,-9.837343818e-005
	,-8.140517861e-005
	,-6.452521322e-005
	,-4.783370023e-005
	,-3.147427295e-005
	,-1.552324775e-005
	,-2.663204594e-018
	,1.509953736e-005
	,2.977900435e-005
	,4.401725604e-005
	,5.774996238e-005
	,7.091174252e-005
	,8.352028190e-005
	,9.565426148e-005
	,1.073905909e-004
	,1.187912812e-004
	,1.299097007e-004
	,1.407921384e-004
	,1.514763730e-004
	,1.619911472e-004
	,1.723556512e-004
	,1.825772631e-004
	,1.926434424e-004
	,2.025005852e-004
	,2.120695214e-004
	,2.213755535e-004
	,2.305092717e-004
	,2.395265831e-004
	,2.484558283e-004
	,2.573124997e-004
	,2.661050573e-004
	,2.748365062e-004
	,2.835034768e-004
	,2.920937964e-004
	,3.005881305e-004
	,3.089763329e-004
	,3.172716030e-004
	,3.254954341e-004
	,3.336623359e-004
	,3.417797192e-004
	,3.498513828e-004
	,3.578796028e-004
	,3.658660049e-004
	,3.738119650e-004
	,3.817190298e-004
	,3.895895049e-004
	,3.974269110e-004
	,4.052357667e-004
	,4.130205717e-004
	,4.207845234e-004
	,4.285285289e-004
	,4.362505830e-004
	,4.439451986e-004
	,4.516023307e-004
	,4.592046450e-004
	,4.667196424e-004
	,4.740725742e-004
	,4.810257368e-004
	,4.867015228e-004
	,4.909436681e-004
	,4.953619157e-004
	,5.000858862e-004
	,5.049768503e-004
	,5.099471318e-004
	,5.149487332e-004
	,5.199554755e-004
	,5.249505220e-004
	,5.299197578e-004
	,5.348492730e-004
	,5.397247521e-004
	,5.445318278e-004
	,5.492574063e-004
	,5.538919775e-004
	,5.584316948e-004
	,5.628783714e-004
	,5.672377763e-004
	,5.715176117e-004
	,5.757257554e-004
	,5.798691385e-004
	,5.839533104e-004
	,5.879824447e-004
	,5.919595101e-004
	,5.958864158e-004
	,5.997639754e-004
	,6.035914249e-004
	,6.073647019e-004
	,6.110708777e-004
	,6.146747500e-004
	,6.181330224e-004
	,6.214745716e-004
	,6.247538479e-004
	,6.279950763e-004
	,6.312064455e-004
	,6.343906570e-004
	,6.375481767e-004
	,6.406781065e-004
	,6.437786267e-004
	,6.468484121e-004
	,6.498887215e-004
	,6.529022420e-004
	,6.558888460e-004
	,6.588435154e-004
	,6.617607426e-004
	,6.646453877e-004
	,6.675117339e-004
	,6.703708732e-004
	,6.732274406e-004
	,6.760823621e-004
	,6.789348575e-004
	,6.817830819e-004
	,6.846239416e-004
	,6.874524862e-004
	,6.902618451e-004
	,6.930457700e-004
	,6.958029131e-004
	,6.985368585e-004
	,7.012523759e-004
	,7.039532840e-004
	,7.066423343e-004
	,7.093216133e-004
	,7.119928531e-004
	,7.146575547e-004
	,7.173169663e-004
	,7.199720421e-004
	,7.226235007e-004
	,7.252719526e-004
	,7.279179996e-004
	,7.305622402e-004
	,7.332053537e-004
	,7.358482328e-004
	,7.384918143e-004
	,7.411373576e-004
	,7.437869755e-004
	,7.464435321e-004
	,7.491047632e-004
	,7.517595526e-004
	,7.544088420e-004
	,7.570334888e-004
	,7.595332904e-004
	,7.618411613e-004
	,7.641141387e-004
	,7.664082014e-004
	,7.687261829e-004
	,7.710644812e-004
	,7.734196493e-004
	,7.757891984e-004
	,7.781715583e-004
	,7.805658153e-004
	,7.829712583e-004
	,7.853869622e-004
	,7.878118197e-004
	,7.902449261e-004
	,7.926858790e-004
	,7.951348796e-004
	,7.975927563e-004
	,8.000610052e-004
	,8.025418977e-004
	,8.050387152e-004
	,8.075562968e-004
	,8.101010509e-004
	,8.126792067e-004
	,8.152984338e-004
	,8.179693664e-004
	,8.207055495e-004
	,8.235236630e-004
	,8.264438724e-004
	,8.294901932e-004
	,-7.484379873e-004
	,-7.291468283e-004
	,-7.099369991e-004
	,-6.907417679e-004
	,-6.714354772e-004
	,-6.518396675e-004
	,-6.319084887e-004
	,-6.117102476e-004
	,-5.912646398e-004
	,-5.706313506e-004
	,-5.500209500e-004
	,-5.296101672e-004
	,-5.095016037e-004
	,-4.897632171e-004
	,-4.704219214e-004
	,-4.514749388e-004
	,-4.328946550e-004
	,-4.146221763e-004
	,-3.965519685e-004
	,-3.785281305e-004
	,-3.603897271e-004
	,-3.420181192e-004
	,-3.233987494e-004
	,-3.046572331e-004
	,-2.859463635e-004
	,-2.673873481e-004
	,-2.490315573e-004
	,-2.308544035e-004
	,-2.127889184e-004
	,-1.947680156e-004
	,-1.767634337e-004
	,-1.587886625e-004
	,-1.408601112e-004
	,-1.229355745e-004
	,-1.049375593e-004
	,-8.689829591e-005
	,-6.895677624e-005
	,-5.122422588e-005
	,-3.377683034e-005
	,-1.668439024e-005
	,-6.736081413e-018
	,1.623466030e-005
	,3.197480802e-005
	,4.717029923e-005
	,6.179302225e-005
	,7.585870160e-005
	,8.940817013e-005
	,1.024889908e-004
	,1.151500813e-004
	,1.274356484e-004
	,1.393827500e-004
	,1.510260384e-004
	,1.623995963e-004
	,1.735343552e-004
	,1.844584225e-004
	,1.951984009e-004
	,2.057785684e-004
	,2.162195497e-004
	,2.265379972e-004
	,2.367466415e-004
	,2.468537975e-004
	,2.568612937e-004
	,2.667583548e-004
	,2.765073287e-004
	,2.860403233e-004
	,2.953393753e-004
	,3.044689497e-004
	,3.134799535e-004
	,3.223996145e-004
	,3.312532629e-004
	,3.400621506e-004
	,3.488397179e-004
	,3.575936925e-004
	,3.663287058e-004
	,3.750477921e-004
	,3.837531005e-004
	,3.924462030e-004
	,4.011282066e-004
	,4.097997605e-004
	,4.184609960e-004
	,4.271114084e-004
	,4.357496746e-004
	,4.443733992e-004
	,4.529787790e-004
	,4.615601623e-004
	,4.701094407e-004
	,4.786151082e-004
	,4.870606094e-004
	,4.954211251e-004
	,5.036568874e-004
	,5.116983564e-004
	,5.194068601e-004
	,5.264082944e-004
	,5.314380458e-004
	,5.351464582e-004
	,5.393945044e-004
	,5.439995908e-004
	,5.487798696e-004
	,5.536489646e-004
	,5.585631547e-004
	,5.634976581e-004
	,5.684365509e-004
	,5.733682627e-004
	,5.782833881e-004
	,5.831735357e-004
	,5.880308597e-004
	,5.928485058e-004
	,5.976221868e-004
	,6.023516273e-004
	,6.070398352e-004
	,6.116908933e-004
	,6.163082465e-004
	,6.208940226e-004
	,6.254490728e-004
	,6.299733047e-004
	,6.344660321e-004
	,6.389262412e-004
	,6.433527694e-004
	,6.477444173e-004
	,6.521000178e-004
	,6.564184770e-004
	,6.606987983e-004
	,6.649400953e-004
	,6.691415962e-004
	,6.733026416e-004
	,6.774226754e-004
	,6.815012248e-004
	,6.855378644e-004
	,6.895321486e-004
	,6.934834823e-004
	,6.973908500e-004
	,7.012521941e-004
	,7.050628204e-004
	,7.088109000e-004
	,7.124660832e-004
	,7.159774994e-004
	,7.193440919e-004
	,7.226218815e-004
	,7.258435056e-004
	,7.290150752e-004
	,7.321322926e-004
	,7.351959771e-004
	,7.382214195e-004
	,7.412266216e-004
	,7.442208620e-004
	,7.472060713e-004
	,7.501810173e-004
	,7.531442174e-004
	,7.560949042e-004
	,7.590317266e-004
	,7.619516370e-004
	,7.648510266e-004
	,7.677281953e-004
	,7.705842339e-004
	,7.734215640e-004
	,7.762424251e-004
	,7.790484125e-004
	,7.818405848e-004
	,7.846196677e-004
	,7.873862070e-004
	,7.901406621e-004
	,7.928834610e-004
	,7.956150312e-004
	,7.983358175e-004
	,8.010462923e-004
	,8.037469617e-004
	,8.064383704e-004
	,8.091211068e-004
	,8.117958074e-004
	,8.144631601e-004
	,8.171238907e-004
	,8.197787041e-004
	,8.224281144e-004
	,8.250720647e-004
	,8.277092545e-004
	,8.303356683e-004
	,8.329378441e-004
	,8.354609731e-004
	,8.377535593e-004
	,8.398844200e-004
	,8.420200063e-004
	,8.441849146e-004
	,8.463739167e-004
	,8.485789049e-004
	,8.507902062e-004
	,8.530089402e-004
	,8.552379426e-004
	,8.574747397e-004
	,8.597167201e-004
	,8.619621344e-004
	,8.642098724e-004
	,8.664592715e-004
	,8.687100289e-004
	,8.709621727e-004
	,8.732160693e-004
	,8.754724604e-004
	,8.777325288e-004
	,8.799979995e-004
	,8.822712838e-004
	,8.845556633e-004
	,8.868554896e-004
	,-7.693156025e-004
	,-7.497192502e-004
	,-7.301226725e-004
	,-7.104625692e-004
	,-6.905859637e-004
	,-6.703210026e-004
	,-6.497147510e-004
	,-6.288498283e-004
	,-6.077772058e-004
	,-5.866645836e-004
	,-5.657215399e-004
	,-5.450558834e-004
	,-5.247431340e-004
	,-5.048238098e-004
	,-4.852948876e-004
	,-4.661211774e-004
	,-4.472324157e-004
	,-4.285094833e-004
	,-4.097839170e-004
	,-3.909004478e-004
	,-3.717885625e-004
	,-3.524805471e-004
	,-3.331138215e-004
	,-3.138374520e-004
	,-2.947682520e-004
	,-2.759706282e-004
	,-2.574394980e-004
	,-2.391212510e-004
	,-2.209314011e-004
	,-2.027745104e-004
	,-1.845644733e-004
	,-1.661958983e-004
	,-1.475515404e-004
	,-1.286532919e-004
	,-1.096832488e-004
	,-9.080636582e-005
	,-7.211094920e-005
	,-5.364248552e-005
	,-3.543936746e-005
	,-1.754345619e-005
	,9.868724081e-018
	,1.713090943e-005
	,3.377327984e-005
	,4.986560215e-005
	,6.538605401e-005
	,8.034398552e-005
	,9.476900282e-005
	,1.087014935e-004
	,1.221831949e-004
	,1.352533479e-004
	,1.479479396e-004
	,1.603002210e-004
	,1.723428569e-004
	,1.841097397e-004
	,1.956344669e-004
	,2.069478431e-004
	,2.180770521e-004
	,2.290458615e-004
	,2.398749490e-004
	,2.505820869e-004
	,2.611820161e-004
	,2.716862333e-004
	,2.821041733e-004
	,2.924415343e-004
	,3.026995496e-004
	,3.128771807e-004
	,3.229786249e-004
	,3.330180898e-004
	,3.430053766e-004
	,3.529231463e-004
	,3.627138340e-004
	,3.723122511e-004
	,3.817347952e-004
	,3.910567025e-004
	,4.003331938e-004
	,4.095918042e-004
	,4.188454126e-004
	,4.280997294e-004
	,4.373563856e-004
	,4.466140268e-004
	,4.558684257e-004
	,4.651118726e-004
	,4.743316540e-004
	,4.835069582e-004
	,4.926030457e-004
	,5.015624490e-004
	,5.103023698e-004
	,5.187482251e-004
	,5.268966662e-004
	,5.348075427e-004
	,5.425341972e-004
	,5.500831028e-004
	,5.573733871e-004
	,5.639976937e-004
	,5.681036947e-004
	,5.713921864e-004
	,5.756346099e-004
	,5.803483927e-004
	,5.853097244e-004
	,5.904143832e-004
	,5.956062711e-004
	,6.008517611e-004
	,6.061288048e-004
	,6.114216856e-004
	,6.167182721e-004
	,6.220086136e-004
	,6.272846690e-004
	,6.325412311e-004
	,6.377769077e-004
	,6.429928653e-004
	,6.481899741e-004
	,6.533673093e-004
	,6.585223718e-004
	,6.636517512e-004
	,6.687515804e-004
	,6.738177468e-004
	,6.788459856e-004
	,6.838320104e-004
	,6.887718524e-004
	,6.936625048e-004
	,6.985026605e-004
	,7.032929578e-004
	,7.080353763e-004
	,7.127322068e-004
	,7.173852878e-004
	,7.219957427e-004
	,7.265640441e-004
	,7.310901897e-004
	,7.355738733e-004
	,7.400146162e-004
	,7.444118566e-004
	,7.487650088e-004
	,7.530734968e-004
	,7.573367719e-004
	,7.615543141e-004
	,7.657256192e-004
	,7.698501677e-004
	,7.739273688e-004
	,7.779564636e-004
	,7.819363647e-004
	,7.858653890e-004
	,7.897408289e-004
	,7.935583292e-004
	,7.973112521e-004
	,8.009908132e-004
	,8.045879150e-004
	,8.080935336e-004
	,8.114881881e-004
	,8.147344049e-004
	,8.178417244e-004
	,8.208775080e-004
	,8.238822344e-004
	,8.268681388e-004
	,8.298366975e-004
	,8.327855876e-004
	,8.357115167e-004
	,8.386120644e-004
	,8.414865649e-004
	,8.443356773e-004
	,8.471604775e-004
	,8.499619666e-004
	,8.527411157e-004
	,8.554991751e-004
	,8.582376875e-004
	,8.609579784e-004
	,8.636608314e-004
	,8.663466227e-004
	,8.690155321e-004
	,8.716676447e-004
	,8.743029704e-004
	,8.769214560e-004
	,8.795230190e-004
	,8.821075878e-004
	,8.846751219e-004
	,8.872256084e-004
	,8.897590370e-004
	,8.922753518e-004
	,8.947743624e-004
	,8.972555665e-004
	,8.997177410e-004
	,9.021578286e-004
	,9.045671872e-004
	,9.069151117e-004
	,9.090797745e-004
	,9.109668772e-004
	,9.128084155e-004
	,9.146860774e-004
	,9.165954286e-004
	,9.185263272e-004
	,9.204710144e-004
	,9.224239675e-004
	,9.243811478e-004
	,9.263394801e-004
	,9.282965645e-004
	,9.302505189e-004
	,9.321998704e-004
	,9.341434500e-004
	,9.360802010e-004
	,9.380083328e-004
	,9.399230237e-004
	,9.418261439e-004
	,-7.878746769e-004
	,-7.679492675e-004
	,-7.479698751e-004
	,-7.278299958e-004
	,-7.073237159e-004
	,-6.864024323e-004
	,-6.652113262e-004
	,-6.438199431e-004
	,-6.223223617e-004
	,-6.009287373e-004
	,-5.797886123e-004
	,-5.589698031e-004
	,-5.385278353e-004
	,-5.184743124e-004
	,-4.987767057e-004
	,-4.793626188e-004
	,-4.601091147e-004
	,-4.408419518e-004
	,-4.214062014e-004
	,-4.017561084e-004
	,-3.819355078e-004
	,-3.620560854e-004
	,-3.422613568e-004
	,-3.226711104e-004
	,-3.033630354e-004
	,-2.843436182e-004
	,-2.655615957e-004
	,-2.469313066e-004
	,-2.283586546e-004
	,-2.097293720e-004
	,-1.908619740e-004
	,-1.716252232e-004
	,-1.521289813e-004
	,-1.325741814e-004
	,-1.130752423e-004
	,-9.368076192e-005
	,-7.443354215e-005
	,-5.538468646e-005
	,-3.658940925e-005
	,-1.810780501e-005
	,7.210556764e-016
	,1.768886294e-005
	,3.493823728e-005
	,5.174156648e-005
	,6.808835921e-005
	,8.395178423e-005
	,9.929598966e-005
	,1.141170398e-004
	,1.284455175e-004
	,1.423184853e-004
	,1.557706115e-004
	,1.688373382e-004
	,1.815564730e-004
	,1.939653458e-004
	,2.060986261e-004
	,2.179880410e-004
	,2.296625679e-004
	,2.411485005e-004
	,2.524693496e-004
	,2.636455985e-004
	,2.746942647e-004
	,2.856281434e-004
	,2.964546834e-004
	,3.071753128e-004
	,3.177892518e-004
	,3.283078144e-004
	,3.387662953e-004
	,3.492073923e-004
	,3.596590468e-004
	,3.701329852e-004
	,3.806312499e-004
	,3.911509747e-004
	,4.016885371e-004
	,4.122366684e-004
	,4.227817930e-004
	,4.332992174e-004
	,4.437436863e-004
	,4.540432079e-004
	,4.641315577e-004
	,4.740070080e-004
	,4.836967511e-004
	,4.931824043e-004
	,5.023996230e-004
	,5.113157584e-004
	,5.199856152e-004
	,5.284935778e-004
	,5.368978335e-004
	,5.452278444e-004
	,5.534953284e-004
	,5.617012842e-004
	,5.698379746e-004
	,5.778855452e-004
	,5.857972523e-004
	,5.934391507e-004
	,6.001835500e-004
	,6.027792464e-004
	,6.058419997e-004
	,6.102379665e-004
	,6.151834308e-004
	,6.204191172e-004
	,6.258269498e-004
	,6.313416309e-004
	,6.369220799e-004
	,6.425397549e-004
	,6.481731479e-004
	,6.538051635e-004
	,6.594224868e-004
	,6.650168103e-004
	,6.705865659e-004
	,6.761357905e-004
	,6.816696711e-004
	,6.871910679e-004
	,6.927000356e-004
	,6.981947682e-004
	,7.036725343e-004
	,7.091302531e-004
	,7.145647876e-004
	,7.199730769e-004
	,7.253521873e-004
	,7.306993235e-004
	,7.360118214e-004
	,7.412871324e-004
	,7.465228015e-004
	,7.517164428e-004
	,7.568657101e-004
	,7.619682647e-004
	,7.670217419e-004
	,7.720237257e-004
	,7.769717554e-004
	,7.818634097e-004
	,7.866965274e-004
	,7.914695826e-004
	,7.961820808e-004
	,8.008346840e-004
	,8.054288812e-004
	,8.099663868e-004
	,8.144486305e-004
	,8.188765216e-004
	,8.232504308e-004
	,8.275702648e-004
	,8.318355439e-004
	,8.360454415e-004
	,8.401987715e-004
	,8.442939260e-004
	,8.483287830e-004
	,8.523006649e-004
	,8.562065274e-004
	,8.600436297e-004
	,8.638106742e-004
	,8.675086878e-004
	,8.711407259e-004
	,8.747105984e-004
	,8.782216874e-004
	,8.816764014e-004
	,8.850760739e-004
	,8.884209509e-004
	,8.917100174e-004
	,8.949404294e-004
	,8.981060429e-004
	,9.011936455e-004
	,9.041763996e-004
	,9.070273793e-004
	,9.097684477e-004
	,9.124433980e-004
	,9.150754902e-004
	,9.176736530e-004
	,9.202412789e-004
	,9.227796596e-004
	,9.252892308e-004
	,9.277700617e-004
	,9.302220660e-004
	,9.326451063e-004
	,9.350390642e-004
	,9.374039139e-004
	,9.397398261e-004
	,9.420472828e-004
	,9.443270349e-004
	,9.465796365e-004
	,9.488049579e-004
	,9.510023721e-004
	,9.531711851e-004
	,9.553108057e-004
	,9.574207173e-004
	,9.595003617e-004
	,9.615489305e-004
	,9.635649241e-004
	,9.655448967e-004
	,9.674789000e-004
	,9.693292191e-004
	,9.709566727e-004
	,9.723560870e-004
	,9.737604256e-004
	,9.752036297e-004
	,9.766723007e-004
	,9.781551478e-004
	,9.796447173e-004
	,9.811360671e-004
	,9.826255922e-004
	,9.841105759e-004
	,9.855900410e-004
	,9.870630241e-004
	,-8.047554496e-004
	,-7.844492859e-004
	,-7.640060443e-004
	,-7.432985869e-004
	,-7.221863300e-004
	,-7.007497229e-004
	,-6.791021680e-004
	,-6.572981380e-004
	,-6.355032936e-004
	,-6.139195249e-004
	,-5.926347971e-004
	,-5.716951059e-004
	,-5.511346862e-004
	,-5.309368298e-004
	,-5.110368426e-004
	,-4.913177153e-004
	,-4.716069762e-004
	,-4.517420466e-004
	,-4.316755147e-004
	,-4.114514551e-004
	,-3.911509687e-004
	,-3.708978739e-004
	,-3.508209030e-004
	,-3.310172637e-004
	,-3.115134776e-004
	,-2.922663408e-004
	,-2.731963109e-004
	,-2.542113376e-004
	,-2.351566019e-004
	,-2.157738190e-004
	,-1.959168229e-004
	,-1.757462529e-004
	,-1.554963139e-004
	,-1.353215379e-004
	,-1.153093792e-004
	,-9.549507196e-005
	,-7.588557663e-005
	,-5.648906561e-005
	,-3.733716809e-005
	,-1.848729208e-005
	,-9.384849784e-016
	,1.808483834e-005
	,3.575064711e-005
	,5.299771756e-005
	,6.984151128e-005
	,8.630359370e-005
	,1.023980955e-004
	,1.181192629e-004
	,1.334281621e-004
	,1.482599965e-004
	,1.625835322e-004
	,1.764334950e-004
	,1.898677857e-004
	,2.029376416e-004
	,2.156853909e-004
	,2.281475684e-004
	,2.403568469e-004
	,2.523427163e-004
	,2.641314254e-004
	,2.757454244e-004
	,2.872022904e-004
	,2.985130355e-004
	,3.096803489e-004
	,3.207006798e-004
	,3.315798661e-004
	,3.423573765e-004
	,3.530970280e-004
	,3.638494640e-004
	,3.746399474e-004
	,3.854774611e-004
	,3.963634746e-004
	,4.072960765e-004
	,4.182712621e-004
	,4.292827303e-004
	,4.403205271e-004
	,4.513679641e-004
	,4.623949479e-004
	,4.733441437e-004
	,4.841118679e-004
	,4.945700220e-004
	,5.046844216e-004
	,5.145427227e-004
	,5.242313371e-004
	,5.337824066e-004
	,5.431842704e-004
	,5.524050115e-004
	,5.614346361e-004
	,5.703069594e-004
	,5.790677912e-004
	,5.877469028e-004
	,5.963559415e-004
	,6.048924154e-004
	,6.133392083e-004
	,6.216532570e-004
	,6.297159962e-004
	,6.370046665e-004
	,6.381155135e-004
	,6.402706300e-004
	,6.445012378e-004
	,6.494442963e-004
	,6.547530629e-004
	,6.602793366e-004
	,6.659431046e-004
	,6.716944053e-004
	,6.774984073e-004
	,6.833286107e-004
	,6.891640730e-004
	,6.949897964e-004
	,7.007991622e-004
	,7.065942708e-004
	,7.123810552e-004
	,7.181633876e-004
	,7.239410850e-004
	,7.297109737e-004
	,7.354685217e-004
	,7.412089986e-004
	,7.469280868e-004
	,7.526220942e-004
	,7.582879211e-004
	,7.639229154e-004
	,7.695247128e-004
	,7.750911138e-004
	,7.806200065e-004
	,7.861093267e-004
	,7.915570403e-004
	,7.969611387e-004
	,8.023196394e-004
	,8.076305891e-004
	,8.128920672e-004
	,8.181021884e-004
	,8.232591055e-004
	,8.283610107e-004
	,8.334061349e-004
	,8.383927464e-004
	,8.433191472e-004
	,8.481836664e-004
	,8.529846515e-004
	,8.577204573e-004
	,8.623894330e-004
	,8.669899126e-004
	,8.715202155e-004
	,8.759786744e-004
	,8.803637094e-004
	,8.846739560e-004
	,8.889084131e-004
	,8.930665144e-004
	,8.971480292e-004
	,9.011528277e-004
	,9.050806821e-004
	,9.089312752e-004
	,9.127044255e-004
	,9.164003592e-004
	,9.200198030e-004
	,9.235638158e-004
	,9.270334795e-004
	,9.304296298e-004
	,9.337527191e-004
	,9.370028078e-004
	,9.401796508e-004
	,9.432828572e-004
	,9.463121073e-004
	,9.492673918e-004
	,9.521492104e-004
	,9.549586639e-004
	,9.576974191e-004
	,9.603675782e-004
	,9.629714893e-004
	,9.655115076e-004
	,9.679896994e-004
	,9.704074461e-004
	,9.727647446e-004
	,9.750585752e-004
	,9.772792921e-004
	,9.794102477e-004
	,9.814516400e-004
	,9.834297936e-004
	,9.853652669e-004
	,9.872668268e-004
	,9.891379550e-004
	,9.909801673e-004
	,9.927942237e-004
	,9.945805842e-004
	,9.963395951e-004
	,9.980715727e-004
	,9.997768434e-004
	,1.001455771e-003
	,1.003108790e-003
	,1.004736462e-003
	,1.006339551e-003
	,1.007918989e-003
	,1.009475406e-003
	,1.011008177e-003
	,1.012514706e-003
	,1.013988677e-003
	,1.015410334e-003
	,1.016696700e-003
	,1.017739362e-003
	,1.018750525e-003
	,1.019805556e-003
	,1.020889414e-003
	,1.021988546e-003
	,-8.202776532e-004
	,-7.995306041e-004
	,-7.786260546e-004
	,-7.574211353e-004
	,-7.358315549e-004
	,-7.139744744e-004
	,-6.919253858e-004
	,-6.697925430e-004
	,-6.477895413e-004
	,-6.260658514e-004
	,-6.046613594e-004
	,-5.836104620e-004
	,-5.629240558e-004
	,-5.425555807e-004
	,-5.224016648e-004
	,-5.022984186e-004
	,-4.820722339e-004
	,-4.616558689e-004
	,-4.410861617e-004
	,-4.204280539e-004
	,-3.997694565e-004
	,-3.792373344e-004
	,-3.589493742e-004
	,-3.389601801e-004
	,-3.192446953e-004
	,-2.997391877e-004
	,-2.803551786e-004
	,-2.608991924e-004
	,-2.410352380e-004
	,-2.205765118e-004
	,-1.997265769e-004
	,-1.787882649e-004
	,-1.579614430e-004
	,-1.373416599e-004
	,-1.169596037e-004
	,-9.681545927e-005
	,-7.690434692e-005
	,-5.723546689e-005
	,-3.783797999e-005
	,-1.874901436e-005
	,4.183573825e-016
	,1.838386682e-005
	,3.638245409e-005
	,5.399064506e-005
	,7.122061639e-005
	,8.809226111e-005
	,1.046249544e-004
	,1.208327279e-004
	,1.367222902e-004
	,1.522941207e-004
	,1.675382224e-004
	,1.824186539e-004
	,1.968697104e-004
	,2.108421662e-004
	,2.243571285e-004
	,2.374784095e-004
	,2.502672216e-004
	,2.627713070e-004
	,2.750275462e-004
	,2.870642316e-004
	,2.989010490e-004
	,3.105473241e-004
	,3.220009912e-004
	,3.332574608e-004
	,3.443402129e-004
	,3.553223467e-004
	,3.662884245e-004
	,3.772915874e-004
	,3.883540515e-004
	,3.994816842e-004
	,4.106729403e-004
	,4.219219792e-004
	,4.332183068e-004
	,4.445433575e-004
	,4.558620752e-004
	,4.671060266e-004
	,4.781592374e-004
	,4.889163812e-004
	,4.994001758e-004
	,5.097128728e-004
	,5.199303455e-004
	,5.300901404e-004
	,5.402085022e-004
	,5.502916626e-004
	,5.603412796e-004
	,5.703567682e-004
	,5.803359487e-004
	,5.902747677e-004
	,6.001664320e-004
	,6.099997869e-004
	,6.197565501e-004
	,6.294079066e-004
	,6.389085091e-004
	,6.481973457e-004
	,6.572185970e-004
	,6.659251815e-004
	,6.741588605e-004
	,6.802064580e-004
	,6.759643613e-004
	,6.792680038e-004
	,6.838209680e-004
	,6.889259726e-004
	,6.943429022e-004
	,6.999537007e-004
	,7.056881510e-004
	,7.114984836e-004
	,7.173489078e-004
	,7.232121513e-004
	,7.290710769e-004
	,7.349220405e-004
	,7.407726903e-004
	,7.466328034e-004
	,7.525070203e-004
	,7.583940277e-004
	,7.642888305e-004
	,7.701848824e-004
	,7.760753107e-004
	,7.819534701e-004
	,7.878131393e-004
	,7.936485609e-004
	,7.994544261e-004
	,8.052258581e-004
	,8.109584154e-004
	,8.166481160e-004
	,8.222914656e-004
	,8.278854645e-004
	,8.334275681e-004
	,8.389156014e-004
	,8.443476469e-004
	,8.497219342e-004
	,8.550367539e-004
	,8.602904020e-004
	,8.654811496e-004
	,8.706072323e-004
	,8.756668474e-004
	,8.806581561e-004
	,8.855792842e-004
	,8.904283191e-004
	,8.952033014e-004
	,8.999022074e-004
	,9.045229214e-004
	,9.090631944e-004
	,9.135205889e-004
	,9.178924124e-004
	,9.221756562e-004
	,9.263669801e-004
	,9.304628253e-004
	,9.344597769e-004
	,9.383552424e-004
	,9.421482835e-004
	,9.458401215e-004
	,9.494338899e-004
	,9.529337652e-004
	,9.563440545e-004
	,9.596686574e-004
	,9.629109222e-004
	,9.660737293e-004
	,9.691596465e-004
	,9.721710555e-004
	,9.751101944e-004
	,9.779791152e-004
	,9.807796061e-004
	,9.835131397e-004
	,9.861808638e-004
	,9.887836242e-004
	,9.913219948e-004
	,9.937963000e-004
	,9.962066215e-004
	,9.985527859e-004
	,1.000834323e-003
	,1.003050377e-003
	,1.005199534e-003
	,1.007279535e-003
	,1.009286839e-003
	,1.011216075e-003
	,1.013059616e-003
	,1.014807965e-003
	,1.016452143e-003
	,1.017988497e-003
	,1.019422949e-003
	,1.020769940e-003
	,1.022046642e-003
	,1.023267655e-003
	,1.024442481e-003
	,1.025574312e-003
	,1.026661069e-003
	,1.027706430e-003
	,1.028723226e-003
	,1.029720830e-003
	,1.030703489e-003
	,1.031673128e-003
	,1.032630728e-003
	,1.033576853e-003
	,1.034511849e-003
	,1.035435938e-003
	,1.036349242e-003
	,1.037251779e-003
	,1.038143391e-003
	,1.039023576e-003
	,1.039890969e-003
	,1.040741590e-003
	,-3.662620884e-006
	,-3.006012159e-006
	,-2.459685078e-006
	,-2.003851685e-006
	,-1.624149756e-006
	,-1.310077736e-006
	,-1.053313489e-006
	,-8.444247428e-007
	,-6.732014307e-007
	,-5.328576844e-007
	,-4.200582102e-007
	,-3.308543592e-007
	,-2.604998031e-007
	,-2.048446206e-007
	,-1.607538940e-007
	,-1.257210468e-007
	,-9.787236606e-008
	,-7.581547294e-008
	,-5.850300441e-008
	,-4.506039380e-008
	,-3.471002692e-008
	,-2.676827764e-008
	,-2.066882390e-008
	,-1.596683032e-008
	,-1.232687202e-008
	,-9.498079102e-009
	,-7.298334370e-009
	,-5.592032496e-009
	,-4.269474094e-009
	,-3.245487635e-009
	,-2.453251102e-009
	,-1.840654165e-009
	,-1.369359821e-009
	,-1.009301291e-009
	,-7.351386921e-010
	,-5.259820947e-010
	,-3.653795157e-010
	,-2.407735678e-010
	,-1.427357697e-010
	,-6.421808943e-011
	,-2.260985772e-017
	,5.376596126e-011
	,1.000639595e-010
	,1.412916075e-010
	,1.793433593e-010
	,2.157570867e-010
	,2.517975132e-010
	,2.884379473e-010
	,3.263142385e-010
	,3.657027001e-010
	,4.067335989e-010
	,4.497090888e-010
	,4.949974057e-010
	,5.428099634e-010
	,5.932629074e-010
	,6.467581938e-010
	,7.041583918e-010
	,7.664829677e-010
	,8.346698410e-010
	,9.095442428e-010
	,9.918136060e-010
	,1.082021400e-009
	,1.180633144e-009
	,1.288428391e-009
	,1.406621316e-009
	,1.536584884e-009
	,1.679846549e-009
	,1.838269001e-009
	,2.014052994e-009
	,2.209743849e-009
	,2.428330550e-009
	,2.673362659e-009
	,2.949041936e-009
	,3.260216115e-009
	,3.612115541e-009
	,4.009687781e-009
	,4.457119026e-009
	,4.960837015e-009
	,5.533214631e-009
	,6.190569683e-009
	,6.950691993e-009
	,7.831916254e-009
	,8.849079390e-009
	,1.000656705e-008
	,1.129654827e-008
	,1.273913871e-008
	,1.439708717e-008
	,1.633282352e-008
	,1.861152214e-008
	,2.130942336e-008
	,2.452627656e-008
	,2.838244527e-008
	,3.300836546e-008
	,3.855986459e-008
	,4.527478250e-008
	,5.343144795e-008
	,6.337865202e-008
	,7.555348191e-008
	,9.045623066e-008
	,1.087092748e-007
	,1.310416041e-007
	,1.581962651e-007
	,1.915800857e-007
	,2.327761354e-007
	,2.830546294e-007
	,3.440793894e-007
	,4.184447067e-007
	,5.055704000e-007
	,6.061265975e-007
	,7.235718918e-007
	,8.663696358e-007
	,1.041142657e-006
	,1.255505862e-006
	,1.518727486e-006
	,1.842244635e-006
	,2.240156288e-006
	,2.727977962e-006
	,3.322753504e-006
	,4.052556498e-006
	,4.944447154e-006
	,6.016821781e-006
	,7.324548948e-006
	,8.917447575e-006
	,1.085410003e-005
	,1.313461736e-005
	,1.571809665e-005
	,1.859286546e-005
	,2.162924945e-005
	,2.512234998e-005
	,2.921413907e-005
	,3.399939230e-005
	,3.957522142e-005
	,4.604716404e-005
	,5.352856223e-005
	,6.213480991e-005
	,7.194810660e-005
	,8.295430759e-005
	,9.534145634e-005
	,1.091845995e-004
	,1.243622323e-004
	,1.410196788e-004
	,1.591757044e-004
	,1.787476325e-004
	,1.993080533e-004
	,2.207944466e-004
	,2.432621818e-004
	,2.654751573e-004
	,2.873709723e-004
	,3.104989325e-004
	,3.352430998e-004
	,3.615972696e-004
	,3.894788177e-004
	,4.188009385e-004
	,4.494834062e-004
	,4.814550864e-004
	,5.146522110e-004
	,5.490170662e-004
	,5.844988783e-004
	,6.210527547e-004
	,6.586382841e-004
	,6.972197331e-004
	,7.367577729e-004
	,7.771803544e-004
	,8.185153403e-004
	,8.607413122e-004
	,9.038391930e-004
	,9.477746004e-004
	,9.925391593e-004
	,1.038126577e-003
	,1.084522440e-003
	,1.131707925e-003
	,1.179671164e-003
	,1.228397264e-003
	,1.277207627e-003
	,1.326519358e-003
	,1.376464591e-003
	,1.427018828e-003
	,1.478154654e-003
	,1.529841293e-003
	,1.582044171e-003
	,1.634724483e-003
	,1.687838778e-003
	,1.741338540e-003
	,1.795169771e-003
	,1.849265064e-003
	,1.903449852e-003
	,1.957734183e-003
	,2.012034987e-003
	,2.066263006e-003
	,2.120323061e-003
	,2.174108785e-003
	,2.227515840e-003
	,2.280438136e-003
	,2.332762512e-003
	,2.384374152e-003
	,2.435158576e-003
	,2.484986324e-003
	,2.533733383e-003
	,2.581339563e-003
	,2.627719651e-003
	,2.672643627e-003
	,-9.359676873e-006
	,-7.807656806e-006
	,-6.471600985e-006
	,-5.336036451e-006
	,-4.380271835e-006
	,-3.579315785e-006
	,-2.902438868e-006
	,-2.333919571e-006
	,-1.864130803e-006
	,-1.482845475e-006
	,-1.178608006e-006
	,-9.368690860e-007
	,-7.432786656e-007
	,-5.864824940e-007
	,-4.597471092e-007
	,-3.584168818e-007
	,-2.782041340e-007
	,-2.155728292e-007
	,-1.671332432e-007
	,-1.297476234e-007
	,-1.008285417e-007
	,-7.834146773e-008
	,-6.072947341e-008
	,-4.689883787e-008
	,-3.609504877e-008
	,-2.768043939e-008
	,-2.111462992e-008
	,-1.602050995e-008
	,-1.211837655e-008
	,-9.153928937e-009
	,-6.906854993e-009
	,-5.201619013e-009
	,-3.903648070e-009
	,-2.911186217e-009
	,-2.147554239e-009
	,-1.554974056e-009
	,-1.090550828e-009
	,-7.236083748e-010
	,-4.312740149e-010
	,-1.949854311e-010
	,-1.791038447e-017
	,1.646491287e-010
	,3.067566965e-010
	,4.317649226e-010
	,5.439162220e-010
	,6.472945455e-010
	,7.457271381e-010
	,8.426486831e-010
	,9.411007853e-010
	,1.043636361e-009
	,1.152374207e-009
	,1.269150644e-009
	,1.395630247e-009
	,1.533322723e-009
	,1.683514908e-009
	,1.847107593e-009
	,2.024777083e-009
	,2.217876862e-009
	,2.428628655e-009
	,2.659368170e-009
	,2.912147693e-009
	,3.188956218e-009
	,3.492240664e-009
	,3.824913391e-009
	,4.190081990e-009
	,4.590682962e-009
	,5.028792772e-009
	,5.504810045e-009
	,6.018052123e-009
	,6.569998784e-009
	,7.165557821e-009
	,7.810034757e-009
	,8.506196282e-009
	,9.252512336e-009
	,1.004294468e-008
	,1.087154113e-008
	,1.174169462e-008
	,1.266883533e-008
	,1.367333142e-008
	,1.477530529e-008
	,1.599433872e-008
	,1.735066434e-008
	,1.886591001e-008
	,2.056375544e-008
	,2.247311034e-008
	,2.463532433e-008
	,2.710318131e-008
	,2.993972356e-008
	,3.322124451e-008
	,3.703885202e-008
	,4.150107625e-008
	,4.673712780e-008
	,5.291055677e-008
	,6.021974342e-008
	,6.890792344e-008
	,7.927021553e-008
	,9.164948024e-008
	,1.063642125e-007
	,1.237552876e-007
	,1.444390501e-007
	,1.692245057e-007
	,1.987561169e-007
	,2.342679164e-007
	,2.766495132e-007
	,3.265888016e-007
	,3.837237860e-007
	,4.486235437e-007
	,5.257142525e-007
	,6.186963453e-007
	,7.318207972e-007
	,8.695393192e-007
	,1.037863395e-006
	,1.244124827e-006
	,1.497242347e-006
	,1.807178983e-006
	,2.186251043e-006
	,2.652355230e-006
	,3.226099070e-006
	,3.928064951e-006
	,4.777092619e-006
	,5.815554183e-006
	,7.087334122e-006
	,8.637362863e-006
	,1.044645089e-005
	,1.252082104e-005
	,1.483406012e-005
	,1.731935785e-005
	,2.022352544e-005
	,2.364865009e-005
	,2.767970494e-005
	,3.240537813e-005
	,3.792233809e-005
	,4.433482188e-005
	,5.175014460e-005
	,6.025713059e-005
	,6.985836109e-005
	,8.071252298e-005
	,9.285263917e-005
	,1.062338268e-004
	,1.210146168e-004
	,1.372086779e-004
	,1.547489954e-004
	,1.733107700e-004
	,1.926924940e-004
	,2.126801551e-004
	,2.324911202e-004
	,2.523818898e-004
	,2.735877543e-004
	,2.963730057e-004
	,3.205426890e-004
	,3.461704734e-004
	,3.731836866e-004
	,4.015146827e-004
	,4.311015305e-004
	,4.618807779e-004
	,4.937348351e-004
	,5.266717003e-004
	,5.606625189e-004
	,5.956684457e-004
	,6.316573814e-004
	,6.685993995e-004
	,7.064677174e-004
	,7.452385531e-004
	,7.848908041e-004
	,8.254057127e-004
	,8.667665194e-004
	,9.089581077e-004
	,9.519657995e-004
	,9.957751196e-004
	,1.040375809e-003
	,1.085755631e-003
	,1.131902116e-003
	,1.178802157e-003
	,1.226441595e-003
	,1.273887898e-003
	,1.321879709e-003
	,1.370475096e-003
	,1.419651949e-003
	,1.469385593e-003
	,1.519648400e-003
	,1.570409403e-003
	,1.621633919e-003
	,1.673283003e-003
	,1.725308122e-003
	,1.777612366e-003
	,1.830168712e-003
	,1.882916270e-003
	,1.935786960e-003
	,1.988707040e-003
	,2.041597037e-003
	,2.094371730e-003
	,2.146940260e-003
	,2.199200220e-003
	,2.251053636e-003
	,2.302398737e-003
	,2.353128278e-003
	,2.403134237e-003
	,2.452309948e-003
	,2.500552560e-003
	,2.547535898e-003
	,2.593057659e-003
	,-2.185378776e-005
	,-1.872016972e-005
	,-1.583703453e-005
	,-1.325279338e-005
	,-1.101788025e-005
	,-9.130740523e-006
	,-7.542357563e-006
	,-6.182379737e-006
	,-5.012255198e-006
	,-4.032318839e-006
	,-3.231875200e-006
	,-2.583613445e-006
	,-2.061640695e-006
	,-1.642033059e-006
	,-1.301543128e-006
	,-1.024890627e-006
	,-8.039141554e-007
	,-6.297109453e-007
	,-4.926708433e-007
	,-3.843936160e-007
	,-2.985626539e-007
	,-2.309990511e-007
	,-1.782647065e-007
	,-1.372197564e-007
	,-1.052663992e-007
	,-8.049636780e-008
	,-6.146851119e-008
	,-4.693770617e-008
	,-3.585183364e-008
	,-2.737741080e-008
	,-2.087524137e-008
	,-1.585910714e-008
	,-1.196513574e-008
	,-8.937040567e-009
	,-6.586644193e-009
	,-4.757550730e-009
	,-3.322944897e-009
	,-2.188665849e-009
	,-1.289008249e-009
	,-5.742326204e-010
	,1.744009767e-017
	,4.724024892e-010
	,8.741936814e-010
	,1.229576923e-009
	,1.557144392e-009
	,1.871259545e-009
	,2.183165921e-009
	,2.501740829e-009
	,2.833791563e-009
	,3.183809110e-009
	,3.554402058e-009
	,3.949122997e-009
	,4.373877119e-009
	,4.834914743e-009
	,5.337265315e-009
	,5.884335659e-009
	,6.478311037e-009
	,7.120986005e-009
	,7.812091474e-009
	,8.547602994e-009
	,9.324421011e-009
	,1.014477228e-008
	,1.101148864e-008
	,1.192351007e-008
	,1.287783011e-008
	,1.387745102e-008
	,1.493511278e-008
	,1.606727682e-008
	,1.728905427e-008
	,1.861368093e-008
	,2.005342283e-008
	,2.162035563e-008
	,2.332658362e-008
	,2.518350633e-008
	,2.720041620e-008
	,2.938462047e-008
	,3.174686310e-008
	,3.430635131e-008
	,3.708740668e-008
	,4.011528335e-008
	,4.341578202e-008
	,4.701800105e-008
	,5.095735538e-008
	,5.527551177e-008
	,6.002013620e-008
	,6.524600413e-008
	,7.101657067e-008
	,7.740521648e-008
	,8.449507216e-008
	,9.237508662e-008
	,1.011298728e-007
	,1.108332978e-007
	,1.215810750e-007
	,1.335689858e-007
	,1.471004091e-007
	,1.625416254e-007
	,1.802981454e-007
	,2.007850134e-007
	,2.243388774e-007
	,2.510305761e-007
	,2.805943131e-007
	,3.131269079e-007
	,3.500480991e-007
	,3.930235350e-007
	,4.436487755e-007
	,5.034908313e-007
	,5.745899747e-007
	,6.592434138e-007
	,7.606835596e-007
	,8.827663052e-007
	,1.030105052e-006
	,1.207921295e-006
	,1.423437733e-006
	,1.685203416e-006
	,2.003597250e-006
	,2.393130766e-006
	,2.869192417e-006
	,3.442864587e-006
	,4.140050731e-006
	,4.992175641e-006
	,6.030396927e-006
	,7.258588673e-006
	,8.707669920e-006
	,1.032858862e-005
	,1.210578907e-005
	,1.413681669e-005
	,1.654379588e-005
	,1.940238742e-005
	,2.278691284e-005
	,2.677807297e-005
	,3.146437846e-005
	,3.694117340e-005
	,4.330581715e-005
	,5.062961467e-005
	,5.896059564e-005
	,6.841506310e-005
	,7.895722666e-005
	,9.068971673e-005
	,1.037085583e-004
	,1.180290873e-004
	,1.335851125e-004
	,1.500766993e-004
	,1.672812623e-004
	,1.847483045e-004
	,2.020590733e-004
	,2.199103734e-004
	,2.391027746e-004
	,2.597814914e-004
	,2.819077821e-004
	,3.054380953e-004
	,3.302567906e-004
	,3.561066185e-004
	,3.831453335e-004
	,4.113424205e-004
	,4.406553615e-004
	,4.710443505e-004
	,5.024719861e-004
	,5.349040711e-004
	,5.683094237e-004
	,6.026594510e-004
	,6.379246587e-004
	,6.740845070e-004
	,7.111171713e-004
	,7.490047703e-004
	,7.877304474e-004
	,8.272790569e-004
	,8.676369119e-004
	,9.087915150e-004
	,9.507312786e-004
	,9.934452348e-004
	,1.036922735e-003
	,1.081153141e-003
	,1.126125499e-003
	,1.171828214e-003
	,1.218112233e-003
	,1.264001091e-003
	,1.310479938e-003
	,1.357531148e-003
	,1.405135217e-003
	,1.453270272e-003
	,1.501908833e-003
	,1.551027790e-003
	,1.600597420e-003
	,1.650583343e-003
	,1.700929667e-003
	,1.751592047e-003
	,1.802521872e-003
	,1.853665964e-003
	,1.904966298e-003
	,1.956359707e-003
	,2.007777638e-003
	,2.059145988e-003
	,2.110385096e-003
	,2.161409939e-003
	,2.212126317e-003
	,2.262439508e-003
	,2.312256681e-003
	,2.361478585e-003
	,2.409734535e-003
	,2.457045214e-003
	,2.503396432e-003
	,-4.517256914e-005
	,-3.969141820e-005
	,-3.459238498e-005
	,-2.979932519e-005
	,-2.541876350e-005
	,-2.155978209e-005
	,-1.821374828e-005
	,-1.527749020e-005
	,-1.266506525e-005
	,-1.039431147e-005
	,-8.486891592e-006
	,-6.908771873e-006
	,-5.613965909e-006
	,-4.548477879e-006
	,-3.656951361e-006
	,-2.910489176e-006
	,-2.300095784e-006
	,-1.809055144e-006
	,-1.418125819e-006
	,-1.110515472e-006
	,-8.695884824e-007
	,-6.810092364e-007
	,-5.325156257e-007
	,-4.144188807e-007
	,-3.208870409e-007
	,-2.479000444e-007
	,-1.913406610e-007
	,-1.474063449e-007
	,-1.130368515e-007
	,-8.610164813e-008
	,-6.515667127e-008
	,-4.899584588e-008
	,-3.659179067e-008
	,-2.710247701e-008
	,-1.982496003e-008
	,-1.420953115e-008
	,-9.864214784e-009
	,-6.490211687e-009
	,-3.842980604e-009
	,-1.729270473e-009
	,-1.232323294e-017
	,1.459060976e-009
	,2.734763131e-009
	,3.891607307e-009
	,4.975240068e-009
	,6.020082314e-009
	,7.058385419e-009
	,8.118836474e-009
	,9.221432305e-009
	,1.037344465e-008
	,1.156659127e-008
	,1.278217186e-008
	,1.401335421e-008
	,1.527757963e-008
	,1.660200808e-008
	,1.801500448e-008
	,1.954253227e-008
	,2.120526445e-008
	,2.301929217e-008
	,2.499901145e-008
	,2.716041250e-008
	,2.952241071e-008
	,3.210562618e-008
	,3.493038047e-008
	,3.801447859e-008
	,4.136992574e-008
	,4.500006101e-008
	,4.890790187e-008
	,5.311564425e-008
	,5.766520106e-008
	,6.260271938e-008
	,6.797032801e-008
	,7.380373845e-008
	,8.013303699e-008
	,8.699000446e-008
	,9.441419741e-008
	,1.024492789e-007
	,1.111341763e-007
	,1.204880620e-007
	,1.304986041e-007
	,1.411467827e-007
	,1.524648504e-007
	,1.645384104e-007
	,1.774513959e-007
	,1.912434031e-007
	,2.058800062e-007
	,2.212265924e-007
	,2.370708253e-007
	,2.532673301e-007
	,2.699142399e-007
	,2.873177739e-007
	,3.058253125e-007
	,3.257429918e-007
	,3.473401532e-007
	,3.708757413e-007
	,3.966205428e-007
	,4.248713696e-007
	,4.559583655e-007
	,4.902594439e-007
	,5.282571118e-007
	,5.706317704e-007
	,6.182618546e-007
	,6.722182551e-007
	,7.338039874e-007
	,8.046286900e-007
	,8.866450543e-007
	,9.822341694e-007
	,1.094261880e-006
	,1.226187422e-006
	,1.382206228e-006
	,1.567442131e-006
	,1.787722939e-006
	,2.050454555e-006
	,2.363071360e-006
	,2.731854978e-006
	,3.169632004e-006
	,3.693675899e-006
	,4.316851334e-006
	,5.051568196e-006
	,5.917758145e-006
	,6.906772357e-006
	,8.002043829e-006
	,9.222558457e-006
	,1.065043932e-005
	,1.235090103e-005
	,1.437322588e-005
	,1.678154141e-005
	,1.964145195e-005
	,2.302599460e-005
	,2.701547450e-005
	,3.169511022e-005
	,3.714806670e-005
	,4.342076952e-005
	,5.061139917e-005
	,5.873827536e-005
	,6.783959599e-005
	,7.804205057e-005
	,8.939867256e-005
	,1.019083318e-004
	,1.154764327e-004
	,1.297604124e-004
	,1.444010933e-004
	,1.592789759e-004
	,1.741890527e-004
	,1.900709659e-004
	,2.072482638e-004
	,2.257115406e-004
	,2.454982260e-004
	,2.665790490e-004
	,2.889232878e-004
	,3.125000153e-004
	,3.372784891e-004
	,3.632283007e-004
	,3.899475546e-004
	,4.176716061e-004
	,4.464113062e-004
	,4.761376824e-004
	,5.068233902e-004
	,5.384423336e-004
	,5.709712070e-004
	,6.043881222e-004
	,6.386729816e-004
	,6.738058405e-004
	,7.097692055e-004
	,7.465492492e-004
	,7.841324158e-004
	,8.225060582e-004
	,8.616585663e-004
	,9.015791747e-004
	,9.422577572e-004
	,9.836846099e-004
	,1.025850222e-003
	,1.068745039e-003
	,1.112358414e-003
	,1.156679689e-003
	,1.201169504e-003
	,1.245314841e-003
	,1.290014276e-003
	,1.335252553e-003
	,1.381013072e-003
	,1.427277698e-003
	,1.474037463e-003
	,1.521300806e-003
	,1.568988120e-003
	,1.617069817e-003
	,1.665513387e-003
	,1.714283252e-003
	,1.763340346e-003
	,1.812641723e-003
	,1.862140182e-003
	,1.911783924e-003
	,1.961516298e-003
	,2.011275635e-003
	,2.060995207e-003
	,2.110603313e-003
	,2.160023526e-003
	,2.209134772e-003
	,2.257730601e-003
	,2.305811663e-003
	,2.353290509e-003
	,2.400083142e-003
	,-8.399875748e-005
	,-7.519534139e-005
	,-6.690989678e-005
	,-5.918010561e-005
	,-5.204737310e-005
	,-4.553958916e-005
	,-3.957231977e-005
	,-3.407904727e-005
	,-2.907783932e-005
	,-2.458959894e-005
	,-2.066292504e-005
	,-1.731151972e-005
	,-1.446004274e-005
	,-1.198478206e-005
	,-9.814897993e-006
	,-7.949539735e-006
	,-6.383314043e-006
	,-5.106725011e-006
	,-4.084932997e-006
	,-3.270424473e-006
	,-2.617227909e-006
	,-2.084968031e-006
	,-1.646398508e-006
	,-1.287877601e-006
	,-9.985803914e-007
	,-7.684613999e-007
	,-5.886054953e-007
	,-4.501679005e-007
	,-3.443950252e-007
	,-2.636227299e-007
	,-2.017198008e-007
	,-1.539417588e-007
	,-1.167145206e-007
	,-8.755862892e-008
	,-6.473376730e-008
	,-4.689102268e-008
	,-3.292266754e-008
	,-2.188908310e-008
	,-1.305410786e-008
	,-5.885059609e-009
	,-4.830031151e-017
	,4.917478389e-009
	,9.131860469e-009
	,1.283818054e-008
	,1.618488362e-008
	,1.930879316e-008
	,2.232273797e-008
	,2.530452319e-008
	,2.832167400e-008
	,3.145108202e-008
	,3.476894745e-008
	,3.834208314e-008
	,4.223107842e-008
	,4.649400832e-008
	,5.118764923e-008
	,5.636615644e-008
	,6.207549935e-008
	,6.834145576e-008
	,7.516063651e-008
	,8.253135981e-008
	,9.050541167e-008
	,9.917148509e-008
	,1.086182987e-007
	,1.189240641e-007
	,1.301463335e-007
	,1.423015117e-007
	,1.553309221e-007
	,1.690877262e-007
	,1.833965862e-007
	,1.981971833e-007
	,2.135760103e-007
	,2.296261521e-007
	,2.463785800e-007
	,2.638379472e-007
	,2.820753445e-007
	,3.012749443e-007
	,3.216528430e-007
	,3.433789603e-007
	,3.665747696e-007
	,3.913508992e-007
	,4.178393508e-007
	,4.461946102e-007
	,4.765764859e-007
	,5.091362311e-007
	,5.440047000e-007
	,5.812799396e-007
	,6.210414144e-007
	,6.634274160e-007
	,7.086931864e-007
	,7.571585413e-007
	,8.091445439e-007
	,8.649613754e-007
	,9.249325373e-007
	,9.894322923e-007
	,1.058893007e-006
	,1.133791558e-006
	,1.214646556e-006
	,1.302025696e-006
	,1.396554399e-006
	,1.498920866e-006
	,1.609872994e-006
	,1.730192831e-006
	,1.860632630e-006
	,2.001813169e-006
	,2.154222345e-006
	,2.318609903e-006
	,2.496704274e-006
	,2.691211303e-006
	,2.905486175e-006
	,3.143601081e-006
	,3.410620190e-006
	,3.712316824e-006
	,4.054400000e-006
	,4.440581952e-006
	,4.869727574e-006
	,5.336633162e-006
	,5.846296577e-006
	,6.418632248e-006
	,7.079866696e-006
	,7.853727346e-006
	,8.762829318e-006
	,9.833193033e-006
	,1.109959010e-005
	,1.260028611e-005
	,1.437906894e-005
	,1.648640048e-005
	,1.897973963e-005
	,2.192294804e-005
	,2.536895207e-005
	,2.938934357e-005
	,3.405570892e-005
	,3.943692889e-005
	,4.553489700e-005
	,5.243594008e-005
	,6.023688853e-005
	,6.899583796e-005
	,7.872755982e-005
	,8.936011600e-005
	,1.006415914e-004
	,1.122285919e-004
	,1.241507032e-004
	,1.362335449e-004
	,1.490706916e-004
	,1.629947045e-004
	,1.780882290e-004
	,1.943605955e-004
	,2.118054424e-004
	,2.304120863e-004
	,2.501679664e-004
	,2.710590303e-004
	,2.930702451e-004
	,3.161855416e-004
	,3.403879249e-004
	,3.656597622e-004
	,3.919830389e-004
	,4.188852456e-004
	,4.466189123e-004
	,4.752722312e-004
	,5.048255332e-004
	,5.352598817e-004
	,5.665568286e-004
	,5.986997516e-004
	,6.316727010e-004
	,6.654607456e-004
	,7.000499112e-004
	,7.354250849e-004
	,7.715756414e-004
	,8.084893968e-004
	,8.461570889e-004
	,8.845688344e-004
	,9.237152136e-004
	,9.635871215e-004
	,1.004175609e-003
	,1.045471719e-003
	,1.087466319e-003
	,1.130149925e-003
	,1.172457390e-003
	,1.214498449e-003
	,1.257055380e-003
	,1.300115443e-003
	,1.343711658e-003
	,1.387844399e-003
	,1.432429232e-003
	,1.477447159e-003
	,1.522877893e-003
	,1.568699288e-003
	,1.614887231e-003
	,1.661415176e-003
	,1.708253763e-003
	,1.755370476e-003
	,1.802729353e-003
	,1.850290760e-003
	,1.898011212e-003
	,1.945843252e-003
	,1.993735590e-003
	,2.041645817e-003
	,2.089435277e-003
	,2.137035223e-003
	,2.184378130e-003
	,2.231399157e-003
	,2.278030188e-003
	,-1.426005352e-004
	,-1.300624894e-004
	,-1.179621351e-004
	,-1.064373712e-004
	,-9.560510987e-005
	,-8.557039545e-005
	,-7.639640506e-005
	,-6.802690800e-005
	,-6.024253325e-005
	,-5.284406103e-005
	,-4.589543146e-005
	,-3.955218316e-005
	,-3.384946099e-005
	,-2.878046322e-005
	,-2.436364957e-005
	,-2.051183544e-005
	,-1.707182452e-005
	,-1.404332278e-005
	,-1.148489210e-005
	,-9.355306578e-006
	,-7.570069313e-006
	,-6.078961389e-006
	,-4.857956892e-006
	,-3.868369825e-006
	,-3.061672730e-006
	,-2.406869780e-006
	,-1.885807406e-006
	,-1.475509878e-006
	,-1.151322004e-006
	,-8.936429254e-007
	,-6.882127711e-007
	,-5.263186696e-007
	,-3.998411255e-007
	,-3.003218972e-007
	,-2.213347501e-007
	,-1.590537907e-007
	,-1.103963949e-007
	,-7.250943812e-008
	,-4.284838899e-008
	,-1.924863058e-008
	,-3.049452952e-017
	,1.619147757e-008
	,3.026232435e-008
	,4.288641002e-008
	,5.460963262e-008
	,6.588568112e-008
	,7.708332914e-008
	,8.849963545e-008
	,1.003469153e-007
	,1.127132477e-007
	,1.256466311e-007
	,1.392537173e-007
	,1.538319729e-007
	,1.697191314e-007
	,1.870934502e-007
	,2.058785822e-007
	,2.257224462e-007
	,2.461793997e-007
	,2.670467324e-007
	,2.883892784e-007
	,3.104309155e-007
	,3.335626364e-007
	,3.582275463e-007
	,3.848145464e-007
	,4.136514113e-007
	,4.450277721e-007
	,4.792224714e-007
	,5.165229789e-007
	,5.572211639e-007
	,6.016061614e-007
	,6.499513907e-007
	,7.024796446e-007
	,7.592921582e-007
	,8.202850419e-007
	,8.852194766e-007
	,9.541230086e-007
	,1.027539522e-006
	,1.106251043e-006
	,1.191023068e-006
	,1.282517926e-006
	,1.381256379e-006
	,1.487612290e-006
	,1.601872297e-006
	,1.724287052e-006
	,1.855063112e-006
	,1.994273874e-006
	,2.141649763e-006
	,2.296527348e-006
	,2.458347944e-006
	,2.627317925e-006
	,2.804265165e-006
	,2.990013172e-006
	,3.184966429e-006
	,3.388788906e-006
	,3.599991289e-006
	,3.815575836e-006
	,4.031460701e-006
	,4.244609212e-006
	,4.455585393e-006
	,4.668251246e-006
	,4.887249151e-006
	,5.116388292e-006
	,5.358440150e-006
	,5.615442340e-006
	,5.888987756e-006
	,6.180391024e-006
	,6.490753182e-006
	,6.821017062e-006
	,7.172223645e-006
	,7.546028513e-006
	,7.945013565e-006
	,8.372575378e-006
	,8.832834304e-006
	,9.330827567e-006
	,9.872815484e-006
	,1.046670588e-005
	,1.112254436e-005
	,1.185303302e-005
	,1.267403822e-005
	,1.360503158e-005
	,1.466940765e-005
	,1.589464853e-005
	,1.731242920e-005
	,1.895826767e-005
	,2.087369947e-005
	,2.310465835e-005
	,2.569720806e-005
	,2.868776561e-005
	,3.209535271e-005
	,3.599125569e-005
	,4.045304183e-005
	,4.554785850e-005
	,5.132313397e-005
	,5.779299530e-005
	,6.489714533e-005
	,7.241733791e-005
	,8.027962522e-005
	,8.849230781e-005
	,9.701879465e-005
	,1.062233510e-004
	,1.162989235e-004
	,1.273170264e-004
	,1.393056641e-004
	,1.522790859e-004
	,1.662436120e-004
	,1.811962190e-004
	,1.971575657e-004
	,2.141307149e-004
	,2.321168687e-004
	,2.511154762e-004
	,2.711243753e-004
	,2.921397519e-004
	,3.141563132e-004
	,3.371677447e-004
	,3.611665021e-004
	,3.861441142e-004
	,4.120913809e-004
	,4.386165480e-004
	,4.656729122e-004
	,4.935667366e-004
	,5.222966355e-004
	,5.518503777e-004
	,5.822138704e-004
	,6.133737839e-004
	,6.453178343e-004
	,6.780342408e-004
	,7.115119811e-004
	,7.457407523e-004
	,7.807092644e-004
	,8.164090155e-004
	,8.528315925e-004
	,8.899671184e-004
	,9.278088866e-004
	,9.663487580e-004
	,1.005578595e-003
	,1.045490191e-003
	,1.086077917e-003
	,1.125969864e-003
	,1.165337500e-003
	,1.205283584e-003
	,1.245768728e-003
	,1.286711068e-003
	,1.328098305e-003
	,1.369917884e-003
	,1.412156846e-003
	,1.454801276e-003
	,1.497836135e-003
	,1.541244970e-003
	,1.585009654e-003
	,1.629110204e-003
	,1.673524668e-003
	,1.718229044e-003
	,1.763197229e-003
	,1.808590703e-003
	,1.854140676e-003
	,1.899874954e-003
	,1.945615699e-003
	,1.991218719e-003
	,2.036642497e-003
	,2.081900518e-003
	,2.127048166e-003
	,-2.156168826e-004
	,-2.014211519e-004
	,-1.874768951e-004
	,-1.736971770e-004
	,-1.602113618e-004
	,-1.472316280e-004
	,-1.349036831e-004
	,-1.232520116e-004
	,-1.121397360e-004
	,-1.013480478e-004
	,-9.069589404e-005
	,-8.034109807e-005
	,-7.067347806e-005
	,-6.195867021e-005
	,-5.425213821e-005
	,-4.744784016e-005
	,-4.127410594e-005
	,-3.548703938e-005
	,-3.003745672e-005
	,-2.507908217e-005
	,-2.078637943e-005
	,-1.717826770e-005
	,-1.417331142e-005
	,-1.164863629e-005
	,-9.489250498e-006
	,-7.662659852e-006
	,-6.152021415e-006
	,-4.891836640e-006
	,-3.837043780e-006
	,-2.981002975e-006
	,-2.305380663e-006
	,-1.777993807e-006
	,-1.363317085e-006
	,-1.032063673e-006
	,-7.691156045e-007
	,-5.626244269e-007
	,-3.996454418e-007
	,-2.688211069e-007
	,-1.616935233e-007
	,-7.330644698e-008
	,2.349566883e-018
	,6.218029340e-008
	,1.165643861e-007
	,1.652243470e-007
	,2.093079713e-007
	,2.498761678e-007
	,2.881938478e-007
	,3.256970127e-007
	,3.639464622e-007
	,4.043644269e-007
	,4.480545398e-007
	,4.952979611e-007
	,5.448840903e-007
	,5.962306123e-007
	,6.497102407e-007
	,7.070104959e-007
	,7.695039553e-007
	,8.378202537e-007
	,9.125052899e-007
	,9.942970907e-007
	,1.083791046e-006
	,1.181142168e-006
	,1.286158570e-006
	,1.399084086e-006
	,1.521114141e-006
	,1.653708246e-006
	,1.797904309e-006
	,1.954178998e-006
	,2.122388108e-006
	,2.301241825e-006
	,2.487707995e-006
	,2.677631119e-006
	,2.868544282e-006
	,3.061348889e-006
	,3.258054380e-006
	,3.459356806e-006
	,3.664577014e-006
	,3.873412889e-006
	,4.087628622e-006
	,4.310525051e-006
	,4.545400599e-006
	,4.795103934e-006
	,5.061759696e-006
	,5.346838627e-006
	,5.651365898e-006
	,5.975958117e-006
	,6.320747105e-006
	,6.685362993e-006
	,7.069220177e-006
	,7.472016359e-006
	,7.894155683e-006
	,8.336851061e-006
	,8.801505640e-006
	,9.288947617e-006
	,9.799321410e-006
	,1.033261984e-005
	,1.088939352e-005
	,1.147098771e-005
	,1.207909011e-005
	,1.271517624e-005
	,1.338035332e-005
	,1.407566929e-005
	,1.480248309e-005
	,1.556246429e-005
	,1.635732785e-005
	,1.718846495e-005
	,1.805661877e-005
	,1.896159805e-005
	,1.990202548e-005
	,2.087546621e-005
	,2.187961817e-005
	,2.291443558e-005
	,2.398284883e-005
	,2.508952028e-005
	,2.623938496e-005
	,2.743709778e-005
	,2.868710629e-005
	,2.999390697e-005
	,3.136223849e-005
	,3.279709065e-005
	,3.430445170e-005
	,3.589087212e-005
	,3.756260387e-005
	,3.932475453e-005
	,4.118047725e-005
	,4.313253754e-005
	,4.519123950e-005
	,4.738354986e-005
	,4.974573954e-005
	,5.231157720e-005
	,5.511004657e-005
	,5.820274435e-005
	,6.167807559e-005
	,6.562351405e-005
	,7.011207225e-005
	,7.520340492e-005
	,8.094755656e-005
	,8.738743231e-005
	,9.456014611e-005
	,1.024973570e-004
	,1.112211298e-004
	,1.207589988e-004
	,1.311304186e-004
	,1.423513565e-004
	,1.544351994e-004
	,1.673922257e-004
	,1.812306726e-004
	,1.959580236e-004
	,2.115778449e-004
	,2.280910732e-004
	,2.454958324e-004
	,2.637872824e-004
	,2.829579365e-004
	,3.029993629e-004
	,3.239067367e-004
	,3.457119132e-004
	,3.683904071e-004
	,3.919424609e-004
	,4.163742069e-004
	,4.416905239e-004
	,4.671728248e-004
	,4.932574617e-004
	,5.201363859e-004
	,5.477997129e-004
	,5.762369767e-004
	,6.054372711e-004
	,6.353894725e-004
	,6.660826122e-004
	,6.975059761e-004
	,7.296489279e-004
	,7.625011526e-004
	,7.960527141e-004
	,8.302933021e-004
	,8.652127685e-004
	,9.008037702e-004
	,9.371505104e-004
	,9.741594767e-004
	,1.011784859e-003
	,1.050187434e-003
	,1.086250364e-003
	,1.122615209e-003
	,1.159362027e-003
	,1.196475732e-003
	,1.234025973e-003
	,1.272044744e-003
	,1.310204457e-003
	,1.348380208e-003
	,1.386511641e-003
	,1.424449949e-003
	,1.461892870e-003
	,1.499851725e-003
	,1.538884385e-003
	,1.578926187e-003
	,1.619810417e-003
	,1.661404841e-003
	,1.703612181e-003
	,1.746357285e-003
	,1.789577832e-003
	,1.833218513e-003
	,1.877227353e-003
	,1.921553292e-003
	,-3.035043063e-004
	,-2.876397737e-004
	,-2.721537949e-004
	,-2.569452105e-004
	,-2.419265878e-004
	,-2.270301872e-004
	,-2.121762736e-004
	,-1.973557695e-004
	,-1.826946253e-004
	,-1.683862333e-004
	,-1.545153819e-004
	,-1.411592834e-004
	,-1.283911042e-004
	,-1.162761229e-004
	,-1.048232826e-004
	,-9.397839862e-005
	,-8.382268170e-005
	,-7.451438586e-005
	,-6.613263472e-005
	,-5.859910598e-005
	,-5.161422607e-005
	,-4.496531520e-005
	,-3.864636554e-005
	,-3.271786678e-005
	,-2.728603972e-005
	,-2.248532357e-005
	,-1.840863161e-005
	,-1.502814433e-005
	,-1.224941884e-005
	,-9.943230638e-006
	,-7.999910387e-006
	,-6.378064672e-006
	,-5.019568902e-006
	,-3.876144830e-006
	,-2.930386462e-006
	,-2.158927266e-006
	,-1.535724851e-006
	,-1.032509165e-006
	,-6.219381988e-007
	,-2.838230465e-007
	,-5.169590323e-018
	,2.427633154e-007
	,4.543777456e-007
	,6.435222407e-007
	,8.185414295e-007
	,9.856029201e-007
	,1.147724248e-006
	,1.308441485e-006
	,1.473968235e-006
	,1.650243593e-006
	,1.840876976e-006
	,2.046772449e-006
	,2.267358325e-006
	,2.499665612e-006
	,2.737566245e-006
	,2.978705542e-006
	,3.224770581e-006
	,3.477914956e-006
	,3.734797532e-006
	,3.984761798e-006
	,4.238536109e-006
	,4.507024148e-006
	,4.795280081e-006
	,5.107776343e-006
	,5.447820394e-006
	,5.817262633e-006
	,6.216484655e-006
	,6.644805748e-006
	,7.101797235e-006
	,7.588515906e-006
	,8.106017317e-006
	,8.653929619e-006
	,9.231748332e-006
	,9.841188304e-006
	,1.048582672e-005
	,1.116846354e-005
	,1.188981338e-005
	,1.264913318e-005
	,1.344546520e-005
	,1.427842855e-005
	,1.514817991e-005
	,1.605440209e-005
	,1.699468147e-005
	,1.796312973e-005
	,1.895003568e-005
	,1.994580959e-005
	,2.094934428e-005
	,2.196827225e-005
	,2.301382593e-005
	,2.409611770e-005
	,2.522219556e-005
	,2.639591999e-005
	,2.761818093e-005
	,2.888683117e-005
	,3.019597353e-005
	,3.153504259e-005
	,3.288966964e-005
	,3.424569309e-005
	,3.559369869e-005
	,3.692935657e-005
	,3.824956685e-005
	,3.954931839e-005
	,4.082310201e-005
	,4.207020651e-005
	,4.329821012e-005
	,4.452025234e-005
	,4.574973015e-005
	,4.699653743e-005
	,4.826595116e-005
	,4.956038492e-005
	,5.088186596e-005
	,5.223326669e-005
	,5.361776014e-005
	,5.503783474e-005
	,5.649507609e-005
	,5.799066944e-005
	,5.952628134e-005
	,6.110397211e-005
	,6.272595358e-005
	,6.439438420e-005
	,6.611144293e-005
	,6.787956119e-005
	,6.970163750e-005
	,7.158117534e-005
	,7.352236153e-005
	,7.552970005e-005
	,7.760765911e-005
	,7.976589089e-005
	,8.201640401e-005
	,8.437333969e-005
	,8.685441423e-005
	,8.948176513e-005
	,9.228264123e-005
	,9.528988783e-005
	,9.854205710e-005
	,1.020829726e-004
	,1.059605657e-004
	,1.102250998e-004
	,1.149274445e-004
	,1.201225220e-004
	,1.258631533e-004
	,1.322020725e-004
	,1.391924511e-004
	,1.468822983e-004
	,1.553119010e-004
	,1.645131901e-004
	,1.745102240e-004
	,1.853200829e-004
	,1.969538306e-004
	,2.094173398e-004
	,2.227119447e-004
	,2.368348811e-004
	,2.517795591e-004
	,2.675356779e-004
	,2.840894962e-004
	,3.014276410e-004
	,3.195294936e-004
	,3.384296859e-004
	,3.581807715e-004
	,3.786792537e-004
	,3.999449331e-004
	,4.220031013e-004
	,4.448764910e-004
	,4.684998334e-004
	,4.919504205e-004
	,5.161550913e-004
	,5.410977742e-004
	,5.667620279e-004
	,5.931203052e-004
	,6.201486691e-004
	,6.479265587e-004
	,6.764633186e-004
	,7.055514128e-004
	,7.351833289e-004
	,7.653491693e-004
	,7.961938803e-004
	,8.277123019e-004
	,8.598457448e-004
	,8.926094511e-004
	,9.261172026e-004
	,9.605054890e-004
	,9.951486266e-004
	,1.027179581e-003
	,1.059768212e-003
	,1.092971428e-003
	,1.126809314e-003
	,1.161278147e-003
	,1.196363214e-003
	,1.232045895e-003
	,1.268307107e-003
	,1.305128282e-003
	,1.342491839e-003
	,1.380381019e-003
	,1.418779652e-003
	,1.457671888e-003
	,1.497041908e-003
	,1.536879534e-003
	,1.577168114e-003
	,1.617883948e-003
	,1.659008365e-003
	,1.700521385e-003
	,-3.964711385e-004
	,-3.784445746e-004
	,-3.606918947e-004
	,-3.430741834e-004
	,-3.256568163e-004
	,-3.087042178e-004
	,-2.923937379e-004
	,-2.768605004e-004
	,-2.621705448e-004
	,-2.481982489e-004
	,-2.344430287e-004
	,-2.203127880e-004
	,-2.057993291e-004
	,-1.912706523e-004
	,-1.770349292e-004
	,-1.632428364e-004
	,-1.499348354e-004
	,-1.371339098e-004
	,-1.249411127e-004
	,-1.134971619e-004
	,-1.027523342e-004
	,-9.239198974e-005
	,-8.214430397e-005
	,-7.228133441e-005
	,-6.321563508e-005
	,-5.506669797e-005
	,-4.768196717e-005
	,-4.089101284e-005
	,-3.477818380e-005
	,-2.937736555e-005
	,-2.457366604e-005
	,-2.021016941e-005
	,-1.627158957e-005
	,-1.289539406e-005
	,-1.008586602e-005
	,-7.738482518e-006
	,-5.741002322e-006
	,-4.017842058e-006
	,-2.516901961e-006
	,-1.190110241e-006
	,-6.474999561e-018
	,1.065080495e-006
	,1.993364083e-006
	,2.777338342e-006
	,3.468430848e-006
	,4.121948854e-006
	,4.774778051e-006
	,5.453063412e-006
	,6.176221098e-006
	,6.952949885e-006
	,7.770786050e-006
	,8.598281752e-006
	,9.416763824e-006
	,1.023646113e-005
	,1.106936853e-005
	,1.191561189e-005
	,1.278720778e-005
	,1.370774778e-005
	,1.469544773e-005
	,1.576024630e-005
	,1.690234268e-005
	,1.811064203e-005
	,1.936492755e-005
	,2.063128559e-005
	,2.188828028e-005
	,2.314812027e-005
	,2.440547105e-005
	,2.569332302e-005
	,2.701292317e-005
	,2.834852313e-005
	,2.969220597e-005
	,3.104244367e-005
	,3.239981895e-005
	,3.376463678e-005
	,3.513529775e-005
	,3.651081026e-005
	,3.789507063e-005
	,3.929837779e-005
	,4.073429467e-005
	,4.221429787e-005
	,4.374480710e-005
	,4.532961634e-005
	,4.697291027e-005
	,4.867755758e-005
	,5.044328678e-005
	,5.226641044e-005
	,5.414024583e-005
	,5.605663701e-005
	,5.800725442e-005
	,5.998334166e-005
	,6.198427438e-005
	,6.401461658e-005
	,6.607297631e-005
	,6.815432697e-005
	,7.025303730e-005
	,7.236350841e-005
	,7.447982070e-005
	,7.659662282e-005
	,7.871165109e-005
	,8.082799781e-005
	,8.295392084e-005
	,8.510032397e-005
	,8.727810844e-005
	,8.949678749e-005
	,9.176405240e-005
	,9.408562681e-005
	,9.646522023e-005
	,9.890454815e-005
	,1.014031785e-004
	,1.039580993e-004
	,1.065656486e-004
	,1.092247988e-004
	,1.119336276e-004
	,1.146874767e-004
	,1.174800530e-004
	,1.203048705e-004
	,1.231564103e-004
	,1.260302768e-004
	,1.289222855e-004
	,1.318273312e-004
	,1.347389341e-004
	,1.376485511e-004
	,1.405453848e-004
	,1.434175231e-004
	,1.462537776e-004
	,1.490452419e-004
	,1.517859969e-004
	,1.544733739e-004
	,1.571085202e-004
	,1.596972190e-004
	,1.622499471e-004
	,1.647785850e-004
	,1.672921621e-004
	,1.698123823e-004
	,1.723598175e-004
	,1.749512950e-004
	,1.776038936e-004
	,1.803359359e-004
	,1.831676480e-004
	,1.861219422e-004
	,1.892252045e-004
	,1.925081279e-004
	,1.960061827e-004
	,1.997598409e-004
	,2.038142565e-004
	,2.082187565e-004
	,2.130255932e-004
	,2.182880697e-004
	,2.240584063e-004
	,2.303853707e-004
	,2.373120945e-004
	,2.448745792e-004
	,2.531089441e-004
	,2.620510624e-004
	,2.717074847e-004
	,2.820977653e-004
	,2.932431407e-004
	,3.051660688e-004
	,3.178882040e-004
	,3.314284392e-004
	,3.458018718e-004
	,3.610196629e-004
	,3.770893783e-004
	,3.940154222e-004
	,4.117993904e-004
	,4.304403083e-004
	,4.499352173e-004
	,4.702803708e-004
	,4.914632784e-004
	,5.125783699e-004
	,5.345233219e-004
	,5.572510728e-004
	,5.807742294e-004
	,6.051139350e-004
	,6.302910690e-004
	,6.563206402e-004
	,6.832104675e-004
	,7.109620551e-004
	,7.395726636e-004
	,7.690365804e-004
	,7.993462045e-004
	,8.304925690e-004
	,8.624658573e-004
	,8.952556625e-004
	,9.288511454e-004
	,9.632401548e-004
	,9.950073928e-004
	,1.026668222e-003
	,1.058863025e-003
	,1.091596217e-003
	,1.124837820e-003
	,1.158578928e-003
	,1.192808563e-003
	,1.227515399e-003
	,1.262687639e-003
	,1.298468758e-003
	,1.334778113e-003
	,1.371534504e-003
	,1.408726426e-003
	,1.446341869e-003
	,1.484368219e-003
	,-4.866008496e-004
	,-4.674950280e-004
	,-4.485956122e-004
	,-4.299765117e-004
	,-4.116920408e-004
	,-3.937944735e-004
	,-3.763442800e-004
	,-3.593884812e-004
	,-3.429238022e-004
	,-3.268670650e-004
	,-3.110433600e-004
	,-2.954320742e-004
	,-2.800087532e-004
	,-2.646461667e-004
	,-2.492529534e-004
	,-2.339090016e-004
	,-2.187880065e-004
	,-2.040459020e-004
	,-1.897891406e-004
	,-1.760598837e-004
	,-1.628405766e-004
	,-1.501038598e-004
	,-1.378549313e-004
	,-1.261586397e-004
	,-1.151269905e-004
	,-1.048379455e-004
	,-9.529032028e-005
	,-8.637235118e-005
	,-7.781515250e-005
	,-6.920457644e-005
	,-6.034947998e-005
	,-5.150974391e-005
	,-4.308690904e-005
	,-3.528106891e-005
	,-2.821059732e-005
	,-2.195105835e-005
	,-1.647152571e-005
	,-1.165772342e-005
	,-7.381531147e-006
	,-3.530273975e-006
	,-7.310461474e-018
	,3.306882044e-006
	,6.470580531e-006
	,9.532647666e-006
	,1.251055226e-005
	,1.543843113e-005
	,1.827251217e-005
	,2.093805792e-005
	,2.354776125e-005
	,2.618045023e-005
	,2.884033124e-005
	,3.152137415e-005
	,3.422275390e-005
	,3.693299506e-005
	,3.966733559e-005
	,4.245105234e-005
	,4.524392233e-005
	,4.799450965e-005
	,5.067849664e-005
	,5.328094766e-005
	,5.587953812e-005
	,5.858299040e-005
	,6.143562619e-005
	,6.443975864e-005
	,6.757738957e-005
	,7.080564914e-005
	,7.401529598e-005
	,7.703944920e-005
	,7.986331363e-005
	,8.259401442e-005
	,8.524381084e-005
	,8.774895560e-005
	,9.004779596e-005
	,9.230934233e-005
	,9.459740431e-005
	,9.692054450e-005
	,9.929176597e-005
	,1.017310163e-004
	,1.042483029e-004
	,1.068403540e-004
	,1.095005760e-004
	,1.122255186e-004
	,1.150191000e-004
	,1.178855273e-004
	,1.208150174e-004
	,1.237761289e-004
	,1.267210374e-004
	,1.296048417e-004
	,1.324053209e-004
	,1.351263572e-004
	,1.377864212e-004
	,1.404041600e-004
	,1.429876526e-004
	,1.455388961e-004
	,1.480883623e-004
	,1.506721924e-004
	,1.533078887e-004
	,1.560022905e-004
	,1.587566364e-004
	,1.615676911e-004
	,1.644278212e-004
	,1.673262146e-004
	,1.702519557e-004
	,1.731962370e-004
	,1.761511226e-004
	,1.791067970e-004
	,1.820505769e-004
	,1.849691072e-004
	,1.878520596e-004
	,1.906931193e-004
	,1.934877309e-004
	,1.962319994e-004
	,1.989239629e-004
	,2.015639018e-004
	,2.041576271e-004
	,2.067200130e-004
	,2.092671166e-004
	,2.118129539e-004
	,2.143695032e-004
	,2.169467740e-004
	,2.195530777e-004
	,2.221949486e-004
	,2.248768721e-004
	,2.276018679e-004
	,2.303731124e-004
	,2.331938369e-004
	,2.360663682e-004
	,2.389921014e-004
	,2.419717676e-004
	,2.450056205e-004
	,2.480935264e-004
	,2.512349879e-004
	,2.544291259e-004
	,2.576746259e-004
	,2.609696204e-004
	,2.643113203e-004
	,2.676940084e-004
	,2.710975989e-004
	,2.745029480e-004
	,2.779283167e-004
	,2.813779282e-004
	,2.848491819e-004
	,2.883386151e-004
	,2.918429958e-004
	,2.953602125e-004
	,2.988900162e-004
	,3.024354753e-004
	,3.060038375e-004
	,3.096069346e-004
	,3.132630935e-004
	,3.169971790e-004
	,3.208426229e-004
	,3.248423176e-004
	,3.290490848e-004
	,3.335217561e-004
	,3.383263895e-004
	,3.435341901e-004
	,3.492164263e-004
	,3.554416815e-004
	,3.622758084e-004
	,3.697768619e-004
	,3.779962631e-004
	,3.869764827e-004
	,3.967532154e-004
	,4.073557609e-004
	,4.188081268e-004
	,4.311302451e-004
	,4.443391459e-004
	,4.584499945e-004
	,4.734769535e-004
	,4.894339043e-004
	,5.063350348e-004
	,5.241954142e-004
	,5.430338649e-004
	,5.624955702e-004
	,5.821671555e-004
	,6.027627619e-004
	,6.242771154e-004
	,6.467048150e-004
	,6.700405486e-004
	,6.942788154e-004
	,7.194136631e-004
	,7.454385070e-004
	,7.723458341e-004
	,8.001271765e-004
	,8.287729730e-004
	,8.582727604e-004
	,8.886147318e-004
	,9.197857794e-004
	,9.517715157e-004
	,9.845563185e-004
	,1.016350525e-003
	,1.046422712e-003
	,1.077007379e-003
	,1.108091219e-003
	,1.139830412e-003
	,1.172076315e-003
	,1.204817185e-003
	,1.238039615e-003
	,1.271732131e-003
	,1.305882930e-003
	,-5.675037600e-004
	,-5.486172621e-004
	,-5.296768666e-004
	,-5.107145662e-004
	,-4.918726196e-004
	,-4.732651597e-004
	,-4.549192515e-004
	,-4.368052926e-004
	,-4.189134561e-004
	,-4.012652383e-004
	,-3.839033477e-004
	,-3.669086761e-004
	,-3.503075778e-004
	,-3.339734838e-004
	,-3.176862618e-004
	,-3.013171864e-004
	,-2.848577116e-004
	,-2.683639017e-004
	,-2.519184116e-004
	,-2.356267354e-004
	,-2.195850411e-004
	,-2.038875210e-004
	,-1.887118379e-004
	,-1.741630091e-004
	,-1.602855453e-004
	,-1.470890564e-004
	,-1.345700147e-004
	,-1.227289266e-004
	,-1.115619044e-004
	,-1.010324031e-004
	,-9.100898640e-005
	,-8.113464936e-005
	,-7.095539613e-005
	,-6.056851104e-005
	,-5.034940412e-005
	,-4.059125938e-005
	,-3.147244595e-005
	,-2.295792596e-005
	,-1.493198824e-005
	,-7.292270786e-006
	,1.884993964e-017
	,6.930197592e-006
	,1.349973855e-005
	,1.973834981e-005
	,2.571914395e-005
	,3.151248884e-005
	,3.713389363e-005
	,4.263082062e-005
	,4.793244631e-005
	,5.274366879e-005
	,5.716863326e-005
	,6.151076963e-005
	,6.588172583e-005
	,7.030920538e-005
	,7.478797385e-005
	,7.930454758e-005
	,8.383154024e-005
	,8.831221713e-005
	,9.275990532e-005
	,9.723560924e-005
	,1.017625977e-004
	,1.063375544e-004
	,1.109450124e-004
	,1.155641541e-004
	,1.201752329e-004
	,1.247680685e-004
	,1.293440449e-004
	,1.339016847e-004
	,1.384150277e-004
	,1.428017088e-004
	,1.468911223e-004
	,1.506405919e-004
	,1.542435595e-004
	,1.577968896e-004
	,1.612737454e-004
	,1.646130595e-004
	,1.677666619e-004
	,1.705643435e-004
	,1.732370674e-004
	,1.759338741e-004
	,1.786626794e-004
	,1.814227918e-004
	,1.842196432e-004
	,1.870539371e-004
	,1.899171152e-004
	,1.927956559e-004
	,1.956772604e-004
	,1.985551902e-004
	,2.014275686e-004
	,2.042942335e-004
	,2.071580405e-004
	,2.100253576e-004
	,2.128987330e-004
	,2.157823458e-004
	,2.186827806e-004
	,2.215892829e-004
	,2.244689849e-004
	,2.273129417e-004
	,2.301600369e-004
	,2.330337527e-004
	,2.359398724e-004
	,2.388785005e-004
	,2.418481262e-004
	,2.448463475e-004
	,2.478703395e-004
	,2.509173474e-004
	,2.539846516e-004
	,2.570689986e-004
	,2.601663825e-004
	,2.632722360e-004
	,2.663817720e-004
	,2.694905226e-004
	,2.725951016e-004
	,2.756938884e-004
	,2.787871646e-004
	,2.818765378e-004
	,2.849632586e-004
	,2.880465622e-004
	,2.911321661e-004
	,2.942339702e-004
	,2.973614191e-004
	,3.005192772e-004
	,3.037108659e-004
	,3.069389677e-004
	,3.102052003e-004
	,3.135093940e-004
	,3.168494510e-004
	,3.202227840e-004
	,3.236287859e-004
	,3.270678259e-004
	,3.305394972e-004
	,3.340423846e-004
	,3.375740670e-004
	,3.411310641e-004
	,3.447086903e-004
	,3.483007695e-004
	,3.518992401e-004
	,3.554937671e-004
	,3.590716476e-004
	,3.626185776e-004
	,3.661211215e-004
	,3.695710253e-004
	,3.729654410e-004
	,3.762894418e-004
	,3.795687461e-004
	,3.828555101e-004
	,3.861746066e-004
	,3.895412324e-004
	,3.929659941e-004
	,3.964565168e-004
	,4.000188660e-004
	,4.036588888e-004
	,4.073833244e-004
	,4.112007023e-004
	,4.151221131e-004
	,4.191619146e-004
	,4.233383998e-004
	,4.276744154e-004
	,4.321978842e-004
	,4.369421604e-004
	,4.419461284e-004
	,4.472539574e-004
	,4.529144445e-004
	,4.589799280e-004
	,4.655048171e-004
	,4.725438576e-004
	,4.801503047e-004
	,4.883741598e-004
	,4.972606877e-004
	,5.068492352e-004
	,5.171723627e-004
	,5.282551583e-004
	,5.401145617e-004
	,5.527585216e-004
	,5.661851099e-004
	,5.803987569e-004
	,5.953997817e-004
	,6.111754400e-004
	,6.277139817e-004
	,6.450324022e-004
	,6.625889202e-004
	,6.803575187e-004
	,6.989145422e-004
	,7.183103633e-004
	,7.385899108e-004
	,7.597855219e-004
	,7.819178188e-004
	,8.049977507e-004
	,8.290111245e-004
	,8.538909035e-004
	,8.794643736e-004
	,9.054895137e-004
	,9.323209689e-004
	,9.598135342e-004
	,9.879965039e-004
	,1.016916915e-003
	,1.046595423e-003
	,1.075581887e-003
	,1.102892542e-003
	,1.130761613e-003
	,1.159138904e-003
	,-6.182879926e-004
	,-6.007829158e-004
	,-5.832459521e-004
	,-5.656408900e-004
	,-5.479985682e-004
	,-5.303297357e-004
	,-5.126625117e-004
	,-4.950671422e-004
	,-4.776095285e-004
	,-4.603011126e-004
	,-4.430818768e-004
	,-4.258107586e-004
	,-4.083440518e-004
	,-3.905354172e-004
	,-3.722785105e-004
	,-3.536780881e-004
	,-3.350047100e-004
	,-3.165010720e-004
	,-2.983136938e-004
	,-2.805170846e-004
	,-2.631530691e-004
	,-2.462429304e-004
	,-2.297905046e-004
	,-2.137978882e-004
	,-1.982892473e-004
	,-1.832998235e-004
	,-1.688488580e-004
	,-1.549342177e-004
	,-1.415033236e-004
	,-1.284016730e-004
	,-1.153767451e-004
	,-1.022573693e-004
	,-8.911816536e-005
	,-7.626472049e-005
	,-6.393903319e-005
	,-5.219640255e-005
	,-4.094804456e-005
	,-3.006113357e-005
	,-1.958700990e-005
	,-9.582504775e-006
	,-9.451332624e-018
	,9.219397285e-006
	,1.812546716e-005
	,2.678328465e-005
	,3.526685746e-005
	,4.363965254e-005
	,5.194273502e-005
	,6.018285699e-005
	,6.828845945e-005
	,7.602484262e-005
	,8.323698314e-005
	,9.011237920e-005
	,9.677785468e-005
	,1.032191923e-004
	,1.093811419e-004
	,1.152343604e-004
	,1.207566365e-004
	,1.260407426e-004
	,1.312863568e-004
	,1.366089182e-004
	,1.420413223e-004
	,1.475846264e-004
	,1.532297107e-004
	,1.589638130e-004
	,1.647716205e-004
	,1.706339232e-004
	,1.765246781e-004
	,1.824073227e-004
	,1.882365122e-004
	,1.939800352e-004
	,1.995828435e-004
	,2.048891885e-004
	,2.096602218e-004
	,2.138705210e-004
	,2.178552967e-004
	,2.218385096e-004
	,2.258652443e-004
	,2.299237723e-004
	,2.339877882e-004
	,2.380247052e-004
	,2.419749544e-004
	,2.455967220e-004
	,2.487195800e-004
	,2.517833047e-004
	,2.549044507e-004
	,2.580665607e-004
	,2.612495998e-004
	,2.644428147e-004
	,2.676427627e-004
	,2.708480734e-004
	,2.740560791e-004
	,2.772603815e-004
	,2.804451338e-004
	,2.835820234e-004
	,2.866693162e-004
	,2.897415619e-004
	,2.928176336e-004
	,2.958968316e-004
	,2.989610645e-004
	,3.019631594e-004
	,3.048655433e-004
	,3.077204721e-004
	,3.105788321e-004
	,3.134546172e-004
	,3.163485892e-004
	,3.192583854e-004
	,3.221809638e-004
	,3.251127249e-004
	,3.280515467e-004
	,3.309961476e-004
	,3.339447092e-004
	,3.368953028e-004
	,3.398453401e-004
	,3.427916303e-004
	,3.457356928e-004
	,3.486802644e-004
	,3.516253947e-004
	,3.545703415e-004
	,3.575138689e-004
	,3.604526109e-004
	,3.633779086e-004
	,3.662810345e-004
	,3.691710287e-004
	,3.720626053e-004
	,3.749625042e-004
	,3.778727839e-004
	,3.807940237e-004
	,3.837264042e-004
	,3.866694680e-004
	,3.896210122e-004
	,3.925773568e-004
	,3.955367722e-004
	,3.985023216e-004
	,4.014785337e-004
	,4.044689442e-004
	,4.074763461e-004
	,4.105029630e-004
	,4.135499177e-004
	,4.166171418e-004
	,4.197042028e-004
	,4.228109276e-004
	,4.259375226e-004
	,4.290845388e-004
	,4.322528170e-004
	,4.354433763e-004
	,4.386571709e-004
	,4.418946166e-004
	,4.451541193e-004
	,4.484230552e-004
	,4.516540768e-004
	,4.548570600e-004
	,4.580716497e-004
	,4.613052867e-004
	,4.645588679e-004
	,4.678327641e-004
	,4.711278113e-004
	,4.744456162e-004
	,4.777887796e-004
	,4.811611162e-004
	,4.845678223e-004
	,4.880155438e-004
	,4.915127340e-004
	,4.950703722e-004
	,4.987028548e-004
	,5.024287229e-004
	,5.062711199e-004
	,5.102581306e-004
	,5.144230429e-004
	,5.188045385e-004
	,5.234465843e-004
	,5.283978486e-004
	,5.337111370e-004
	,5.394422516e-004
	,5.456487153e-004
	,5.523882825e-004
	,5.597169065e-004
	,5.676874564e-004
	,5.763486377e-004
	,5.857449569e-004
	,5.959165490e-004
	,6.068991800e-004
	,6.187242650e-004
	,6.314185461e-004
	,6.450056101e-004
	,6.595069048e-004
	,6.749432075e-004
	,6.913367180e-004
	,7.078310167e-004
	,7.249734295e-004
	,7.430264471e-004
	,7.619873873e-004
	,7.818505454e-004
	,8.026086757e-004
	,8.242551579e-004
	,8.467831514e-004
	,8.701852226e-004
	,8.944545142e-004
	,9.195809291e-004
	,9.455527905e-004
	,9.723572062e-004
	,9.999789635e-004
	,-6.555386095e-004
	,-6.380666911e-004
	,-6.207078870e-004
	,-6.034282145e-004
	,-5.861686826e-004
	,-5.689671839e-004
	,-5.519401699e-004
	,-5.351677317e-004
	,-5.185934105e-004
	,-5.020278147e-004
	,-4.851692774e-004
	,-4.677549954e-004
	,-4.496782019e-004
	,-4.309792267e-004
	,-4.119018216e-004
	,-3.927448459e-004
	,-3.736883494e-004
	,-3.547792821e-004
	,-3.359916302e-004
	,-3.173466790e-004
	,-2.989293675e-004
	,-2.808232901e-004
	,-2.630931579e-004
	,-2.457701253e-004
	,-2.288525529e-004
	,-2.123184258e-004
	,-1.961388864e-004
	,-1.802660411e-004
	,-1.646150900e-004
	,-1.490554226e-004
	,-1.335295213e-004
	,-1.181977766e-004
	,-1.032770406e-004
	,-8.888497657e-005
	,-7.504385108e-005
	,-6.171492730e-005
	,-4.881398759e-005
	,-3.621013862e-005
	,-2.378736638e-005
	,-1.166191344e-005
	,1.461888597e-018
	,1.118900580e-005
	,2.196623434e-005
	,3.240967435e-005
	,4.259662807e-005
	,5.259475988e-005
	,6.244379728e-005
	,7.210509177e-005
	,8.139067971e-005
	,9.017046981e-005
	,9.862115494e-005
	,1.068921020e-004
	,1.150346389e-004
	,1.230705689e-004
	,1.310055752e-004
	,1.388315710e-004
	,1.465336779e-004
	,1.541098359e-004
	,1.615840111e-004
	,1.689890607e-004
	,1.763475159e-004
	,1.836670823e-004
	,1.909410808e-004
	,1.981475326e-004
	,2.052472337e-004
	,2.121883179e-004
	,2.189395364e-004
	,2.255436744e-004
	,2.320881716e-004
	,2.386231703e-004
	,2.451294383e-004
	,2.515096071e-004
	,2.576422396e-004
	,2.635228791e-004
	,2.692253272e-004
	,2.748002106e-004
	,2.802734873e-004
	,2.856597651e-004
	,2.909674945e-004
	,2.962006576e-004
	,3.013556967e-004
	,3.064043776e-004
	,3.113019219e-004
	,3.160511366e-004
	,3.205711520e-004
	,3.244867089e-004
	,3.276188062e-004
	,3.306523642e-004
	,3.337758617e-004
	,3.369813658e-004
	,3.402472011e-004
	,3.435558817e-004
	,3.468947072e-004
	,3.502549582e-004
	,3.536313517e-004
	,3.570211550e-004
	,3.604228007e-004
	,3.638346453e-004
	,3.672538428e-004
	,3.706742870e-004
	,3.740813537e-004
	,3.774409916e-004
	,3.807048529e-004
	,3.838735122e-004
	,3.869931476e-004
	,3.900934614e-004
	,3.931856576e-004
	,3.962734325e-004
	,3.993576960e-004
	,4.024380408e-004
	,4.055127625e-004
	,4.085776363e-004
	,4.116247061e-004
	,4.146515972e-004
	,4.176725656e-004
	,4.207009445e-004
	,4.237417632e-004
	,4.267963417e-004
	,4.298649691e-004
	,4.329477791e-004
	,4.360447037e-004
	,4.391544976e-004
	,4.422726954e-004
	,4.453876079e-004
	,4.484830070e-004
	,4.515582344e-004
	,4.546292967e-004
	,4.577080933e-004
	,4.607993780e-004
	,4.639047553e-004
	,4.670244365e-004
	,4.701572904e-004
	,4.732996613e-004
	,4.764437606e-004
	,4.795809400e-004
	,4.827119106e-004
	,4.858460037e-004
	,4.889908465e-004
	,4.921504942e-004
	,4.953275394e-004
	,4.985235263e-004
	,5.017381013e-004
	,5.049699586e-004
	,5.082182846e-004
	,5.114829685e-004
	,5.147644118e-004
	,5.180634173e-004
	,5.213811621e-004
	,5.247191753e-004
	,5.280792083e-004
	,5.314628985e-004
	,5.348712151e-004
	,5.383032945e-004
	,5.417506405e-004
	,5.451639989e-004
	,5.484828177e-004
	,5.517843090e-004
	,5.551047172e-004
	,5.584479330e-004
	,5.618134504e-004
	,5.652006212e-004
	,5.686092072e-004
	,5.720394729e-004
	,5.754922596e-004
	,5.789691041e-004
	,5.824724162e-004
	,5.860057237e-004
	,5.895739939e-004
	,5.931840111e-004
	,5.968446579e-004
	,6.005668663e-004
	,6.043635807e-004
	,6.082504855e-004
	,6.122472918e-004
	,6.163786262e-004
	,6.206745853e-004
	,6.251709574e-004
	,6.299092712e-004
	,6.349363276e-004
	,6.403036231e-004
	,6.460665819e-004
	,6.522826154e-004
	,6.590102155e-004
	,6.663073146e-004
	,6.742299757e-004
	,6.828315142e-004
	,6.921615775e-004
	,7.022642230e-004
	,7.131785301e-004
	,7.249379522e-004
	,7.375732176e-004
	,7.511128990e-004
	,7.655858259e-004
	,7.803920057e-004
	,7.956106200e-004
	,8.117387657e-004
	,8.287797957e-004
	,8.467337775e-004
	,8.655979918e-004
	,8.853692191e-004
	,9.060419525e-004
	,-6.906559874e-004
	,-6.726282647e-004
	,-6.545737657e-004
	,-6.364645148e-004
	,-6.183930488e-004
	,-6.004999706e-004
	,-5.828499810e-004
	,-5.653695172e-004
	,-5.478956888e-004
	,-5.302348350e-004
	,-5.122250837e-004
	,-4.938143213e-004
	,-4.750605480e-004
	,-4.561489731e-004
	,-4.372834076e-004
	,-4.185362197e-004
	,-3.998657399e-004
	,-3.812446801e-004
	,-3.627082047e-004
	,-3.443139712e-004
	,-3.261052977e-004
	,-3.080966302e-004
	,-2.902630395e-004
	,-2.725065910e-004
	,-2.546859068e-004
	,-2.368010144e-004
	,-2.189529419e-004
	,-2.011481058e-004
	,-1.833838171e-004
	,-1.657979517e-004
	,-1.485764875e-004
	,-1.318351620e-004
	,-1.156167155e-004
	,-9.991695042e-005
	,-8.470082333e-005
	,-6.990892381e-005
	,-5.545914049e-005
	,-4.124684619e-005
	,-2.719157336e-005
	,-1.339057744e-005
	,-1.556064785e-017
	,1.294542000e-005
	,2.548161704e-005
	,3.766331893e-005
	,4.953536134e-005
	,6.109645129e-005
	,7.227754332e-005
	,8.293607671e-005
	,9.301439178e-005
	,1.026868678e-004
	,1.121203591e-004
	,1.214073890e-004
	,1.306004636e-004
	,1.397311089e-004
	,1.488176559e-004
	,1.578684058e-004
	,1.668826170e-004
	,1.758503822e-004
	,1.847523231e-004
	,1.935602878e-004
	,2.022400085e-004
	,2.107569875e-004
	,2.190871699e-004
	,2.272263898e-004
	,2.351908368e-004
	,2.430099825e-004
	,2.507150113e-004
	,2.583291738e-004
	,2.658621743e-004
	,2.733028168e-004
	,2.806140405e-004
	,2.877670280e-004
	,2.947853042e-004
	,3.017049065e-004
	,3.085384432e-004
	,3.152831209e-004
	,3.219416798e-004
	,3.285356506e-004
	,3.350949214e-004
	,3.416420230e-004
	,3.481885118e-004
	,3.547374563e-004
	,3.612856261e-004
	,3.678239307e-004
	,3.743354206e-004
	,3.807872491e-004
	,3.870983727e-004
	,3.929830816e-004
	,3.977284846e-004
	,4.018303988e-004
	,4.060384098e-004
	,4.103789633e-004
	,4.147917604e-004
	,4.192261899e-004
	,4.236319783e-004
	,4.279417140e-004
	,4.321337024e-004
	,4.362541692e-004
	,4.403227747e-004
	,4.443352552e-004
	,4.482800100e-004
	,4.521522093e-004
	,4.559610525e-004
	,4.597152450e-004
	,4.634194501e-004
	,4.670803574e-004
	,4.707038099e-004
	,4.742936354e-004
	,4.778526613e-004
	,4.813834248e-004
	,4.848882799e-004
	,4.883692939e-004
	,4.918282257e-004
	,4.952665895e-004
	,4.986857316e-004
	,5.020868902e-004
	,5.054712364e-004
	,5.088399065e-004
	,5.121940321e-004
	,5.155347699e-004
	,5.188633103e-004
	,5.221808063e-004
	,5.254881603e-004
	,5.287856763e-004
	,5.320724994e-004
	,5.353454148e-004
	,5.385969745e-004
	,5.418185270e-004
	,5.450144359e-004
	,5.481997566e-004
	,5.513842630e-004
	,5.545713158e-004
	,5.577612384e-004
	,5.609540413e-004
	,5.641507076e-004
	,5.673495630e-004
	,5.705423351e-004
	,5.737123256e-004
	,5.768418613e-004
	,5.799273907e-004
	,5.829698453e-004
	,5.859977281e-004
	,5.890378040e-004
	,5.920955016e-004
	,5.951708945e-004
	,5.982627916e-004
	,6.013700159e-004
	,6.044917857e-004
	,6.076277244e-004
	,6.107777899e-004
	,6.139422152e-004
	,6.171214758e-004
	,6.203162770e-004
	,6.235275700e-004
	,6.267566652e-004
	,6.300055342e-004
	,6.332752851e-004
	,6.365634668e-004
	,6.398613622e-004
	,6.431255303e-004
	,6.462463373e-004
	,6.492894954e-004
	,6.523410418e-004
	,6.554148675e-004
	,6.585119118e-004
	,6.616320488e-004
	,6.647751941e-004
	,6.679400540e-004
	,6.711242477e-004
	,6.743259489e-004
	,6.775445553e-004
	,6.807805618e-004
	,6.840354089e-004
	,6.873114882e-004
	,6.906122673e-004
	,6.939425057e-004
	,6.973085394e-004
	,7.007186008e-004
	,7.041831396e-004
	,7.077151294e-004
	,7.113304735e-004
	,7.150486090e-004
	,7.188932629e-004
	,7.228932265e-004
	,7.270831158e-004
	,7.315035503e-004
	,7.361993269e-004
	,7.412185805e-004
	,7.466136264e-004
	,7.524401301e-004
	,7.587553206e-004
	,7.656163685e-004
	,7.730790253e-004
	,7.811963888e-004
	,7.900187695e-004
	,7.995913270e-004
	,8.099554826e-004
	,8.211490830e-004
	,8.332083938e-004
	,8.459121937e-004
	,8.586738854e-004
	,-7.217312585e-004
	,-7.027350797e-004
	,-6.836653948e-004
	,-6.646519858e-004
	,-6.458568621e-004
	,-6.273400406e-004
	,-6.089801129e-004
	,-5.905165654e-004
	,-5.717830507e-004
	,-5.527259653e-004
	,-5.333397182e-004
	,-5.136746474e-004
	,-4.939098791e-004
	,-4.742983789e-004
	,-4.550130762e-004
	,-4.361085967e-004
	,-4.175728089e-004
	,-3.993854954e-004
	,-3.815206291e-004
	,-3.639001265e-004
	,-3.463584696e-004
	,-3.286936828e-004
	,-3.107946942e-004
	,-2.926360193e-004
	,-2.742167487e-004
	,-2.555583377e-004
	,-2.367275487e-004
	,-2.178745128e-004
	,-1.991588171e-004
	,-1.806757772e-004
	,-1.625134659e-004
	,-1.447530111e-004
	,-1.274213593e-004
	,-1.105032722e-004
	,-9.395892844e-005
	,-7.773043634e-005
	,-6.173704941e-005
	,-4.588921198e-005
	,-3.021473249e-005
	,-1.488458278e-005
	,1.357455857e-018
	,1.443329346e-005
	,2.844701259e-005
	,4.207654057e-005
	,5.533165992e-005
	,6.815482070e-005
	,8.043334163e-005
